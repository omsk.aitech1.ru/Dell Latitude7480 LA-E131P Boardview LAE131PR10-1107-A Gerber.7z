# Allegro board LAE131PR10-1107-A.brd (continued)
## Nets (continued)
DDR_B_D30: JDIMM2.208 UC1.AR30
DDR_B_D31: JDIMM2.204 UC1.AP30
DDR_B_D32: JDIMM2.50 UC1.AY31
DDR_B_D33: JDIMM2.45 UC1.AW31
DDR_B_D34: JDIMM2.58 UC1.AY29
DDR_B_D35: JDIMM2.62 UC1.AW29
DDR_B_D36: JDIMM2.49 UC1.BB31
DDR_B_D37: JDIMM2.46 UC1.BA31
DDR_B_D38: JDIMM2.63 UC1.BA29
DDR_B_D39: JDIMM2.59 UC1.BB29
DDR_B_D40: JDIMM2.66 UC1.AY27
DDR_B_D41: JDIMM2.70 UC1.AW27
DDR_B_D42: JDIMM2.67 UC1.AY25
DDR_B_D43: JDIMM2.71 UC1.AW25
DDR_B_D44: JDIMM2.79 UC1.BB27
DDR_B_D45: JDIMM2.83 UC1.BA27
DDR_B_D46: JDIMM2.80 UC1.BA25
DDR_B_D47: JDIMM2.84 UC1.BB25
DDR_B_D48: JDIMM2.216 UC1.AU27
DDR_B_D49: JDIMM2.215 UC1.AT27
DDR_B_D50: JDIMM2.224 UC1.AT25
DDR_B_D51: JDIMM2.228 UC1.AU25
DDR_B_D52: JDIMM2.211 UC1.AP27
DDR_B_D53: JDIMM2.212 UC1.AN27
DDR_B_D54: JDIMM2.229 UC1.AN25
DDR_B_D55: JDIMM2.225 UC1.AP25
DDR_B_D56: JDIMM2.233 UC1.AT22
DDR_B_D57: JDIMM2.237 UC1.AU22
DDR_B_D58: JDIMM2.245 UC1.AU21
DDR_B_D59: JDIMM2.249 UC1.AT21
DDR_B_D60: JDIMM2.236 UC1.AN22
DDR_B_D61: JDIMM2.232 UC1.AP22
DDR_B_D62: JDIMM2.246 UC1.AP21
DDR_B_D63: JDIMM2.250 UC1.AN21
DDR_B_DQS0: JDIMM2.13 UC1.AY38
DDR_B_DQS1: JDIMM2.34 UC1.BA34
DDR_B_DQS2: JDIMM2.179 UC1.AR38
DDR_B_DQS3: JDIMM2.200 UC1.AR32
DDR_B_DQS4: JDIMM2.55 UC1.AY30
DDR_B_DQS5: JDIMM2.76 UC1.BA26
DDR_B_DQS6: JDIMM2.221 UC1.AR27
DDR_B_DQS7: JDIMM2.242 UC1.AR21
DDR_B_DQS#0: JDIMM2.11 UC1.BA38
DDR_B_DQS#1: JDIMM2.32 UC1.AY34
DDR_B_DQS#2: JDIMM2.177 UC1.AT38
DDR_B_DQS#3: JDIMM2.198 UC1.AT32
DDR_B_DQS#4: JDIMM2.53 UC1.BA30
DDR_B_DQS#5: JDIMM2.74 UC1.AY26
DDR_B_DQS#6: JDIMM2.219 UC1.AR25
DDR_B_DQS#7: JDIMM2.240 UC1.AR22
DDR_B_MA0: JDIMM2.144 UC1.BA46
DDR_B_MA1: JDIMM2.133 UC1.AY46
DDR_B_MA2: JDIMM2.132 UC1.AY47
DDR_B_MA3: JDIMM2.131 UC1.BB46
DDR_B_MA4: JDIMM2.128 UC1.BA47
DDR_B_MA5: JDIMM2.126 UC1.AY48
DDR_B_MA6: JDIMM2.127 UC1.BA48
DDR_B_MA7: JDIMM2.122 UC1.AP48
DDR_B_MA8: JDIMM2.125 UC1.BB48
DDR_B_MA9: JDIMM2.121 UC1.AP50
DDR_B_MA10: JDIMM2.146 UC1.AW46
DDR_B_MA11: JDIMM2.120 UC1.AN48
DDR_B_MA12: JDIMM2.119 UC1.AN50
DDR_B_MA13: JDIMM2.158 UC1.BA43
DDR_B_MA14: JDIMM2.151 UC1.AY44
DDR_B_MA15: JDIMM2.156 UC1.AY43
DDR_B_MA16: JDIMM2.152 UC1.AW44
DDR_B_ODT0: JDIMM2.155 UC1.BA42
DDR_B_ODT1: JDIMM2.161 UC1.AW42
DDR_B_PARITY: JDIMM2.143 UC1.AP43
DDR_DRAMRST#: RD11.2 RD12.2 UC1.AT13
DDR_DRAMRST#_R: CD29.1 CD61.1 JDIMM1.108 JDIMM2.108 RD12.1
DDR_VTT_CTRL: UC1.AW67 UD1.2
DDR_XDP_WAN_SMBCLK: JDIMM1.253 JDIMM2.253 JXDP1.53 QC2.1 RC319.1
DDR_XDP_WAN_SMBDAT: JDIMM1.254 JDIMM2.254 JXDP1.51 QC2.4 RC318.1
DEBUG_TX: JDEG1.9 RE30.2 RE74.2
DIMM1_SA0: JDIMM1.256 RD4.2 RD5.1
DIMM1_SA1: JDIMM1.260 RD6.2 RD7.1
DIMM1_SA2: JDIMM1.166 RD8.2 RD9.1
DIMM2_SA0: JDIMM2.256 RD20.2 RD21.1
DIMM2_SA1: JDIMM2.260 RD22.2 RD23.1
DIMM2_SA2: JDIMM2.166 RD24.2 RD25.1
DISP_ON: DV2.1 JEDP1.17 RV2.1
DMIC0: CA6.1 JEDP1.2 RA52.2 UA1.2
DMIC_CLK0: CA5.1 CA54.1 JEDP1.4 RA14.1
DMIC_CLK_CODEC: RA14.2 UA1.3
DPSNK0_DDC_CLK: RT14.1 RT126.1 RT341.2 UT1.Y5
DPSNK0_DDC_DATA: RT15.1 RT127.1 RT342.2 UT1.R4
DPSNK1_DDC_CLK: RT128.1 RT336.1 UT1.Y8
DPSNK_RBIAS: RT38.1 UT1.Y18
EC_FPM_EN: JUSH1.5 UE1.D6
EDP_AUXN: CV1.1 UC1.E45
EDP_AUXN_C: CV1.2 JEDP1.29
EDP_AUXP: CV2.1 UC1.F45
EDP_AUXP_C: CV2.2 JEDP1.30
EDP_BIA_PWM: DV1.3 UC1.R11
EDP_COMP: RC2.1 UC1.E52
EDP_HPD: JEDP1.21 RC1.1 RV7.1 UC1.L10
EDP_TXN0: CV4.1 UC1.C47
EDP_TXN0_C: CV4.2 JEDP1.32
EDP_TXN1: CV6.1 UC1.D46
EDP_TXN1_C: CV6.2 JEDP1.34
EDP_TXN2: CV8.1 UC1.A45
EDP_TXN2_C: CV8.2 JEDP1.36
EDP_TXN3: CV10.1 UC1.A47
EDP_TXN3_C: CV10.2 JEDP1.38
EDP_TXP0: CV3.1 UC1.C46
EDP_TXP0_C: CV3.2 JEDP1.31
EDP_TXP1: CV5.1 UC1.C45
EDP_TXP1_C: CV5.2 JEDP1.33
EDP_TXP2: CV7.1 UC1.B45
EDP_TXP2_C: CV7.2 JEDP1.35
EDP_TXP3: CV9.1 UC1.B47
EDP_TXP3_C: CV9.2 JEDP1.37
EDRAM_OPIO_RCOMP: RC90.1 UC1.H66
EMMC_RCOMP: RC4.1 UC1.AT1
EN_0.6V: PC222.1 PR210.2 PR212.1 PU200.2
EN_1.0V_PRIM_COREP: PC411.1 PR406.2 PR407.1 PU402.13
EN_1.2V: PC221.1 PR208.2 PR209.1 PU200.1
EN_1.8VALW: PC505.1 PR504.2 PR505.1 PU501.1
EN_1VS_VCCIO: PC402.1 PR402.2 PR403.1 PU401.13
EN_2.5V: PC513.1 PR513.2 PR514.1 PU503.5
EN_+1VALWP: PR302.1 PR312.1 PU301.1
EN_INVPWR: QV2.2 RE55.1 UE1.B2
EN_LCDPWR: DV3.1 RV3.2 UV24.4
EN_PD_HV_1: PQ1214.5 PR1210.1 PR1211.1 PR1250.2 PR1254.1 PR1260.1 RT70.1
EN_PD_HV_1#: PQ1214.2 PQ1214.3 PR1253.2
EN_PD_HV_1_R: RT70.2 UT5.C2
EN_VCC_EDRAM: PC1302.1 PR1301.2 PR1304.1 PR1325.2 PU1301.13
EN_VCC_EOPIO: PC1311.1 PR1315.2 PR1316.1 PR1326.2 PU1302.13
ENLDO_3V5V: PR102.1 PR103.1 PU100.11 PU102.11
ENVDD_PCH: DV3.3 UC1.U13 UE1.L12
EOPIO_RCOMP: RC91.1 UC1.H65
ESPI_ALERT#: RC21.1 UC1.AY11 UE1.H7
ESPI_CLK: RC16.1 UC1.AW9
ESPI_CLK_5105: CC316.1 JESPI.10 RC16.2 RE350.1 UE1.G7
ESPI_CS#: JESPI.7 UC1.BA12 UE1.H6
ESPI_IO0: JESPI.3 RC366.2 UE1.K5
ESPI_IO0_R: RC366.1 UC1.AY13
ESPI_IO1: JESPI.4 RC367.2 UE1.L4
ESPI_IO1_R: RC367.1 UC1.BA13
ESPI_IO2: JESPI.5 RC368.2 UE1.G6
ESPI_IO2_R: RC368.1 UC1.BB13
ESPI_IO3: JESPI.6 RC369.2 UE1.L5
ESPI_IO3_R: RC369.1 UC1.AY12
ESPI_RESET#: UC1.BA11 UE1.K6
EXPANDER_ALERT#: T267.1(TP-1) UE2.7
EXPANDER_GPU_SMCLK: RE525.1 UE1.M4 UE2.19
EXPANDER_GPU_SMDAT: RE524.1 UE1.M7 UE2.20
FAN1_PWM: JFAN1.2 RE48.2 UE1.L10
FAN1_TACH: JFAN1.3 RE51.2 UE1.E3
FB_1.8VALW: PC503.2 PR501.2 PR506.1 PU501.6
FB_+1VALWP: PR306.2 PR308.2 PR311.1 PU301.4
FB_IA: PR645.2 PR648.2 PR650.1 PU602.17
FB_VSA: PR646.1 PR649.1 PR652.1 PU602.25
FCCM_GT: PR664.2 PR671.2 PU602.11
FCCM_IA: PR659.2 PU602.21
FCCM_VSA: PR679.2 PU602.29
FIVR_EN: RC217.1 RC218.1 RC219.1
FIVR_EN_R: JXDP1.45 RC126.2 RC132.1 RC217.2
GPIO126: RE5.1 UE1.E12
GPP_B23: RC317.1 UC1.AM7
GPP_C5: RC25.1 UC1.W1
GPP_C8: RC405.1 UC1.AB1
GPP_E23: T120.1(TP-1) UC1.N12
GPU_B+: PC664.1 PC665.1 PC672.1 PC673.1 PC679.1 PC681.1 PC683.1 PC684.1 PC687.1 PC688.1 PJP602.1 PU612.5 PU613.5
GT1N: PL612.2 PR670.1 PR673.1
GT1P: PL612.3 PR674.2 PR675.1
GT2N: PL613.2 PR666.1 PR677.2
GT2P: PL613.3 PR667.2 PR668.1
GT_SNUB1: PC678.1 PR676.2
GT_SNUB2: PC670.1 PR669.2
GT_SW1: PL612.4 PR676.1 PU612.4
GT_SW2: PL613.4 PR669.1 PU613.4
H_CATERR#: RC79.1 UC1.D63
H_CPU_SVIDALRT#: RC153.1 UC1.B63
H_CPUPWRGD: CC300.1 RC77.2 UC1.A68
H_CPUPWRGD_R: RC77.1 T9.1(TP-1)
H_PROCHOT#: CC310.1 PC605.2 PR678.1 PR926.1 RC83.1 RC84.1 RE288.2
H_PROCHOT#_R: RC84.2 UC1.C65
H_PROCHOT#_R1: RE288.1 UE1.H13
H_THERMTRIP#: CC312.1 QE4.3 RC80.1 RD14.2 RD27.2 UC1.C63
H_VCCST_PWRGD_XDP: CC307.1 JXDP1.39 RC123.2 RC124.2
HDA_BIT_CLK: RC93.2 UC1.AY22
HDA_BIT_CLK_R: CC27.1 RA17.1 RC93.1 UA1.6
HDA_RST#: CC331.1 RC95.2 UC1.AW22
HDA_RST#_R: RA50.1 RC95.1
HDA_SDIN0: CC332.1 RA9.1 UC1.BA21
HDA_SDIN0_R: RA9.2 UA1.8
HDA_SDOUT: CC333.1 RC94.2 RC187.1 RC223.2 UC1.BB22
HDA_SDOUT_R: RC94.1 UA1.5
HDA_SYNC: RC92.2 UC1.BA22
HDA_SYNC_R: RC92.1 UA1.10
HDD_DET#: RPC4.3 UC1.H2
HDMI_CEC: JHDMI1.13 RV19.1
HDMI_CLKN: CV38.1 LV12.1 LV38.1 RV17.1
HDMI_CLKP: CV37.1 LV12.2 LV37.1 RV16.1
HDMI_CTRL_CLK: JHDMI1.15 QV3.6 RV22.1
HDMI_CTRL_DATA: JHDMI1.16 QV3.3 RV23.1
HDMI_HPD: JHDMI1.19 QV5.1 RV21.1
HDMI_L_CLKN: JHDMI1.12 LV12.4 LV38.2 RV35.1
HDMI_L_CLKP: JHDMI1.10 LV12.3 LV37.2 RV35.2
HDMI_L_TX_N0: JHDMI1.9 LV9.4 LV36.2 RV32.1
HDMI_L_TX_N1: JHDMI1.6 LV6.4 LV34.2 RV29.1
HDMI_L_TX_N2: JHDMI1.3 LV3.4 LV32.2 RV26.1
HDMI_L_TX_P0: JHDMI1.7 LV9.3 LV35.2 RV32.2
HDMI_L_TX_P1: JHDMI1.4 LV6.3 LV33.2 RV29.2
HDMI_L_TX_P2: JHDMI1.1 LV3.3 LV31.2 RV26.2
HDMI_OB: QV4.1 RV10.2 RV11.2 RV12.2 RV13.2 RV14.2 RV15.2 RV16.2 RV17.2
HDMI_TX_N0: CV36.2 LV9.1 LV36.1 RV15.1
HDMI_TX_N1: CV34.2 LV6.1 LV34.1 RV13.1
HDMI_TX_N2: CV32.2 LV3.1 LV32.1 RV11.1
HDMI_TX_P0: CV35.2 LV9.2 LV35.1 RV14.1
HDMI_TX_P1: CV33.2 LV6.2 LV33.1 RV12.1
HDMI_TX_P2: CV31.2 LV3.2 LV31.1 RV10.1
HOST_DEBUG_TX: JDEG1.8 RE73.2 RE306.2 RZ132.1 UE1.G11
HOST_SD_WP#: QR1.2 RC292.1 UC1.W10
HP_OUT_L: CA43.2 RA7.1 UA1.32
HP_OUT_R: CA44.2 RA8.1 UA1.33
HV_GATE1_A: RT64.1 UT5.B9
HV_GATE2_A: RT65.1 UT5.A9
HW_GPS_DISABLE#: DZ6.1 RE12.1 UE1.H5
HW_GPS_DISABLE#_R: DZ6.2 JNGFF2.18
I2C1_SCK_TP: RZ21.2 RZ29.1 UC1.U9
I2C1_SCK_TP_R: JKBTP1.2 RZ29.2 RZ117.2 RZ347.2
I2C1_SDA_TP: RZ20.2 RZ26.1 UC1.U8
I2C1_SDA_TP_R: JKBTP1.3 RZ26.2 RZ116.2 RZ346.2
I_ADP: PR935.2 UE1.B11
I_BATT: PR947.2 RE64.2
I_BATT_R: CE3.1 RE64.1 UE1.J4
I_SYS: PR620.1 PR936.2 RE312.2
I_SYS_R: CE4.1 RE312.1 RE313.1 UE1.J5
ILIM_SEL: RI13.1 UI3.4
ILMT_+1VALWP: PR307.2 PR310.1 PU301.3
ILMT_DDR: PR205.1 PR207.2 PU200.17
IMON_IA: PC625.2 PR629.2 PU602.14
IMON_VSA: PC643.1 PR651.1 PU602.23
IMVP_VR_ON: PR616.1 PR1325.1 PR1326.1 RE304.1 UE3.4 UE4.2
IMVP_VR_ON_EC: RE304.2 RPE10.2 UE1.N7 UE3.1
INT_SPK_L+: CA22.1 LA6.1 UA1.42
INT_SPK_L-: CA23.1 LA7.1 UA1.43
INT_SPK_R+: CA19.1 LA8.1 UA1.45
INT_SPK_R-: CA24.1 LA9.1 UA1.44
INT_SPKR_L+: DA6.2 JSPK1.4 LA6.2
INT_SPKR_L-: DA6.3 JSPK1.3 LA7.2
INT_SPKR_R+: DA7.2 JSPK1.2 LA8.2
INT_SPKR_R-: DA7.3 JSPK1.1 LA9.2
INTRUDER#: RC69.1 UC1.AP16
IR_CAM_DET#: JIR1.1 RC345.1 UC1.H5
ISEN1_GT: PC635.2 PR634.1 PR675.2 PR677.1 PU602.9
ISEN2_GT: PC638.2 PR615.1 PR668.2 PR670.2 PU602.10
ISH_I2C2_SCL: RC362.1 RZ76.1 UC1.AD12
ISH_I2C2_SCL_R: JNGFF2.32 RZ76.2
ISH_I2C2_SDA: RC363.1 RZ77.1 UC1.AD11
ISH_I2C2_SDA_R: JNGFF2.34 RZ77.2
ISH_UART0_CTS#: RZ80.1 UC1.U4
ISH_UART0_CTS#_R: JNGFF1.62 RZ80.2
ISH_UART0_RTS#: RZ81.1 UC1.U3
ISH_UART0_RTS#_R: JNGFF1.64 RZ81.2
ISH_UART0_RXD: RZ78.1 UC1.U1
ISH_UART0_RXD_R: JNGFF1.58 RZ78.2
ISH_UART0_TXD: RZ79.1 UC1.U2
ISH_UART0_TXD_R: JNGFF1.60 RZ79.2
ISUMN_GT: PC624.2 PC626.2 PC635.1 PC638.1 PC641.1 PH602.2 PR632.1 PR633.2 PR638.1 PR666.2 PR673.2
ISUMN_IA: PC642.2 PC645.1 PC646.2 PH605.2 PL610.2 PR640.2 PR644.2 PR656.2
ISUMN_VSA: PC633.2 PC637.2 PC644.1 PH604.2 PL614.2 PR636.2 PR641.2 PR643.1
ISUMP_GT: PC624.1 PC626.1 PR628.1 PR633.1 PR658.2 PR667.1 PR674.1 PU602.7
ISUMP_IA: PC642.1 PC646.1 PR653.2 PR656.1 PR657.1 PR661.2 PU602.19
ISUMP_VSA: PC633.1 PC637.1 PR624.2 PR642.1 PR643.2 PR654.2 PU602.27
ITP_PMODE: JXDP1.46 RC115.1 UC1.E8
JDIMM1_EVENT#: JDIMM1.134 RD14.1
JDIMM2_EVENT#: JDIMM2.134 RD27.1
JTAG_CLK: JDEG1.4 RPE7.3 UE1.C8
JTAG_RST#: CE30.1 JTAG1.1 RE63.1 RE65.1 UE1.G13
JTAG_TDI: JDEG1.2 RPE7.1 UE1.E9
JTAG_TDO: JDEG1.5 RPE7.4 UE1.F6
JTAG_TMS: JDEG1.3 RPE7.2 UE1.C5
KB_DET#: JKBTP1.20 RC288.1 UC1.D8
LAN_ACTLED_YEL#: QL1.6 RL14.1
LAN_ACTLED_YEL_R#: JLOM1.10 RL14.2
LAN_DISABLE#_R: RL5.1 RL7.2 RL9.1 UL1.3
LAN_MDIN0: RL72.1 UL1.14
LAN_MDIN0_L: RL72.2 TL1.2
LAN_MDIN1: RL74.1 UL1.18
LAN_MDIN1_L: RL74.2 TL1.6
LAN_MDIN2: RL76.1 UL1.21
LAN_MDIN2_L: RL76.2 TL1.8
LAN_MDIN3: RL78.1 UL1.24
LAN_MDIN3_L: RL78.2 TL1.12
LAN_MDIP0: RL71.1 UL1.13
LAN_MDIP0_L: RL71.2 TL1.1
LAN_MDIP1: RL73.1 UL1.17
LAN_MDIP1_L: RL73.2 TL1.5
LAN_MDIP2: RL75.1 UL1.20
LAN_MDIP2_L: RL75.2 TL1.7
LAN_MDIP3: RL77.1 UL1.23
LAN_MDIP3_L: RL77.2 TL1.11
LAN_TEST_EN: RL12.1 UL1.30
LAN_WAKE#: RC323.1 RL70.1 UC1.AM15 UE1.L3 UL1.2
LCD_CBL_DET#: JEDP1.40 RC287.1 UC1.AC3
LCD_TST: JEDP1.24 RE20.1 UE1.D1
LCD_VCC_TEST_EN: DV3.2 UE1.E1
LED_10_GRN#: QL2.6 RL19.1
LED_10_GRN_R#: JLOM1.11 RL19.2
LED_100_ORG#: QL1.3 RL20.1
LED_100_ORG_R#: JLOM1.13 RL20.2
LG1_ISL88738: PQ905.6 PU901.9
LG2_ISL88738: PQ904.6 PU901.7
LID_CL#: JLED1.5 RE26.1 UZ1.3 UZ10.2
LID_CL#_NB: CE8.1 RE25.2 RE26.2 UE1.N11
LID_CL#_PCH: T268.1(TP-1) UC1.AW7
LINE1_L: CA43.1 UA1.22
LINE1_R: CA44.1 UA1.21
LM393_P: PC949.2 PC1201.2 PD1801.1 PR950.2 PU903.5 PU1201.8
LOM_ACTLED_YEL#: QL1.1 UL1.26
LOM_CABLE_DETECT#: RE505.1 UE1.D2 UL2.4
LOM_SPD10LED_GRN#: QL2.1 RL30.2 UL1.25 UL2.2
LOM_SPD100LED_ORG#: QL1.4 RL29.2 UL1.27 UL2.1
LPM_ZVM_N: PR1303.1 PR1314.1 UC1.AR56
LPS_PROTECT#: PR1248.2 PT1.1(TP-1)
LPSS_UART2_RXD: JUART1.3 RC330.1 RC402.1 UC1.AD1
LPSS_UART2_TXD: JUART1.2 RC331.1 RC403.1 UC1.AD2
LX1_ISL88738: PC930.2 PL902.1 PQ905.7 PR923.1 PU901.10
LX2_ISL88738: PL902.2 PQ904.7 PR921.1 PR924.1 PU901.6
LX_1.8VALW: PL501.1 PR502.1 PU501.3
LX_1V_PRIM: PL404.1 PR409.1 PU402.2 PU402.3
LX_1VS_VCCIO: PL402.1 PR405.1 PU401.2 PU401.3
LX_3V: PC102.2 PL100.1 PR106.1 PU100.6 PU100.19 PU100.20
LX_5V: PC114.2 PL101.1 PR112.1 PU102.6 PU102.19 PU102.20
LX_DDR: PC205.2 PL201.1 PR202.1 PU200.11
LX_VCC_EDRAM: PL1301.1 PR1305.1 PU1301.2 PU1301.3
LX_VCC_EOPIO: PL1302.1 PR1319.1 PU1302.2 PU1302.3
M2280_DEVSLP: JNGFF3.38 RN37.2 UC1.J3
M2280_PCIE_SATA#: JNGFF3.69 RPC4.4 UC1.G4
M3042_DEVSLP: JNGFF2.30 UC1.J2
M3042_PCIE#_SATA: RC412.2 UC1.H3 UE1.J12
MASK_BASE_LEDS#: QZ7.5 UZ10.4
ME_FW_EC: RC221.1 SW1.1 UE1.G12
ME_FWP: RC221.2 RC223.1 SW1.3
ME_RESET#: RC225.1 RC227.1 UC12.2
ME_SUS_PWR_ACK: RC74.1 UC1.AR13 UE1.B13
MEC_XTAL1: CE28.1 UE1.A1 YE1.1
MEC_XTAL2: CE29.1 RE290.2 YE1.2
MEC_XTAL2_R: RE290.1 UE1.A3
MEDIACARD_IRQ#: RR19.1 UC1.AN8 UR1.32
MEM_INTERLEAVED: RC371.1 RC372.1 UC1.P2
MEM_SMBCLK: CC320.1 QC2.6 RC12.1 UC1.R7
MEM_SMBDATA: QC2.3 RC14.1 UC1.R8
MPHYP_PWR_EN: RC387.1 UC1.AM10
MSCLK: JDEG1.6 RE30.1 RE72.2 UE1.H10
MSDATA: JDEG1.7 RE75.2 RE86.1 UE1.G9
MSM_N: PR1317.1 PR1318.1 UC1.AP56
NB_PSID: PD4.2 PD4.3 PJPDC1.1 PL3.2
NRB_BIT: RC186.1 UC1.AR7
NTC_IA: PR635.2 PU602.15
NVME_LED#: JNGFF3.10 RN100.1
ONE_DIMM#: RC267.1 RC268.1 UC1.AP7
OTGEN/CMIN: PR919.2 PR960.2 PU901.20
PANEL_BKEN_EC: DV2.2 UE1.J9
PANEL_BKLEN: DV2.3 UC1.R12
PANEL_ID: CE47.1 RE300.1 UE1.J10
PBAT_CHARGER_SMBCLK: PD2.3 PR922.1 PRP1.3 RE43.1 UE1.N2
PBAT_CHARGER_SMBDAT: PD1.2 PR920.1 PRP1.2 RE37.1 UE1.M3
PBAT_PRES#: PD1.3 PR1.2 PR931.1 PRP1.1 UE1.F9
PBAT_PRES#_C: PBATT1.6 PRP1.8
PBAT_SMBCLK_C: PBATT1.4 PRP1.6
PBAT_SMBDAT_C: PBATT1.5 PRP1.7
PBATT+_C: PBATT1.1 PBATT1.2 PBATT1.3 PC1.1 PL1.1 PL2.1
PCH_ALW_ON: RPE10.3 RZ65.1 UE1.M8
PCH_BATLOW#: RC72.1 UC1.AU13
PCH_CL_CLK1: JNGFF1.42 UC1.G3
PCH_CL_DATA1: JNGFF1.40 UC1.G2
PCH_CL_RST1#: JNGFF1.38 UC1.G1
PCH_DPWROK: CC266.1 RC215.1 RC220.1 RE536.2 UC1.BB20 UE7.1
PCH_DPWROK_EC: RE34.1 UE1.F8
PCH_JTAG_TCK: JXDP1.55 RC86.1 UC1.B56
PCH_JTAG_TDI: CC304.1 RC81.1 RC229.2 UC1.D59
PCH_JTAG_TDO: CC303.1 RC82.1 RC230.2 UC1.A56
PCH_JTAG_TMS: RC130.1 RC228.2 UC1.C59
PCH_PCIE_WAKE#: RC67.1 RE274.2 UC1.BB15 UE1.L1
PCH_PLTRST#: RC60.1 RC62.1 RC244.1 UC1.AN10 UC7.1 UC7.2
PCH_PLTRST#_5105: RE340.1 UE1.K1 UE6.4
PCH_PLTRST#_AND: CZ61.1 JNGFF1.52 JNGFF1.66 JNGFF2.42 JNGFF3.50 RC65.1 RC325.1 RZ114.1 UC7.4 UR1.1 UT1.L4
PCH_PLTRST#_EC: RC244.2 RE375.2 UE6.2
PCH_POPIRCOMP: RC89.1 UC1.AU16
PCH_PWROK: PR614.1 RC411.1 UC1.BA20
PCH_RSMRST#: RE342.1 RE363.2 RE364.2 UZ6.1
PCH_RSMRST#_AND: RC75.1 RC124.1 RC215.2 UC1.AY17 UZ6.4
PCH_RSMRST#_GPIO204: RE363.1 UE1.H2
PCH_RTCRST#: CC25.1 CMOS1.1 JAPS1.9 RC57.1 RE94.2 UC1.AM16
PCH_RTCX1: CC23.1 RC54.2 UC1.AM18 YC2.1
PCH_RTCX2: RC54.1 RC296.1 UC1.AM20
PCH_RTCX2_R: CC26.1 RC296.2 YC2.2
PCH_SMB_ALERT#: RC23.1 UC1.R10
PCH_SPI_CLK: JSPI1.13 RC35.1 UC1.AV2
PCH_SPI_CLK_0_R: RC29.1 RPC1.6 UC5.6
PCH_SPI_CLK_1_R: RC28.1 RC408.2 UC6.6
PCH_SPI_CLK_2_R: RZ60.2 RZ63.2 UZ12.19
PCH_SPI_CLK_R1: JSPI1.14 RC35.2 RC408.1 RPC1.3 RZ60.1
PCH_SPI_CS#0: JSPI1.11 RC36.1 UC1.AU3
PCH_SPI_CS#0_R1: JSPI1.12 RC36.2 RC37.1
PCH_SPI_CS#0_R2: RC37.2 UC5.1
PCH_SPI_CS#1: JSPI1.19 RC32.2 UC1.AU2
PCH_SPI_CS#1_R1: JSPI1.20 RC32.1 RC42.1
PCH_SPI_CS#1_R2: RC42.2 UC6.1
PCH_SPI_CS#2: RZ61.1 UC1.AU1
PCH_SPI_CS#2_R: RZ61.2 RZ113.1 UZ12.20
PCH_SPI_D0: JSPI1.17 RC10.2 RC33.1 UC1.AV3
PCH_SPI_D0_0_R: RPC1.7 UC5.5
PCH_SPI_D0_1_R: RC409.2 UC6.5
PCH_SPI_D0_2_R: RZ59.2 UZ12.21
PCH_SPI_D0_R1: JSPI1.18 RC33.2 RC409.1 RPC1.2 RZ59.1
PCH_SPI_D1: JSPI1.15 RC34.1 UC1.AW3
PCH_SPI_D1_0_R: RPC1.8 UC5.2
PCH_SPI_D1_1_R: RC410.2 UC6.2
PCH_SPI_D1_2_R: RZ58.2 UZ12.24
PCH_SPI_D1_R1: JSPI1.16 RC34.2 RC410.1 RPC1.1 RZ58.1
PCH_SPI_D2: JSPI1.9 RC11.2 RC38.1 UC1.AW2
PCH_SPI_D2_0_R: RC39.2 UC5.3
PCH_SPI_D2_1_R: RC43.2 UC6.3
PCH_SPI_D2_R1: JSPI1.10 RC30.1 RC38.2 RC39.1 RC43.1
PCH_SPI_D3: JSPI1.7 RC40.1 UC1.AU4
PCH_SPI_D3_0_R: RPC1.5 UC5.7
PCH_SPI_D3_1_R: RC407.2 UC6.7
PCH_SPI_D3_R1: JSPI1.8 RC31.1 RC40.2 RC316.1 RC407.1 RPC1.4
PCH_SPI_DO2_XDP: JXDP1.60 RC11.1
PCH_SPI_DO_XDP: RC10.1 RC128.1 RC133.1
PCI_CLK_LPC1: RC22.1 UC1.AY9
PCIE_PRX_C_DTX_N1: CR14.2 UR1.8
PCIE_PRX_C_DTX_N5: CT130.1 UT1.F22
PCIE_PRX_C_DTX_N6: CT128.1 UT1.K22
PCIE_PRX_C_DTX_N7: CT9.1 UT1.P22
PCIE_PRX_C_DTX_N8: CT7.1 UT1.V22
PCIE_PRX_C_DTX_N9: CL2.2 UL1.39
PCIE_PRX_C_DTX_P1: CR13.2 UR1.7
PCIE_PRX_C_DTX_P5: CT129.1 UT1.F23
PCIE_PRX_C_DTX_P6: CT127.1 UT1.K23
PCIE_PRX_C_DTX_P7: CT8.1 UT1.P23
PCIE_PRX_C_DTX_P8: CT6.1 UT1.V23
PCIE_PRX_C_DTX_P9: CL1.2 UL1.38
PCIE_PRX_DTX_N1: CR14.1 UC1.H13
PCIE_PRX_DTX_N3: JNGFF1.43 UC1.H16
PCIE_PRX_DTX_N4: JNGFF1.67 UC1.G15
PCIE_PRX_DTX_N5: CT130.2 UC1.F16
PCIE_PRX_DTX_N6: CT128.2 UC1.G18
PCIE_PRX_DTX_N7: CT9.2 UC1.F20
PCIE_PRX_DTX_N8: CT7.2 UC1.G21
PCIE_PRX_DTX_N9: CL2.1 UC1.E22
PCIE_PRX_DTX_N11: JNGFF3.29 UC1.E28
PCIE_PRX_DTX_N12: JNGFF3.43 UC1.E30
PCIE_PRX_DTX_P1: CR13.1 UC1.G13
PCIE_PRX_DTX_P3: JNGFF1.41 UC1.G16
PCIE_PRX_DTX_P4: JNGFF1.65 UC1.F15
PCIE_PRX_DTX_P5: CT129.2 UC1.E16
PCIE_PRX_DTX_P6: CT127.2 UC1.F18
PCIE_PRX_DTX_P7: CT8.2 UC1.E20
PCIE_PRX_DTX_P8: CT6.2 UC1.F21
PCIE_PRX_DTX_P9: CL1.1 UC1.E23
PCIE_PRX_DTX_P11: JNGFF3.31 UC1.E27
PCIE_PRX_DTX_P12: JNGFF3.41 UC1.F30
PCIE_PTX_C_DRX_N1: CR12.2 UR1.4
PCIE_PTX_C_DRX_N3: CZ13.2 JNGFF1.37
PCIE_PTX_C_DRX_N4: CZ15.2 JNGFF1.61
PCIE_PTX_C_DRX_N5: CT126.2 UT1.H22
PCIE_PTX_C_DRX_N6: CT124.2 UT1.M22
PCIE_PTX_C_DRX_N7: CT5.2 UT1.T22
PCIE_PTX_C_DRX_N8: CT3.2 UT1.Y22
PCIE_PTX_C_DRX_N9: CL6.2 UL1.42
PCIE_PTX_C_DRX_N11: CN69.1 JNGFF3.35
PCIE_PTX_C_DRX_N12: CN71.1 JNGFF3.47
PCIE_PTX_C_DRX_P1: CR11.2 UR1.3
PCIE_PTX_C_DRX_P3: CZ12.2 JNGFF1.35
PCIE_PTX_C_DRX_P4: CZ14.2 JNGFF1.59
PCIE_PTX_C_DRX_P5: CT125.2 UT1.H23
PCIE_PTX_C_DRX_P6: CT123.2 UT1.M23
PCIE_PTX_C_DRX_P7: CT4.2 UT1.T23
PCIE_PTX_C_DRX_P8: CT2.2 UT1.Y23
PCIE_PTX_C_DRX_P9: CL5.2 UL1.41
PCIE_PTX_C_DRX_P11: CN70.1 JNGFF3.37
PCIE_PTX_C_DRX_P12: CN72.1 JNGFF3.49
PCIE_PTX_DRX_N1: CR12.1 UC1.B17
PCIE_PTX_DRX_N3: CZ13.1 UC1.D17
PCIE_PTX_DRX_N4: CZ15.1 UC1.B19
PCIE_PTX_DRX_N5: CT126.1 UC1.C19
PCIE_PTX_DRX_N6: CT124.1 UC1.D20
PCIE_PTX_DRX_N7: CT5.1 UC1.B21
PCIE_PTX_DRX_N8: CT3.1 UC1.D21
PCIE_PTX_DRX_N9: CL6.1 UC1.B23
PCIE_PTX_DRX_N11: CN69.2 UC1.D24
PCIE_PTX_DRX_N12: CN71.2 UC1.A25
PCIE_PTX_DRX_P1: CR11.1 UC1.A17
PCIE_PTX_DRX_P3: CZ12.1 UC1.C17
PCIE_PTX_DRX_P4: CZ14.1 UC1.A19
PCIE_PTX_DRX_P5: CT125.1 UC1.D19
PCIE_PTX_DRX_P6: CT123.1 UC1.C20
PCIE_PTX_DRX_P7: CT4.1 UC1.A21
PCIE_PTX_DRX_P8: CT2.1 UC1.C21
PCIE_PTX_DRX_P9: CL5.1 UC1.A23
PCIE_PTX_DRX_P11: CN70.2 UC1.C24
PCIE_PTX_DRX_P12: CN72.2 UC1.B25
PCIE_RCOMPN: RC45.1 UC1.F5
PCIE_RCOMPP: RC45.2 UC1.E5
PCIE_WAKE#: JNGFF1.55 JNGFF1.70 JNGFF2.46 JNGFF3.54 RE274.1 RE275.2 UT1.W1
PCIE_WAKE#_R: RE35.1 RE275.1 UE1.N13
PD1_GPIO0: RT69.1 UT5.B2
PD1_GPIO2: RT71.1 UT5.D10
PD1_GPIO5: RT74.1 UT5.E10
PD1_GPIO6: RT75.1 UT5.G10
PD1_GPIO7: RT339.1 UT5.D7
PD1_GPIO8: RT76.1 RT377.1 UT5.H6
PD#: CA31.1 DA8.2 RA18.1 RA48.2 RA50.2 UA1.47
PECI_EC: RE60.2 UC1.A54
PECI_EC_R: RE60.1 UE1.K13
PGOOD_3V: PR107.2 PR119.1 PU100.9
PGOOD_5V: PR113.2 PR120.1 PU102.9
PLTRST_LAN#: RC62.2 UL1.36
PLTRST_TPM#: RC60.2 RC325.2 UZ12.17
PM_LANPHY_ENABLE: RL7.1 UC1.AW17
PME#: T115.1(TP-1) UC1.AU11
POA_WAKE#: JUSH1.4 RE324.1 UE1.E4
PORT80_DET#: RE512.1 RE513.1 RZ131.1 UE1.K4
POWER_SW#_MB: CE10.1 JAPS1.11 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE1.D5
PRIM_PWRGD_GPIO024: RE361.1 RE362.1 UE1.C1
PROCHOT#_ISL88738: PQ1216.1 PR926.2 PU901.23
PS_ID: PR4.1 PR5.2 UE1.L11
PWM1_GT: PR680.1 PU602.12 PU612.8
PWM2_GT: PR681.1 PU602.13 PU613.8
PWM_IA: PR662.1 PU602.22 PU610.8
PWM_SA: PR606.1 PU614.3
PWM_VSA: PR606.2 PU602.30
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE1.A8
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE1.A7
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE1.A10
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE1.A9
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE1.A11
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE1.B10
RES_BIAS: RL13.1 UL1.12
RESET_OUT#_R: CC33.1 JXDP1.47 RC128.2 RC129.2
RING2: LA10.1 RA5.2 UA1.17
RING2_R: CA4.1 CA13.2 DA3.3 JHP1.4 LA10.2
RJ45_MDIN0: JLOM1.2 TL1.23
RJ45_MDIN1: JLOM1.6 TL1.19
RJ45_MDIN2: JLOM1.5 TL1.17
RJ45_MDIN3: JLOM1.8 TL1.13
RJ45_MDIP0: JLOM1.1 TL1.24
RJ45_MDIP1: JLOM1.3 TL1.20
RJ45_MDIP2: JLOM1.4 TL1.18
RJ45_MDIP3: JLOM1.7 TL1.14
RTCRST_ON: QE12.2 RE93.1 RE514.2 RE515.2
RTCRST_ON_GPIO122: RE515.1 UE1.F11
RTCRST_ON_GPIO141: RE514.1 UE1.B6
RTD3_CIO_PWR_EN: RT25.1 RT372.1 RT392.2 UC1.AC2
RTD3_CIO_PWR_EN_R: RT392.1 UT1.F1
RTD3_USB_PWR_EN: RT26.1 UT1.D4
RUN_ON: PR402.1 PR1301.1 QE2.2 RE280.2 RE292.1 RZ320.1 RZ345.1 UE5.4 UZ3.5 UZ4.3 UZ35.2
RUN_ON#: QE2.5 QE2.6 RE68.1
RUN_ON_EC: RE292.2 RPE10.4 UE1.E8 UE5.2
RUNPWROK: QE2.3 RE67.1 UC8.1 UC8.4 UC8.10 UC8.13 UE1.G3
SA_SNUB: PC622.1 PR627.2
SA_SW: PL614.4 PQ501.9 PR619.2 PR627.1 PU614.8
SATA_LED_EN: QZ2.5 UE2.14
SATALED#: QZ2.4 RN100.2 RPC4.1 UC1.H1
SBIOS_TX: RE306.1 UC1.AB2
SD/MMCCD#: JSD1.9 UR1.30
SD/MMCCLK: RR5.1 UR1.17
SD/MMCCLK_R: CR21.1 JSD1.5 RR5.2
SD/MMCCMD: RR6.1 UR1.19
SD/MMCCMD_R: JSD1.3 RR6.2
SD/MMCDAT0/RCLK+: RR10.1 UR1.16
SD/MMCDAT0/RCLK+_R: JSD1.7 RR10.2
SD/MMCDAT1/RCLK-: RR9.1 UR1.15
SD/MMCDAT1/RCLK-_R: JSD1.8 RR9.2
SD/MMCDAT2: RR8.1 UR1.21
SD/MMCDAT2_R: JSD1.1 RR8.2
SD/MMCDAT3: RR7.1 UR1.20
SD/MMCDAT3_R: JSD1.2 RR7.2
SD_GPIO: RR3.2 UR1.28
SD_RCOMP: RC96.1 UC1.AB7
SD_UHS2_D0N: JSD1.19 UR1.25
SD_UHS2_D0P: JSD1.18 UR1.26
SD_UHS2_D1N: JSD1.21 UR1.23
SD_UHS2_D1P: JSD1.22 UR1.22
SDWP: QR1.1 UR1.29
SHD_CLK: RE374.1 UE1.J8
SHD_CLK_R1: RE374.2 UE9.6
SHD_CS#: RE98.1 RE364.1 UE1.M5 UE9.1
SHD_IO0: CE503.1 QE13.5 RE366.1 RE530.1 UE1.J7
SHD_IO0_R1: RE366.2 RE367.1
SHD_IO0_R2: RE367.2 UE9.5
SHD_IO1: RE368.1 UE1.L6
SHD_IO1_R1: RE368.2 RE369.1
SHD_IO1_R2: RE369.2 UE9.2
SHD_IO2: RE360.1 RE370.1 UE1.L7
SHD_IO2_R1: RE370.2 RE371.1 RE376.1
SHD_IO2_R2: RE371.2 UE9.3
SHD_IO3: RE372.1 UE1.M6
SHD_IO3_R1: RE372.2 RE373.1 RE377.1
SHD_IO3_R2: RE373.2 UE9.7
SIM_DET: JNGFF2.58 JSIM1.2
SIO_EXT_SCI#: RC237.1 RE341.1 UC1.AN7
SIO_EXT_SCI#_EC: RE341.2 UE1.M1
SIO_EXT_SMI#: RC346.1 RE338.1 UC1.A6
SIO_EXT_SMI#_EC: RE338.2 UE1.K7
SIO_EXT_WAKE#: RC283.1 UC1.AC1 UE1.M12
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.1 UC1.BA15 UE1.K11
SIO_RCIN#: RC13.1 RE339.1 UC1.AW13
SIO_RCIN#_EC: RE339.2 UE1.N3
SIO_SLP_A#: JAPS1.6 UC1.AN16 UE1.M11
SIO_SLP_LAN#: RC68.1 RC344.1 UC1.AW15 UE1.H9 UZ2.5
SIO_SLP_S0#: JAPS1.15 PR425.1 PR426.1 RZ112.1 RZ363.1 UC1.AT11 UZ35.1
SIO_SLP_S3#: JAPS1.2 QE11.2 RE280.1 UC1.AP15 UE1.K9 UE3.2 UE5.1 UT1.D2
SIO_SLP_S4#: JAPS1.5 PR208.1 PR513.1 UC1.BA16 UE1.N12 UZ21.4 UZ34.2
SIO_SLP_S5#: JAPS1.4 UC1.AY16 UE1.N8
SIO_SLP_SUS#: PR312.2 PR406.1 PR504.1 PR1315.1 RE349.1 RZ64.1 UC1.AN15 UZ34.1
SIO_SLP_WLAN#: RZ71.1 UC1.BB17 UE1.D9
SLEEVE: LA11.1 RA6.2 UA1.18
SLEEVE_R: CA1.2 CA12.1 DA3.2 JHP1.3 LA11.2
SLOT2_CONFIG_0: JNGFF2.13 RPE9.1 UE1.N9
SLOT2_CONFIG_1: JNGFF2.61 RPE9.2 UE1.M10
SLOT2_CONFIG_2: JNGFF2.67 RPE9.3 UE1.N10
SLOT2_CONFIG_3: JNGFF2.1 RPE9.4 UE1.F4
SM_RCOMP0: RC5.1 UC1.AR18
SM_RCOMP1: RC6.1 UC1.AT18
SM_RCOMP2: RC7.1 UC1.AU18
SML0_SMBCLK: CC318.1 RC19.1 RC347.1 UC1.R9 UL1.28
SML0_SMBDATA: RC20.1 RC348.1 UC1.W2 UL1.31
SML1_SMBCLK: CC319.1 RC15.1 UC1.W3 UE1.D8
SML1_SMBDATA: RC17.1 UC1.V3 UE1.E11
SNB_+1VALWP: PC302.1 PR303.2
SNK0_CONFIG1: RT129.1 RT337.1 UT1.N4
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_1V_PRIM: PC419.1 PR409.2
SNUB_1VS_VCCIO: PC401.1 PR405.2
SNUB_CHG1: PC940.1 PR923.2
SNUB_CHG2: PC941.1 PR924.2
SNUB_VCC_EDRAM: PC1309.1 PR1305.2
SNUB_VCC_EOPIO: PC1319.1 PR1319.2
SPKR: RA12.2 RC183.1 UC1.AW5
SPKR_R: CA27.1 CA72.1 RA12.1 RA51.1
SRTCRST#: CC24.1 RC56.1 UC1.AN18
SS_1V_PRIM: PC420.1 PR428.1 PU402.7
SS_1VS_VCCIO: PC410.1 PR427.1 PU401.7
SS_VCC_EDRAM: PC1310.1 PU1301.7
SS_VCC_EOPIO: PC1320.1 PU1302.7
SUSACK#: UC1.AP11 UE1.K12
SUSCLK: RC48.1 RN99.2 RZ56.2 UC1.BA17
SUSCLK_R: JNGFF3.68 RN99.1
SW2_DP1_AUXN: CT175.1 RV70.1 UV7.29
SW2_DP1_AUXN_C: CT175.2 UT1.W12
SW2_DP1_AUXP: CT169.1 RV76.1 UV7.28
SW2_DP1_AUXP_C: CT169.2 UT1.Y12
SW2_DP1_CADET: RV73.1 UV7.33
SW2_DP1_HPD: RT29.1 UT1.Y6 UV7.38
SW2_DP1_N0: CT176.1 UV7.39
SW2_DP1_N0_C: CT176.2 UT1.AC15
SW2_DP1_N1: CT171.1 UV7.36
SW2_DP1_N1_C: CT171.2 UT1.AC17
SW2_DP1_N2: CT168.1 UV7.34
SW2_DP1_N2_C: CT168.2 UT1.AC19
SW2_DP1_N3: CT170.1 UV7.31
SW2_DP1_N3_C: CT170.2 UT1.AC21
SW2_DP1_P0: CT177.1 UV7.40
SW2_DP1_P0_C: CT177.2 UT1.AB15
SW2_DP1_P1: CT172.1 UV7.37
SW2_DP1_P1_C: CT172.2 UT1.AB17
SW2_DP1_P2: CT174.1 UV7.35
SW2_DP1_P2_C: CT174.2 UT1.AB19
SW2_DP1_P3: CT173.1 UV7.32
SW2_DP1_P3_C: CT173.2 UT1.AB21
SW2_DP2_AUXN: CV150.1 RV71.1 UV7.27
SW2_DP2_AUXN_C: CV150.2 JNGFF1.20
SW2_DP2_AUXP: CV149.1 RV77.1 UV7.26
SW2_DP2_AUXP_C: CV149.2 JNGFF1.22
SW2_DP2_CADET: RV74.1 UV7.43
SW2_DP2_HPD: JNGFF1.31 UV7.48
SW2_DP2_N0: CV156.1 UV7.49
SW2_DP2_N0_C: CV156.2 JNGFF1.32
SW2_DP2_N1: CV152.1 UV7.46
SW2_DP2_N1_C: CV152.2 JNGFF1.26
SW2_DP2_N2: CV148.1 UV7.44
SW2_DP2_N2_C: CV148.2 JNGFF1.25
SW2_DP2_N3: CV145.1 UV7.41
SW2_DP2_N3_C: CV145.2 JNGFF1.19
SW2_DP2_P0: CV157.1 UV7.50
SW2_DP2_P0_C: CV157.2 JNGFF1.34
SW2_DP2_P1: CV153.1 UV7.47
SW2_DP2_P1_C: CV153.2 JNGFF1.28
SW2_DP2_P2: CV147.1 UV7.45
SW2_DP2_P2_C: CV147.2 JNGFF1.27
SW2_DP2_P3: CV146.1 UV7.42
SW2_DP2_P3_C: CV146.2 JNGFF1.21
SW2_PS8338_CFG0: RV85.1 UV7.59
SW2_PS8338_P0: RV95.1 UV7.60
SW2_PS8338_P1: RV93.1 RV94.1 UV7.1
SW2_PS8338_PC10: RV90.1 RV91.1 UV7.56
SW2_PS8338_PC11: RV83.1 RV84.1 UV7.55
SW2_PS8338_PC20: RV81.1 RV82.1 UV7.54
SW2_PS8338_PC21: RV79.1 RV80.1 UV7.53
SW2_PS8338_PEQ: RV87.1 RV88.1 UV7.8
SW2_PS8338_SW: RV89.1 UV7.18
SW_+1VALWP: PL301.1 PR303.1 PR304.2 PU301.10
SW_USB20_N1: LI7.1 UI3.11
SW_USB20_P1: LI7.4 UI3.10
SYS_LED_MASK#: QL1.2 QL1.5 QL2.2 RE21.1 UE1.A12 UZ10.1
SYS_PWROK: RC129.1 RE56.1 UC1.B6 UE1.G4
SYS_RESET#: CC302.1 JAPS1.13 RC224.2 RC291.1 UC1.B5
SYS_RESET#_R: RC224.1 RC290.2 UC12.4
TBT_CIO_PLUG_EVENT#: RT371.1 RT391.1 UC1.AB12 UT1.W2
TBT_DP_RBIAS: RT35.1 UT1.N6
TBT_FORCE_PWR: RT27.1 UC1.B7 UT1.H4
TBT_I2C_SCL: RT19.1 UT1.U2 UT5.D2
TBT_I2C_SDA: RT18.1 UT1.U1 UT5.D1
TBT_JTAG_TCK: RT6.1 UT1.T4
TBT_JTAG_TDI: RT8.1 UT1.Y4
TBT_JTAG_TDO: RT5.1 UT1.W4
TBT_JTAG_TMS: RT7.1 UT1.V4
TBT_PCIE_RBIAS: RT34.1 UT1.N16
TBT_PWR_EN: T269.1(TP-1) UC1.D7
TBT_RBIAS: RT39.2 UT1.H6
TBT_RESET_N_EC: RE506.1 RT11.1 RT110.2 UT1.F4
TBT_RESET_N_EC_R: RE95.1 RE506.2 UE1.L8
TBT_ROM_CLK: UT1.AB4 UT2.6
TBT_ROM_CS#: RT2.1 UT1.AC3 UT2.1
TBT_ROM_DI: UT1.AB3 UT2.5
TBT_ROM_DO: RT3.1 UT1.AC4 UT2.2
TBT_ROM_HOLD#: RT1.1 UT2.7
TBT_ROM_WP#: RT4.1 UT1.V1 UT2.3
TBT_RSENSE: RT39.1 UT1.J6
TBT_SRC_CFG1: RT30.1 RT338.1 UT1.AA1
TBT_TMU_CLK_OUT: RT28.1 UT1.V2
TBTA_AUXN: CT81.1 UT1.W15
TBTA_AUXN_C: CT81.2 RT95.1 UT5.J2
TBTA_AUXP: CT80.1 UT1.Y15
TBTA_AUXP_C: CT80.2 RT96.1 UT5.J1
TBTA_BOT_N: RT122.2 UT5.L7
TBTA_BOT_N_R: DT20.1 JUSBC1.B7 RT122.1
TBTA_BOT_P: RT123.2 UT5.K7
TBTA_BOT_P_R: DT19.1 JUSBC1.B6 RT123.1
TBTA_CC1: CT86.1 DT7.1 JUSBC1.A5 RT104.2 UT5.L9
TBTA_CC2: CT85.1 DT16.1 JUSBC1.B5 RT105.2 UT5.L10
TBTA_DBG_CTL1: RT106.1 UT5.E4
TBTA_DBG_CTL2: RT107.1 UT5.D5
TBTA_DEBUG1: RT92.2 UT5.L2
TBTA_DEBUG2: RT93.2 UT5.K2
TBTA_DEBUG3: RT89.2 UT5.L3
TBTA_DEBUG4: RT90.2 UT5.K3
TBTA_HPD: RT23.1 RT73.1 UT1.M4
TBTA_HPD_R: RT73.2 UT5.C10
TBTA_I2C_INT: RT16.1 UT1.J4 UT5.C1
TBTA_LSRX: RT21.1 RT88.1 RT90.1 UT1.A4
TBTA_LSRX_R: RT88.2 UT5.K4
TBTA_LSTX: RT22.1 RT87.1 RT89.1 UT1.A5
TBTA_LSTX_R: RT87.2 UT5.L4
TBTA_MRESET: RT86.1 UT5.E11
TBTA_RESET_N_EC_R: RT110.1 UT5.F11
TBTA_ROM_CLK_PD: RT54.2 UT5.A3
TBTA_ROM_CLK_PD_R: JDB1.2 RT54.1 UT6.6
TBTA_ROM_CS#_PD: RT57.2 UT5.B3
TBTA_ROM_CS#_PD_R: JDB1.5 RT51.1 RT57.1 UT6.1
TBTA_ROM_DI_PD: RT55.2 UT5.B4
TBTA_ROM_DI_PD_R: JDB1.3 RT55.1 UT6.5
TBTA_ROM_DO_PD: RT56.2 UT5.A4
TBTA_ROM_DO_PD_R: JDB1.4 RT52.1 RT56.1 UT6.2
TBTA_ROM_HOLD#_PD: RT50.1 UT6.7
TBTA_ROM_WP#_PD: RT53.1 UT6.3
TBTA_ROSC: RT100.1 UT5.G2
TBTA_RX1N: DT14.1 JUSBC1.B10 UT1.A21
TBTA_RX1P: DT13.1 JUSBC1.B11 UT1.B21
TBTA_RX2N: DT9.1 JUSBC1.A10 UT1.B15
TBTA_RX2P: DT10.1 JUSBC1.A11 UT1.A15
TBTA_SBU1: DT8.1 JUSBC1.A8 RT108.2
TBTA_SBU1_R: RT108.1 UT5.K8
TBTA_SBU2: DT15.1 JUSBC1.B8 RT109.2
TBTA_SBU2_R: RT109.1 UT5.L8
TBTA_TOP_N: RT121.1 UT5.L6
TBTA_TOP_N_R: DT12.1 JUSBC1.A7 RT121.2
TBTA_TOP_P: RT120.1 UT5.K6
TBTA_TOP_P_R: DT11.1 JUSBC1.A6 RT120.2
TBTA_TX1N: CT96.1 UT1.B19
TBTA_TX1N_C: CT96.2 DT6.1 JUSBC1.A3
TBTA_TX1P: CT95.1 UT1.A19
TBTA_TX1P_C: CT95.2 DT5.1 JUSBC1.A2
TBTA_TX2N: CT98.1 UT1.B17
TBTA_TX2N_C: CT98.2 DT18.1 JUSBC1.B3
TBTA_TX2P: CT97.1 UT1.A17
TBTA_TX2P_C: CT97.2 DT17.1 JUSBC1.B2
TBTA_USB2_RBIAS: RT41.1 UT1.H19
TBTA_USB20_N: UT1.D20 UT5.K5
TBTA_USB20_P: UT1.E20 UT5.L5
TBTB_HPD: RT33.1 UT1.G2
TBTB_I2C_INT: RT17.1 UT1.E2
TBTB_LSRX: RT32.1 UT1.B5
TBTB_LSTX: RT31.1 UT1.B4
TBTB_USB2_RBIAS: RT42.1 UT1.F19
TDI_XDP: JXDP1.56 RC229.1 UC8.5
TDO_XDP: CC306.1 JXDP1.52 RC230.1 UC8.2
TDOCK_BATLOW#: RT20.1 UT1.F2
TEST_EN: RT36.1 UT1.E1
TEST_PWRGD: RT37.1 UT1.AB5
THERMATRIP1#: RE301.1 UE1.B12
THERMATRIP2#: CE36.1 QE4.1 RE69.2 UE1.H3
THERMDA: UT1.AB23 UT1.AC23
TOUCH_SCREEN_DET#: JTS1.5 RV8.1 UC1.AY5
TOUCH_SCREEN_PD#: JTS1.6 RC272.1 UC1.A7
TOUCHPAD_INTR#: JKBTP1.5 RC414.1 RE318.2 UC1.BA5
TP_LAN_JTAG_TCK: RL2.1 UL1.35
TP_LAN_JTAG_TDI: T88.1(TP-1) UL1.32
TP_LAN_JTAG_TDO: T89.1(TP-1) UL1.34
TP_LAN_JTAG_TMS: RL1.1 UL1.33
TPM_GPIO4: T283.1(TP-1) UZ12.13
TPM_LPM#: QZ9.1 RZ111.1 RZ363.2 UZ12.3
TPM_PIRQ#: RZ69.2 UC1.AP8 UZ12.18
TPM_TYPE: RC349.1 UC1.AY7
TRST#_XDP: JXDP1.54 UC8.12
TYPEC_ID: CE62.1 RE343.1 UE1.F2
UART_MISO: RT82.1 RT83.1 UT5.F2
UART_MOSI: RT81.1 RT83.2 UT5.E2
UG1_ISL88738: PQ905.1 PU901.11
UG2_ISL88738: PQ904.1 PU901.5
UIM_CLK: CZ38.1 JNGFF2.24 JSIM1.C3
UIM_DATA: CZ39.1 JNGFF2.26 JSIM1.C7 RZ335.2
UIM_RESET: CZ40.1 JNGFF2.22 JSIM1.C2
UPD1_ALERT#: RE91.1 RT60.1 UE1.F10
UPD1_SMBCLK: QT1.1 RE303.1 RT58.1 UE1.C3
UPD1_SMBCLK_Q: QT1.6 RT58.2 RT67.1 RT92.1 UT5.B5
UPD1_SMBDAT: QT1.4 RE302.1 RT59.1 UE1.B4
UPD1_SMBDAT_Q: QT1.3 RT59.2 RT66.1 RT93.1 UT5.A5
UPD1_SMBUS_ALERT#: RT60.2 RT68.1 UT5.B6
UPD2_ALERT#: RE92.1 UE1.F5
UPD2_SMBCLK: RPE12.3 UE1.D7
UPD2_SMBDAT: RPE12.4 UE1.E7
USB2_ID: RC337.1 UC1.AG3
USB2_VBUSSENSE: RC338.1 UC1.AG4
USB3_PRX_DTX_N1: DI4.1 DI4.9 JUSB1.5 UC1.H8
USB3_PRX_DTX_N2: LI16.4 RI28.1 UC1.J6
USB3_PRX_DTX_N3: DI1.1 DI1.9 JUSB2.5 UC1.J10
USB3_PRX_DTX_N4: DI6.5 DI6.6 JUSB3.5 UC1.E10
USB3_PRX_DTX_P1: DI4.2 DI4.8 JUSB1.6 UC1.G8
USB3_PRX_DTX_P2: LI16.1 RI27.1 UC1.H6
USB3_PRX_DTX_P3: DI1.2 DI1.8 JUSB2.6 UC1.H10
USB3_PRX_DTX_P4: DI6.4 DI6.7 JUSB3.6 UC1.F10
USB3_PRX_L_DTX_N2: JNGFF2.21 LI16.3 RI28.2
USB3_PRX_L_DTX_P2: JNGFF2.23 LI16.2 RI27.2
USB3_PTX_C_DRX_N1: CI13.1 DI4.4 DI4.7 JUSB1.8
USB3_PTX_C_DRX_N2: CI29.1 LI17.4 RI30.1
USB3_PTX_C_DRX_N3: CI5.1 DI1.4 DI1.7 JUSB2.8
USB3_PTX_C_DRX_N4: CI27.1 DI6.2 DI6.8 JUSB3.8
USB3_PTX_C_DRX_P1: CI16.1 DI4.5 DI4.6 JUSB1.9
USB3_PTX_C_DRX_P2: CI30.1 LI17.1 RI29.1
USB3_PTX_C_DRX_P3: CI4.1 DI1.5 DI1.6 JUSB2.9
USB3_PTX_C_DRX_P4: CI28.1 DI6.1 DI6.9 JUSB3.9
USB3_PTX_DRX_N1: CI13.2 UC1.C13
USB3_PTX_DRX_N2: CI29.2 UC1.B13
USB3_PTX_DRX_N3: CI5.2 UC1.B15
USB3_PTX_DRX_N4: CI27.2 UC1.C15
USB3_PTX_DRX_P1: CI16.2 UC1.D13
USB3_PTX_DRX_P2: CI30.2 UC1.A13
USB3_PTX_DRX_P3: CI4.2 UC1.A15
USB3_PTX_DRX_P4: CI28.2 UC1.D15
USB3_PTX_L_DRX_N2: JNGFF2.27 LI17.3 RI30.2
USB3_PTX_L_DRX_P2: JNGFF2.29 LI17.2 RI29.2
USB20_N1: UC1.AB9 UI3.2
USB20_N1_R: DI5.2 JUSB1.2 LI7.2
USB20_N2: LI3.1 UC1.AD6
USB20_N2_R: DI2.3 JUSB2.2 LI3.2
USB20_N3: LI4.1 UC1.AH3
USB20_N3_R: DI3.3 JUSB3.2 LI4.2
USB20_N4: LI8.4 RI48.1 UC1.AD9
USB20_N4_L: JNGFF2.9 LI8.3 RI48.2
USB20_N5: LZ1.4 UC1.AJ1
USB20_N5_R: DV8.1 JEDP1.7 LZ1.3
USB20_N7: LI9.1 RI50.1 UC1.AH1
USB20_N7_L: JNGFF1.5 LI9.2 RI50.2
USB20_N8: LV27.3 UC1.AF8
USB20_N8_R: DV4.2 JTS1.2 LV27.4
USB20_N10: JUSH1.8 UC1.AH7
USB20_P1: UC1.AB10 UI3.3
USB20_P1_R: DI5.3 JUSB1.3 LI7.3
USB20_P2: LI3.4 UC1.AD7
USB20_P2_R: DI2.2 JUSB2.3 LI3.3
USB20_P3: LI4.4 UC1.AJ3
USB20_P3_R: DI3.2 JUSB3.3 LI4.3
USB20_P4: LI8.1 RI47.1 UC1.AD10
USB20_P4_L: JNGFF2.7 LI8.2 RI47.2
USB20_P5: LZ1.1 UC1.AJ2
USB20_P5_R: DV7.1 JEDP1.8 LZ1.2
USB20_P7: LI9.4 RI49.1 UC1.AH2
USB20_P7_L: JNGFF1.3 LI9.3 RI49.2
USB20_P8: LV27.2 UC1.AF9
USB20_P8_R: DV4.3 JTS1.3 LV27.1
USB20_P10: JUSH1.9 UC1.AH8
USB_OC0#: RPC3.3 UC1.A9 UI3.13
USB_OC1#: RPC3.2 UC1.C9 UI1.3
USB_OC2#: RPC3.1 UC1.D9 UI2.3
USB_OC3#: RPC3.4 UC1.B9
USB_PWR_EN1#: RPE11.3 UE1.K3 UI1.4
USB_PWR_EN2#: RPE11.4 UE1.G5 UI2.4
USB_PWR_SHR_LFT_EN#: RPE11.2 UE1.J3 UI3.6
USB_PWR_SHR_VBUS_EN: RPE11.1 UE1.J2 UI3.5
USBCOMP: RC44.1 UC1.AB6
USH_DET#: DZ7.2 RE526.2 RZ87.1 UE1.C13
USH_DET#_R: DZ7.1 JUSH1.26 RZ87.2
USH_PWR_STATE#: JUSH1.22 RZ10.2 UE2.9
USH_RST#_R: JUSH1.21 RZ114.2
USH_SMBCLK: CZ62.1 JUSH1.11 RZ8.2 UE1.B3
USH_SMBDAT: CZ63.1 JUSH1.12 RZ9.2 UE1.E5
VCI_IN1#: RE507.1 UE1.B5
VCI_IN2#: RE508.1 UE1.D4
VCT_LAN_R1: RL3.1 UL1.6
VGA_ID: RE84.1 RE85.1 UE1.H11
VID0_EDRAM_VR: PR1307.2 PR1310.1 PU1301.9
VID0_EOPIO_VR: PR1318.2 PR1321.1 PU1302.9
VID0_PRIM_CORE: PR408.2 PR418.2 PR420.1 PU402.9
VID0_VCCIO: PR414.2 PR416.1 PU401.9
VID1_EDRAM_VR: PR1306.2 PR1309.1 PU1301.8
VID1_EOPIO_VR: PR1317.2 PR1320.1 PU1302.8
VID1_PRIM_CORE: PR411.2 PR417.2 PR419.1 PU402.8
VID1_VCCIO: PR413.2 PR415.1 PU401.8
VIDALERT_N: PR604.2 PR625.1 RC152.1 RC153.2
VIDALERT_N_B: PR625.2 PU602.36
VIDSCLK: CC321.1 PR601.2 PR618.1 UC1.A63
VIDSCLK_B: PR618.2 PU602.37
VIDSOUT: PR605.2 PR626.1 RC157.1 UC1.D64
VIDSOUT_B: PR626.2 PU602.35
VRALERT#: RC73.1 UC1.AM11
VSA_SEN+: PC640.2 PC650.1 PC652.1 PR649.2 RC168.2 UC1.H20
VSA_SEN-: PC649.1 PC650.2 PU602.26 RC166.1 UC1.H21
VSET_5105: CE38.1 RE77.1 UE1.C9
WIGIG_32KHZ: JNGFF1.50 RZ56.1
WLAN_COEX1: JNGFF1.48 RZ130.2
WLAN_COEX2: JNGFF1.46 RZ129.2
WLAN_COEX3: JNGFF1.44 RZ128.2
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.1 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.56
WRST#: CE500.1 RE6.2 UE2.4
WWAN_COEX1: JNGFF2.56 RZ130.1
WWAN_COEX2: JNGFF2.54 RZ129.1
WWAN_COEX3: JNGFF2.52 RZ128.1
WWAN_PWR_EN: CZ198.1 JNGFF2.6 RZ43.1
WWAN_RADIO_DIS#: DZ5.1 RE10.1 UE1.M2
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.15 RE38.1 UE1.M13
XCLK_BIASREF: RC52.1 RC324.1 UC1.E42
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.1 RC290.1 UC12.1
XDP_JTAGX: CC305.1 RC87.1 RC328.2 UC1.A59
XDP_OBS0: JXDP1.21 RC239.2
XDP_OBS0_R: RC239.1 UC1.C55
XDP_OBS1: JXDP1.23 RC240.2
XDP_OBS1_R: RC240.1 UC1.D55
XDP_OBS2_R: T10.1(TP-1) UC1.B54
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XDP_TMS: JXDP1.58 RC228.1 UC8.9
XTAL24_IN: CC21.1 RC46.2 UC1.E37 YC1.3
XTAL24_OUT: RC46.1 RC295.1 UC1.E35
XTAL24_OUT_R: CC22.1 RC295.2 YC1.1
XTAL_25_IN: CT21.1 UT1.D22 YT1.1
XTAL_25_OUT: RT40.1 UT1.D23
XTAL_25_OUT_R: CT20.1 RT40.2 YT1.3
XTALI: CL14.1 RL11.2 UL1.10 YL1.1
XTALO: RL11.1 RL34.2 UL1.9
XTALO_R: CL13.1 RL34.1 YL1.3
Z2805: RL18.1 TL1.22
Z2806: RL16.1 TL1.16
Z2807: RL17.1 TL1.21
Z2808: RL15.1 TL1.15
N04748: PC939.1 PR929.1 PU901.3
N40459: QV2.1 RV5.2
N16399089: PD901.1 PD903.1 PD904.1 PR916.2
N16400770: PR901.3 PR910.1
N16404606: PD905.3 PR939.2 PR950.1
N16404788: PD905.1 PU903.1
N16775301: PC208.2 PR204.2 PR206.1 PU200.16
N16775385: PC218.1 PU200.3
N16775433: PC204.1 PR202.2
N16775513: PC205.1 PR203.2
N16775517: PR203.1 PU200.12
N16776853: PC207.1 PU200.14
N16783095: PC113.2 PR108.1
N16783126: PC111.1 PR104.1 PR105.1 PU100.16 PU100.17
N16783134: PC127.2 PR117.1
N16783223: PC119.1 PU102.16 PU102.17
N16784595: PC102.1 PR100.2
N16784799: PC114.1 PR111.2
N17185089: PQ1204.5 PR1218.1
N17185092: PQ1204.6 PR1214.2 PR1218.2
N17185371: PQ1204.2 PR1223.1
N17370862: PC4.2 PQ4.4 PQ5.1 PR11.2 PR16.1
N17370885: PQ5.2 PR10.2 PR15.1
N17370921: PQ1.6 PR15.2
N17370927: PQ7.1 PR16.2
N17370961: PL3.1 PQ2.1 PR3.1 PR6.2
N17370983: PQ2.3 PR3.2 PR5.1
N17370995: PQ3.2 PR6.1 PR8.2
N17370999: PQ2.2 PQ3.1 PR7.2
N17371029: PC6.1 PQ9.4 PR12.2 PR18.1
N17371043: PQ6.1 PR18.2
N17371125: PQ7.2 PR20.1
N17371182: PQ6.2 PR23.2
N17371207: PQ8.1 PR22.1 PR27.1
N17372063: PQ1.3 PR17.2 PR19.2
N17372074: PQ1.5 PR25.1
N17372283: PQ1.2 PR19.1
N17372833: PC1206.1 PR1201.2 PR1203.1 PR1219.1 PU1201.3
N17377163: PC515.2 PR515.2 PR516.1 PU503.3
N17494434: PC1211.1 PD1205.1 PQ1212.1 PR1238.1 PR1239.2 PR1246.1 PR1255.2 PU1201.5
N17509431: PC947.1 PR935.1 PR947.1 PR949.2
N17509921: PD905.2 PR941.2
N17636493: PR612.2 PR614.2 PU602.39
N17637817: PR616.2 PU602.40
N17639131: PR620.2 PU602.1
N17853535: PR949.1 PU901.29
N17853651: PR936.1 PR948.1 PU901.30
N17965667: PQ8.3 PR26.2 PR28.1
N18008238: PQ1208.2 PQ1208.3 PR1259.1
N18008242: PQ1208.5 PR1244.2 PR1260.2 PR1261.1
N18008271: PQ1208.6 PQ1211.1 PR1234.1 PR1261.2
N18008295: PQ1211.5 PR1233.1 PR1242.2
N18008297: PQ1211.2 PR1235.1 PR1257.2
N18008327: PQ1210.5 PR1245.2
N18008396: PQ1207.6 PQ1211.4 PR1230.1 PR1258.2
N18008581: PQ1207.2 PQ1207.3 PR1232.1
N18011421: PR933.2 PR951.2 PU901.26
N18026694: PC1210.1 PQ1206.4 PR1228.2 PR1229.1
N18029341: PC1203.2 PQ1202.4 PQ1203.1 PR1207.2 PR1213.1
N18150665: PR1216.2 PU1200.4
N18150669: PQ1201.2 PR1216.1
N18150673: PC1202.2 PQ1213.4 PQ1215.1 PR1205.2 PR1212.1
N18150689: PQ1215.2 PR1251.2 PR1252.1
N18150691: PQ1214.6 PR1252.2
N18150723: PQ1201.6 PR1212.2
N18150740: PQ1205.1 PR1215.1 PR1226.2
N18151122: PQ1205.2 PR1225.1
N18151130: PQ1205.3 PR1221.2 PR1224.1
N18168775: PR23.1 PU1.4
N18168791: PR21.2 PU1.1
N18168794: PR22.2 PU1.2
N18169269: PR1215.2 PU1200.2
N18169272: PR1211.2 PU1200.1
N18170358: PR942.2 PU903.2
N18184051: PQ1207.5 PR1241.2
N18325201: CL16.1 TL1.3
N18325205: CL17.1 TL1.4
N18325209: CL20.1 TL1.9
N18325213: CL21.1 TL1.10
N18364501: RV97.1 UV7.20
N18366912: CV96.1 UV7.17
N18410850: PH603.2 PR635.1 PR647.2
N18490882: RI14.2 UI3.16
N18609334: QV7.1 QV8.2 RV6.1
N18667384: PR946.1 PU903.4
N18669063: PQ8.2 PR29.1
N18670418: PC930.1 PR914.1
N18762046: CA33.1 RA17.2
N18762152: CZ127.1 UZ5.10
N18762172: CZ126.1 UZ5.12
N18762349: CA51.1 RA44.1 UA1.27
N18762353: CA53.1 UA1.7
N18762355: CA52.1 UA1.39
N18762401: RA53.1 RA54.1 UA1.20
N18762411: CA29.1 UA1.35
N18762416: CA29.2 UA1.37
N18762426: CA35.1 UA1.28
N18762428: CA49.1 UA1.34
N18762438: CA25.1 UA1.19
N18805219: PL614.3 PR624.1
N18894766: PC640.1 PR646.2
N18894780: PC601.1 PR652.2
N18894855: PC632.1 PR636.1 PU602.28
N18894856: PC632.2 PR641.1
N18894871: PH604.1 PR642.2
N20151644: PR901.2 PR909.1
N20880735: PC307.2 PR308.1
N24606174: PC313.1 PU301.5
N26506689: PR678.2 PU602.38
N26508248: PC603.1 PR602.1 PU602.34
N26508256: PC604.1 PR603.1 PU602.33
N26509112: PR608.1 PU602.32
N26509117: PR611.1 PU602.31
N26518420: PC630.1 PR640.1 PU602.20
N26519264: PH605.1 PR657.2
N26522108: PC639.2 PR645.1
N26523008: PC647.2 PR650.2
N26523611: PC629.2 PR639.1
N26526626: PC627.1 PR632.2
N26527807: PH602.1 PR628.2
N26528911: PC627.2 PR638.2 PU602.8
N26532119: PC621.2 PR623.1
N26532121: PR621.2 PR622.2 PR623.2 PU602.5
N26533060: PC616.2 PR617.2 PU602.4
N26533062: PC614.2 PR617.1
N26533293: PR610.2 PU602.3
N26533871: PC613.2 PR613.2 PU602.2
N26535263: PL610.3 PR661.1
N26554964: PC617.2 PR621.1
N26566701: PC631.1 PR630.2
N26570644: PC630.2 PR644.1
N27076067: PC944.1 PR934.2
N27077001: PR917.2 PR937.2
N28424999: T113.1(TP-1) UC1.AW71
N28425002: T114.1(TP-1) UC1.AW70
N28489601: RC222.1 SW1.2
N28712229: PC671.2 PU612.7
N28712232: PR672.2 PU612.6
N28712235: PC671.1 PR672.1
N28713556: PR671.1 PU612.1
N28714854: PC655.2 PU610.7
N28714856: PR660.2 PU610.6
N28714858: PC655.1 PR660.1
N28714920: PR659.1 PU610.1
N28716223: PC663.2 PU613.7
N28716225: PR665.2 PU613.6
N28716227: PC663.1 PR665.1
N28716292: PR664.1 PU613.1
N28718522: PC611.2 PU614.2
N28718526: PC611.1 PR619.1
N28769860: PR421.2 PR422.1 PU401.5
N28771761: PR404.2 PR425.2 PU401.14
N28771835: PR410.2 PR426.2 PU402.14
N28810563: CZ110.1 UZ2.10
N28811129: CZ114.1 UZ3.10
N28856399: T16.1(TP-1) UC1.BA70
N28856402: T17.1(TP-1) UC1.BA68
N28857231: T12.1(TP-1) UC1.BB68
N28857234: T13.1(TP-1) UC1.BB69
N28857240: T15.1(TP-1) UC1.AK12
N28861827: RC120.1 UC1.C64
N28938912: CC8.1 RC29.2
N28938914: CC7.1 RC28.2
N29207759: PH601.2 PR610.1 PR631.2
N29708559: T126.1(TP-1) UC1.AY4
N29708561: T127.1(TP-1) UC1.BB3
N29708599: T128.1(TP-1) UC1.AU5
N29708601: T129.1(TP-1) UC1.AT5
N29708639: T130.1(TP-1) UC1.BB5
N30191461: PR1322.2 PR1323.1 PU1302.5
N30191517: PR1308.2 PR1311.1 PU1301.5
N30191539: PR1302.2 PR1303.2 PU1301.14
N30191541: PR1313.2 PR1314.2 PU1302.14
N30409911: JEDP1.16 LV1.1
N32011565: PQ501.8 PU614.5
N32011581: PQ501.1 PU614.1
N32015249: PR679.1 PU614.7
N32590572: CZ117.1 UZ4.12
N32592963: CZ118.1 UZ4.10
N32594166: CZ109.1 UZ2.12
N32595008: RZ70.2 RZ71.2 UZ2.3
N32817808: CZ113.1 UZ3.12
N32818355: RZ64.2 RZ65.2 UZ3.3
N32819772: CZ121.1 UZ8.6
N33199734: JDIMM1.162 T50.1(TP-1)
N33199744: JDIMM1.165 T51.1(TP-1)
N33290988: CD62.2 RD31.1
N33298469: JDIMM2.162 T54.1(TP-1)
N33298471: JDIMM2.165 T55.1(TP-1)
N33612393: CD31.2 RD18.1
N35551572: PC1214.1 PQ1209.5 PR1243.2
N35551576: PQ1209.2 PQ1209.3 PR1236.1
N35551581: PQ1209.6 PR1229.2
N35551584: PC1213.1 PD1205.2 PR1238.2 PR1240.2 PR1243.1 PU1201.7
N35551592: PC1212.1 PR1237.2 PR1247.1 PU1201.6
N35551616: PQ1212.2 PR1248.1 PR1249.1 PR1250.1
N35551655: PC1205.1 PR1208.2 PR1217.1 PU1201.2
N35551785: PQ1203.2 PR1202.2 PR1209.1
N35551806: PQ1204.3 PR1209.2
N35551822: PQ1201.3 PR1213.2
N36255106: PQ1201.5 PR1220.2
N36307052: RT97.2 RT98.1 RT99.1 UT5.F10
N36307117: RT85.1 UT5.G4
N36307119: RT84.1 UT5.F4
N36307669: RT63.1 UT5.F1
N36307918: RT105.1 UT5.K10
N36307920: RT104.1 UT5.K9
N36307926: RT103.1 UT5.L11
N36626863: CT90.1 RT111.2 UT7.3
N36736352: RT85.2 T220.1(TP-1)
N36736355: RT84.2 T219.1(TP-1)
N36827741: RZ120.2 UZ26.4 UZ34.4
N38312012: CT87.1 UT5.H7
N38327809: RT101.1 UT5.D6
N39317125: PR423.1 PR424.1 PU402.5
N40478997: QV4.2 RV18.2
N41228182: JNGFF2.17 RZ326.1
N41307615: CZ38.2 RZ334.1
N44311288: QE11.3 RE70.1 RE90.2
N44311298: QE4.2 RE70.2
N44311418: QE13.1 RE34.2 RE348.1 RE536.1 RE537.2 UE7.3
N44311425: CE5.1 UE7.4
N44321668: RE57.1 RE58.1 UE1.B1
N44321726: RE318.1 UE1.G2
N44321827: RE349.2 UE1.N4
N44321953: CE57.1 RE350.2
N44683730: CZ197.1 RZ345.2 UZ8.3
N44957960: JNGFF2.59 T225.1(TP-1)
N45096894: JESPI.8 RE375.1
N45586607: QZ3.1 RZ25.1
N45640623: RE13.2 RE14.1 UE2.1
N45640625: RE15.2 RE16.1 UE2.2
N45640715: RE17.2 RE18.1 UE2.3
N46646690: CZ56.1 RZ63.1
N46646814: RZ112.2 RZ362.2 UZ12.29
N46646843: RZ62.1 UZ12.27
N46647029: QZ9.2 RZ113.2
N46748110: JNGFF2.48 RZ131.2
N46748113: JNGFF2.50 RZ132.2
N46916972: QE12.1 RE94.1
N47676492: QE13.3 QE13.6
N119328643: PC938.1 PR930.1 PR931.2 PU901.25
N131988242: PR920.2 PU901.21
N131988252: PR922.2 PU901.22
N132000604: PC934.1 PR921.2
N132005053: PR917.3 PR938.2
N482247290: PR932.1 PU901.27

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 11 15 27; JHDMI1 14; JIR1 4; JKBTP1 10 17; JNGFF1 6 16 17; JNGFF2 10 12 14 16 20 33 35 36 38 39 40 41 44 45 47 51 53 55 57 60; JNGFF3 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JSD1 16; JSIM1 1 C4 C6 C8; JSPI1 4; JUSH1 2 17; PBATT1 11 12; PD2 2; PRP1 4 5; PU100 10 15; PU102 10; PU200 18 19; PU301 2; PU401 4; PU402 4; PU503 2 6 7; PU901 13; PU1301 4; PU1302 4; QL2 3 4 5; QZ7 1 2 6; RC22 2; RC405 2; RPC4 2 7; RPE12 1 2 7 8; RT69 2; RT74 2; RT75 2; RT339 2; RZ326 2; UA1 4 11 12 15 23 24 48; UC1 A3 A4 A11 A26 A27 A29 A31 A33 A36 A38 A52 A65 A69 AB3 AB4 AB13 AD3 AD4 AF6 AF7 AF11 AF12 AF13 AG1 AG2 AH9 AH10 AH11 AH12 AK6 AK7 AK9 AK10 AK13 AK62 AL25 AL27 AL61 AM1 AM2 AM3 AM4 AM5 AN1 AN2 AN3 AP1 AP2 AP3 AP4 AP13 AU56 AW1 AW20 AW48 AW68 AW69 AY1 AY2 AY20 AY21 B2 B3 B11 B26 B27 B29 B31 B33 B36 B38 B52 B69 B70 BA3 BA4 BA7 BA8 BA9 BB2 BB4 BB7 BB9 BB11 C2 C4 C7 C8 C11 C12 C16 C23 C27 C28 C29 C31 C32 C33 C36 C37 C38 C54 C56 C70 C71 D1 D3 D4 D5 D12 D16 D23 D27 D28 D29 D31 D32 D33 D36 D37 D38 D54 D71 E1 E2 E3 E25 E61 F6 F11 F25 F52 F60 F61 F65 G11 G65 H11 J1 J4 J5 J68 J71 K45 K46 L6 M1 M2 M3 M4 N1 N2 N3 N9 N11 P1 P3 U6 U7 V1 V2 W4 W7 W12; UD1 1; UE1 B8 B9 F7 F12 F13 J6; UE2 5 6 8 10 11; UE4 1; UE6 1; UI3 9 15; UR1 31; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 V18 W16 W19 Y16 Y19; UT7 4; UV7 2 4 14 58; UV24 3; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; YC1 2 4

## Via types
v1: diameter 0.406, hole 0.203, TOP to BOTTOM, 392 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 6611 vias
v3: diameter 0.305, hole 0.152, TOP to BOTTOM, 468 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 94 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 69.6
  TOP w0.102: v2(42.52,34.11) 39.88,34.11 PR210.1
  IN3 w0.102: v2(63.88,59.53) 63.88,54.32 52.14,42.58 50.55,42.58 49.6,41.62 49.6,40.04 43.67,34.11 v2(42.52,34.11)
  BOTTOM w0.102: v2(63.88,59.53) 64.45,59.53 64.62,59.37 68.49,59.37 68.58,59.28 88.39,59.28 89.51,60.39 v3(89.51,61.41) 89.51,61.59 88.61,62.49 RD19.1 87.29,62.61 UD1.4
1.8V_PRIM_PWRGD: length 180.6
  TOP w0.102: v2(262.08,31.91) 262.52,32.35 RE361.2 ; v2(279.13,41.26) 278.98,41.1 RE360.2
  IN2 w0.102: v2(162.4,97.01) 163.28,97.01 164.42,95.88 165.33,95.88 166.1,95.11 166.9,95.11 167.81,94.2 170.74,94.2 171.6,93.33 171.6,91.35 171.11,90.86 171.11,86.88 171.52,86.48 171.52,81.5 172.4,80.61 172.4,79.63 176.75,75.28 177.84,75.28 179.54,73.58 179.54,71.4 182.24,68.69 182.24,68.3 185.52,65.02 185.92,65.02 189.27,61.67 189.27,60.96 190.93,59.29 191.43,59.29 196.9,53.82 197.63,53.82 207.5,43.95 209.46,43.95 221,43.95 222.79,42.17 236.59,42.17 237.28,41.48 246.47,41.48 249.06,38.89 249.06,37.22 249.7,36.58 253.79,36.58 254.14,36.93 254.95,36.93 255.1,36.78 256.18,36.78 256.88,36.08 257.61,36.08 257.61,36.09 259.33,36.09 259.65,35.77 259.65,34.98 261.36,33.27 261.36,32.63 v2(262.08,31.91) 262.53,31.91 263.05,31.4 264.8,31.4 265.27,30.93 266.33,30.93 267.18,30.07 268.1,30.07 268.46,30.43 273.29,30.43 273.84,30.99 273.84,32.17 276.19,34.51 276.19,38.32 v2(279.13,41.26)
  BOTTOM w0.102: PR517.1 169,101.33 169.47,100.86 171.15,100.86 171.88,100.12 171.88,99.31 170.77,98.19 169.54,98.19 v3(169.1,97.76) 168.42,97.07 167.7,97.07 167.13,96.5 162.91,96.5 v2(162.4,97.01)
2.5VSP: length 1.6
  TOP w0.102: PC516.1 195.21,27.03 v1(195.52,27.34)
3.3V_CAM_EN#: length 225.8
  TOP w0.102: v2(146.12,70.79) 146.12,71.03 RC311.1 ; QZ1.2 58.75,112.61 59.51,111.85 v2(59.51,111.64)
  IN2 w0.102: v2(59.51,111.64) 60.87,113 61.17,113 62.94,114.77 70.39,114.77 71.9,113.27 77.3,113.27 78.52,112.06 91.45,112.06 92.47,113.07 102.42,113.07 103.32,112.17 115.05,112.17 115.61,112.73 120.95,112.73 122.8,114.57 151.53,114.57 158.28,107.82 158.95,107.82 159.16,107.6 162.95,107.6 171.21,99.35 171.21,98.59 174.97,94.82 174.97,92.9 177.07,90.8 177.07,89.76 176.94,89.63 176.94,88.21 176.23,87.5 176.23,83.08 185.29,74.01 185.85,74.01 v2(186.55,73.31)
  IN3 w0.076: v2(136.91,69.32) 137.24,69.65 137.24,70.02 138.29,71.07 138.29,71.95 138.78,72.44 139.13,72.44 139.15,72.47 142.72,72.47 144.29,70.9 146.02,70.9 v2(146.12,70.79)
  IN3 w0.102: v2(146.12,70.79) 146.39,70.52 148.89,70.52 149.36,70.05 151.94,70.05 153.97,72.08 155.43,72.08 156.23,72.87 158.03,72.87 160.57,70.34 160.57,69.73 v2(161.33,68.97)
  BOTTOM w0.076: UC1.AT15 137.34,69.75 v2(136.91,69.32)
  BOTTOM w0.102: v2(186.55,73.31) 187.05,72.81 187.05,71.87 184.97,69.8 184.97,68.6 184.3,67.93 181.93,67.93 179.57,65.57 169.57,65.57 169.4,65.41 168.34,65.41 166.67,63.74 162.6,63.74 160.76,65.58 v1(160.76,66.58) 160.76,67.93 161.33,68.5 v2(161.33,68.97)
3.3V_TS_EN: length 174.1
  TOP w0.102: RC282.1 145.1,72.17 144.88,71.95 144.88,71.37 144.35,70.83 142.63,70.83 v2(142.39,70.59) ; v2(185.71,85.49) 180.68,90.52 v1(180.67,90.52) 180.51,90.67 179.07,90.67 176.54,93.2 176.54,94.25 175.94,94.86 175.94,99.06 173.61,101.38 170.81,101.38 169.78,102.42 169.78,105.15 168.21,106.72 167.38,106.72 167.18,106.92 166.69,106.92 166.52,106.74 164.37,106.74 163.9,106.27 163.19,106.27 162.89,106.58 162.89,107.2 160.75,109.34 159.86,109.34 155.65,113.55 135.84,113.55 132.7,116.68 122.53,116.68 121.85,116 105.11,116 103.93,114.81 99.55,114.81 98.63,113.89 97.85,113.89 97.12,113.16 97.12,112.61 96.9,112.4 96.9,110.16 97.47,109.59 QV7.2
  IN2 w0.102: v2(142.39,70.59) 145.35,70.59 146.09,69.84 150.84,69.84 151.28,70.28 158.4,70.28 158.96,70.83 158.96,73.06 159.55,73.66 162.54,73.66 v2(163.45,74.57)
  BOTTOM w0.076: UC1.AP5 v2(142.39,70.59)
  BOTTOM w0.102: v2(185.71,85.49) 185.71,84.73 184.81,83.84 184.81,81.5 184.71,81.4 182.96,81.4 182.07,80.51 180.21,80.51 179.78,80.08 179.78,79.01 179.68,78.91 176.83,78.91 175.38,80.36 172.56,80.36 172.3,80.1 172.3,78.86 171.73,78.29 168.86,78.29 167.77,77.2 167.77,75.91 167.3,75.44 166.45,75.44 166.16,75.73 165.09,75.73 164.84,75.49 164.37,75.49 v2(163.45,74.57)
3.3V_WWAN_EN: length 79.5
  TOP w0.102: v2(285,78.65) 285,78.27 RZ40.2 285.75,77.95 285.92,78.11 UZ4.5
  TOP w0.107: v2(263.62,40.44) 263.67,40.44 UE1.C6
  IN1 w0.102: v2(297.37,70.9) 296.67,70.2 296.67,66.35 295.91,65.59 295.91,64.47 297.47,62.91 297.47,61.44 297.64,61.27 297.64,58.96 296.76,58.07 296.64,58.07 294.72,56.14 294.72,52.81 293.28,51.37 293.28,50.73 291.64,49.09 291.64,48.09 291.21,47.67 291.21,45.37 286.45,40.61 280.4,40.61 279.22,39.44 272.6,39.44 272.1,39.93 271.48,39.93 271.24,40.18 271.24,40.72 271.1,40.87 267.04,40.87 266.98,40.8 264.87,40.8 264.72,40.95 264.12,40.95 263.98,40.81 263.98,40.8 v2(263.62,40.44)
  BOTTOM w0.102: v2(297.37,70.9) 297.37,71.54 295.66,73.25 294.13,73.25 v3(291.66,75.72) 289.31,78.07 285.57,78.07 v2(285,78.65)
3V5V_EN: length 248.4
  IN2 w0.102: v2(236.54,23.84) 236.46,23.92 236.07,23.92 235.52,24.47 235.52,25.35 231.6,29.27 221.92,29.27 220.78,28.14 202.09,28.14 201.62,27.67 199.12,27.67 198.78,28.01 197.23,28.01 196.93,28.31 185.51,28.31 183.07,25.86 167.66,25.86 167.23,26.28 167.23,26.68 166.75,27.16 164.15,27.16 163.65,26.66 159.7,26.66 158.32,25.28 115.82,25.28 113.63,23.09 83.47,23.09 81.22,25.35 46.98,25.35 43.26,21.63 32.37,21.63 28.63,25.37 28.63,41.95 31.98,45.31 v2(32.8,45.31)
  BOTTOM w0.102: PU102.12 33.04,45.54 v2(32.8,45.31) 32.27,45.31 PR114.2 32.03,44.08 PD100.1 ; PC128.1 PR116.1 236.92,23.73 236.81,23.84 v2(236.54,23.84) 236.46,23.92 236.02,23.92 235.08,24.86 PU100.12
3V_FB: length 2.9
  BOTTOM w0.254: PU100.13 234.63,24.97 234.75,24.86 234.75,24.56 v3(235.08,24.23) 235.83,23.48 PC113.1
3V_SN:
  vias: v3(231.71,26.19)
3V_VIN: length 0.7
  BOTTOM w0.102: v3(233.72,31.11) 233.75,31.08 234.41,31.08
5V_FB: length 1.4
  BOTTOM w0.102: PC127.1 32.35,45.99 PU102.13
5V_SN: length 1.6
  TOP w0.102: v1(36.51,46.01) 36.76,46.25 PC125.1
5V_VIN:
  vias: v1(37.21,44.29) v2(37.86,42.58) v2(38.42,42.58)
+0.6V_DDR_VTT: length 173.8
  IN1 w1.016: 184.22,27.91 183.62,27.91 183.24,28.28 183.24,28.28 181.52,30 181.52,34.8 179.94,36.38 150.46,36.38 148.11,34.04 148.11,29.56 146.61,28.06 125.62,28.06 124.8,28.88 119.27,28.88 118.63,28.24
  IN3 w1.016: 40.13,35.79 40.13,34.2 42.03,32.29 44.86,32.29 49.27,36.7 82.09,36.7 82.67,36.11 82.67,33.34 83.84,32.17 83.84,26.18 84.84,25.18 98.54,25.18 99.21,24.52 116.12,24.52 118.49,26.9 118.49,27.07 118.48,27.08
  BOTTOM w0.356: JDIMM2.258 191.68,26.86 191.59,26.77 v2(191.59,26.67)
  vias: v1(120.53,28.54) v2(39.02,36.35) v2(39.56,36.58) v2(117.8,27.92) v2(118.43,27.92) v2(190.97,26.67)
+0.6VSP: length 2.4
  BOTTOM w0.102: PJP201.1 38.47,37.17 38.89,37.59 v1(38.89,37.6)
+0.9V_LAN: length 20
  TOP w0.152: UL1.43 v2(271.42,94.22)
  TOP w0.203: UL1.47 271.55,92.62 271.27,92.89 ; UL1.22 279.49,95.82 CL9.1 ; v2(271.15,97.63) 271.31,97.63 UL1.37 ; 271.27,92.89 270.22,92.89 ; 271.27,92.89 271.4,93.02 UL1.46 ; UL1.16 279.32,93.42 279.93,92.8 CL8.1 ; 275.9,89.9 UL1.8 ; UL1.40 v2(271.2,95.42) ; UL1.11 277.1,90.92 277.31,90.71 278.37,90.71 v1(278.82,90.26) 279.66,89.43 CL11.1
  TOP w0.381: CL9.1 v2(280.42,97.25) ; CL8.1 v2(280.42,92.3) ; v2(280.29,88.99) 279.87,89.41 CL11.1
  TOP w0.508: CL10.1 v2(271.15,97.63)
  vias: v2(268.1,92.42) v2(268.1,91.79) v2(275.48,88.95) v2(275.49,88.36) v2(275.56,89.51)
