# Allegro board LAE131PR10-1107-A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 10.72,80.47 10.72,77.45 11.44,76.73 12.23,76.73 12.98,75.98 12.98,74.69 12.64,74.35 10.2,74.35 10.2,74.83 10.24,74.84 10.69,75.62 10,76.2 1,76.2 0.44,76.44 0.2,77 0.2,78.43 7.28,78.43 9.61,80.76 10.43,80.76
GND on BOTTOM (solid shape): 43.69,83.98 43.69,82.79 43.53,82.51 43.69,82.23 43.69,79.96 43.63,79.76 43.69,79.57 43.69,75.53 43.06,74.9 43.06,74.14 42.93,74.01 42.29,74.01 42.25,74.05 42.25,74.83 41.28,75.8 41.28,81.88 41.4,82.01 41.66,82.01 41.77,82.12 41.77,82.23 41.85,82.45 41.77,82.68 41.77,82.82 41.85,83.04 41.77,83.26 41.77,84.21 41.86,84.3 43.37,84.3
GND on BOTTOM (solid shape): 3.99,85.14 4.35,84.74 4.89,84.72 4.92,84.73 5.46,84.19 5.52,84.19 5.73,83.98 6.62,83.98 7,83.79 7.34,83.54 7.65,83.54 9.08,82.11 9.08,80.54 7.16,78.62 0.33,78.62 0.2,78.75 0.2,82.97 0.24,83.23 0.54,83.79 0.6,84.17 0.6,84.37 0.84,84.94 1.4,85.17 3.98,85.17
GND on BOTTOM (solid shape): 47.03,17.13 47.11,17.04 47.2,16.95 47.76,16.38 47.94,16.12 48,15.82 48,8.7 47.76,8.14 47.2,7.9 40.75,7.9 40.19,8.14 39.95,8.7 39.95,12.6 39.86,12.95 39.6,13.21 39.55,13.28 39.58,13.37 40.31,14.1 40.32,14.1 40.68,14.32 40.9,14.68 40.9,14.69 43.34,17.13
GND on BOTTOM (solid shape): 13.89,61.33 13.89,60.83 11.95,58.89 11.95,56.88 6.77,56.88 6.76,56.92 6.33,57.56 5.6,57.8 1,57.8 0.44,58.04 0.2,58.6 0.2,59.6 0.44,60.16 1,60.4 10,60.4 10.69,60.98 10.24,61.76 10.2,61.77 10.2,62.12 13.11,62.12
GND on BOTTOM (solid shape): outline of 89 points within 300.36,51.66 305.72,54.7
GND on BOTTOM (solid shape): 91.83,29.84 91.82,29.81 91.84,29.6 91.99,29.45 92.04,29.36 91.99,29.28 91.81,28.98 91.99,28.69 92.04,28.6 91.99,28.51 91.84,28.36 91.82,28.15 91.83,28.13 90.75,27.05 90.73,27.06 90.36,26.9 90.42,26.5 90.42,26 90.24,25.82 90.24,24.1 90.17,24.03 89.98,24.03 89.92,24.1 89.92,25.64 89.76,25.8 89.69,25.85 89.61,25.88 89.56,25.88 89.56,26.23 89.57,26.24 89.6,26.38 89.57,26.53 89.56,26.54 89.56,29.9 89.81,30.14 91.52,30.14
GND on BOTTOM (solid shape): 6.45,54.42 7.01,54.29 7.46,53.92 10.74,53.92 11.19,54.29 11.75,54.42 11.95,54.42 11.95,54.31 13.01,53.24 13.01,53.06 12.98,52.98 12.91,52.95 12.5,52.83 12.24,52.49 12.23,52.45 9.2,52.45 9.01,52.42 8.84,52.31 8.72,52.18 8.69,52.16 8.65,52.15 4.1,52.15 3.54,52.39 3.3,52.95 3.3,53.6 3.54,54.16 4.1,54.4 5.6,54.4 5.71,54.4 5.82,54.42
GND on BOTTOM (solid shape): 16.59,100.35 16.59,100.24 16.07,99.72 16.07,97.78 12.92,94.63 9.53,94.63 9.27,94.9 7.89,94.9 7.07,94.08 5.35,94.08 5.35,94.33 4.77,95.02 3.99,94.56 3.98,94.53 1.4,94.53 0.84,94.76 0.6,95.32 0.6,95.53 0.54,95.91 0.24,96.47 0.2,96.72 0.2,97.7 0.44,98.26 1,98.5 1.1,98.5 1.6,98.7 1.8,99.2 1.8,100.3 1.89,100.51 2.1,100.6 16.34,100.6
GND on BOTTOM (solid shape): 16.68,39.16 16.68,31.69 16.18,31.19 13.6,31.19 13.6,32.75 13.02,33.44 12.24,32.99 12.23,32.95 9.2,32.95 9.01,32.92 8.84,32.81 8.72,32.68 8.69,32.66 8.65,32.65 4.1,32.65 3.54,32.89 3.3,33.45 3.3,37.35 3.54,37.91 4.1,38.15 8.65,38.15 8.69,38.14 8.72,38.12 8.84,37.99 9.01,37.88 9.2,37.85 12.23,37.85 12.24,37.81 13.02,37.36 13.6,38.05 13.6,39.78 16.05,39.78
GND on BOTTOM (solid shape): outline of 156 points within 204.09,21.81 209.91,33.5
GND on BOTTOM (solid shape): 40.05,93.27 40.05,93.05 41.34,93.05 41.44,92.98 41.4,92.87 41.68,91.99 41.97,92.87 41.93,92.98 42.03,93.05 42.68,93.05 43.18,92.55 43.18,90.39 43.06,90.26 42.59,90.26 42.56,90.28 42.54,90.32 42.21,90.65 41.88,90.32 41.87,90.28 41.83,90.26 40.65,90.26 40.57,90.3 40.55,90.39 40.57,90.48 40.55,90.58 40.52,90.65 40.48,90.71 40.45,90.78 40.48,90.85 40.24,91.4 39.99,90.85 40.02,90.78 39.99,90.71 39.98,90.7 39.91,90.66 39.83,90.69 38.86,91.66 37.53,91.66 37.4,91.79 37.4,93.27 37.53,93.4 39.92,93.4
GND on BOTTOM (solid shape): outline of 162 points within 57.89,60.17 63.5,68.05
GND on BOTTOM (solid shape): 132.46,73.93 132.52,74.03 132.63,74.01 132.84,73.93 133.05,74 133.07,74.02 133.1,74.02 133.19,73.92 133.15,73.88 133.14,73.88 132.93,73.4 133.44,73.31 133.46,73.33 133.52,73.33 133.96,72.89 134.03,72.89 134.04,72.88 134.26,72.89 134.39,73.07 134.44,73.11 134.48,73.11 134.52,73.1 134.54,73.07 134.58,72.97 134.66,72.9 134.69,72.88 134.69,72.8 134.37,72.48 134.37,72.36 134.37,72.34 134.44,72.17 134.61,72.1 134.63,72.1 134.75,71.98 134.75,71.6 134.24,71.09 134.05,71.09 133.82,71.32 133.79,71.41 133.84,71.48 133.89,71.88 133.49,71.83 133.41,71.78 133.33,71.81 133,72.13 132.99,72.17 133,72.2 133,72.51 132.69,72.59 132.68,72.58 132.64,72.58 132.6,72.54 132.51,72.63 132.54,72.67 132.59,72.79 132.57,72.93 132.57,72.94 132.57,73.28 132.67,73.56 132.49,73.81 132.46,73.82
GND on BOTTOM (solid shape): 312.62,54.99 312.73,55.01 312.8,54.92 312.8,54.8 313.38,54.11 314.16,54.56 314.17,54.6 318.69,54.6 322.62,54.6 323.18,54.36 323.41,53.8 323.41,53.15 323.18,52.59 322.62,52.35 320.8,52.35 319.95,52 319.6,51.15 319.6,50.15 319.95,49.3 320.8,48.95 325.8,48.95 326.36,48.71 326.6,48.15 326.6,33.78 326.4,33.26 325.9,32.99 325.51,32.88 325.19,32.64 321.13,32.64 321.13,33.56 321.6,34.03 323.8,34.03 323.93,33.9 325.75,33.9 326.09,34.25 326.09,44.35 323.88,46.56 322.65,46.56 322.07,47.14 322.07,47.81 321.44,48.44 320.8,48.44 319.59,48.94 319.09,50.15 319.09,50.57 313.66,50.57 312.6,51.64 312.6,54.97
GND on BOTTOM (solid shape): 16.97,19.48 16.97,19.03 16.58,18.65 15.35,18.65 14.95,18.24 14.95,18.08 14.94,18.07 14.73,17.52 14.63,16.93 14.62,16.88 13.96,16.88 13.51,16.51 12.95,16.38 11.75,16.38 11.19,16.51 10.74,16.88 7.46,16.88 7.01,16.51 6.45,16.38 5.97,16.38 5.97,13.92 17.65,13.92 18.2,13.82 18.72,14.01 18.82,14.02 18.88,13.93 18.88,13.3 18.83,13.29 18.41,13.05 18.25,12.6 18.25,8.7 18.01,8.14 17.45,7.9 16.44,7.9 16.21,7.94 16,8.03 14.1,8.6 12.2,8.03 11.99,7.94 11.76,7.9 10,7.9 9.15,7.55 8.8,6.7 8.8,5.3 8.56,4.74 8,4.5 1,4.5 0.44,4.74 0.2,5.3 0.2,15.85 0.44,16.41 1,16.65 2.1,16.65 2.95,17 3.54,18.41 4.1,18.65 8.65,18.65 8.69,18.64 8.72,18.62 8.84,18.49 9.01,18.38 9.2,18.35 12.23,18.35 12.24,18.31 13.02,17.86 13.6,18.55 13.6,20.02 16.43,20.02
GND on BOTTOM (solid shape): outline of 139 points within 132.75,72.29 138.5,75.79
GND on BOTTOM (solid shape): outline of 128 points within 168.63,26.28 171.42,34.87
GND on BOTTOM (solid shape): outline of 222 points within 39.37,0.25 326.15,24.91
GND on BOTTOM (solid shape): outline of 279 points within 0.25,52.99 326.15,118.8
GND on BOTTOM (solid shape): outline of 3422 points within 168.38,26.28 190.6,37.71
GND on BOTTOM (solid shape): outline of 4104 points within 124.06,25.83 152.28,38.68
GND on BOTTOM (solid shape): outline of 7649 points within 45.44,23.16 119.45,43.81
GND on GND1 (solid shape): 166.28,22.7 165.77,22.7 165.28,22.83 164.91,23.18 164.18,23.89 163.2,24.15 162.2,24.15 160.79,23.56 160.2,22.15 160.2,21.22 158.76,21.22 158.76,24.94 166.28,24.94
GND on GND1 (solid shape): 50.98,19.28 50.51,19.31 50.11,19.56 49.96,19.71 47.34,19.71 47.34,17.09 47.91,16.53 48.09,16.27 48.19,15.96 48.17,15.88 48.09,15.84 45.49,15.84 45.49,21.06 50.98,21.06
GND on GND1 (solid shape): 191.02,19.81 190.99,19.73 190.91,19.71 190.29,20.05 190.05,20.7 190.05,21.6 189.51,22.91 188.2,23.45 187.2,23.45 185.89,22.91 185.35,21.6 185.35,20.7 185.06,19.99 184.35,19.7 184.14,19.7 184.14,24.35 191.02,24.35
GND on IN1 (solid shape): 326.2,99.6 325.96,99.04 325.4,98.8 314.88,98.8 314.88,100.22 315.89,101.23 326.2,101.23
GND on IN1 (solid shape): 10.72,80.47 10.72,77.45 11.44,76.73 12,76.73 12.98,75.75 12.98,74.69 12.64,74.35 10.2,74.35 10.2,74.83 10.24,74.84 10.69,75.62 10,76.2 1,76.2 0.44,76.44 0.2,77 0.2,78.43 7.28,78.43 9.61,80.76 10.43,80.76
GND on IN1 (solid shape): 72.58,82.95 73.71,82.95 74.6,82.07 74.6,76.78 74.03,76.22 70.87,76.22 70.87,76.3 70.86,76.35 70.84,76.41 70.82,76.46 70.78,76.5 70.76,76.52 70.48,76.8 70.48,76.96 72.89,76.96 72.89,76.9 72.9,76.85 72.91,76.8 72.94,76.76 72.97,76.71 73,76.68 73.04,76.65 73.09,76.62 73.14,76.61 73.19,76.6 73.24,76.6 73.29,76.61 73.34,76.62 73.39,76.65 73.43,76.68 73.47,76.71 73.5,76.76 73.52,76.8 73.54,76.85 73.55,76.9 73.55,76.96 73.54,77.01 73.52,77.06 73.5,77.1 73.47,77.15 73.43,77.18 73.39,77.21 73.34,77.24 73.29,77.25 73.24,77.26 73.19,77.26 73.14,77.25 73.09,77.24 73.04,77.21 73,77.18 72.97,77.15 72.94,77.1 72.91,77.06 72.9,77.01 72.89,76.96 70.48,76.96 70.48,83.28 70.87,83.66 71.87,83.66
GND on IN1 (solid shape): 3.99,85.14 4.35,84.74 4.89,84.72 4.92,84.73 5.46,84.19 5.52,84.19 5.73,83.98 6.62,83.98 7,83.79 7.34,83.54 7.65,83.54 9.08,82.11 9.08,80.54 7.16,78.62 0.33,78.62 0.2,78.75 0.2,82.97 0.24,83.23 0.54,83.79 0.6,84.17 0.6,84.37 0.84,84.94 1.4,85.17 3.98,85.17
GND on IN1 (solid shape): 16.68,39.16 16.68,31.69 16.18,31.19 13.6,31.19 13.6,32.75 13.02,33.44 12.24,32.99 12.23,32.95 9.2,32.95 9.01,32.92 8.84,32.81 8.72,32.68 8.69,32.66 8.65,32.65 4.1,32.65 3.54,32.89 3.3,33.45 3.3,37.35 3.54,37.91 4.1,38.15 8.65,38.15 8.69,38.14 8.72,38.12 8.84,37.99 9.01,37.88 9.2,37.85 12.23,37.85 12.24,37.81 13.02,37.36 13.6,38.05 13.6,39.78 16.05,39.78
GND on IN1 (solid shape): 16.59,100.35 16.59,100.24 16.07,99.72 16.07,97.37 15.31,96.61 15.29,96.61 15.03,96.52 14.94,96.26 14.94,96.24 13.33,94.63 9.53,94.63 9.27,94.9 7.89,94.9 7.07,94.08 5.35,94.08 5.35,94.33 4.77,95.02 3.99,94.56 3.98,94.53 1.4,94.53 0.84,94.76 0.6,95.32 0.6,95.53 0.54,95.91 0.24,96.47 0.2,96.72 0.2,97.7 0.44,98.26 1,98.5 1.1,98.5 1.6,98.7 1.8,99.2 1.8,100.3 1.89,100.51 2.1,100.6 16.34,100.6
GND on IN1 (solid shape): 12.62,61.6 13.63,61.6 13.89,61.33 13.89,60.83 11.95,58.89 11.95,54.31 13.01,53.24 13.01,53.06 12.98,52.98 12.91,52.95 12.5,52.83 12.24,52.49 12.23,52.45 9.2,52.45 9.01,52.42 8.84,52.31 8.72,52.18 8.69,52.16 8.65,52.15 4.1,52.15 3.54,52.39 3.3,52.95 3.3,53.6 3.54,54.16 4.1,54.4 5.6,54.4 6.45,54.75 6.8,55.6 6.8,56.6 6.45,57.45 5.6,57.8 1,57.8 0.44,58.04 0.2,58.6 0.2,59.6 0.44,60.16 1,60.4 10,60.4 10.69,60.98 10.24,61.76 10.2,61.77 10.2,62.12 12.1,62.12
GND on IN1 (solid shape): outline of 192 points within 39.55,7.9 48,17.13
GND on IN1 (solid shape): 312.62,54.99 312.73,55.01 312.8,54.92 312.8,54.8 313.38,54.11 314.16,54.56 314.17,54.6 318.69,54.6 322.62,54.6 323.18,54.36 323.41,53.8 323.41,53.15 323.18,52.59 322.62,52.35 320.8,52.35 319.95,52 319.6,51.15 319.6,50.15 319.95,49.3 320.8,48.95 325.8,48.95 326.36,48.71 326.6,48.15 326.6,33.78 326.4,33.26 325.9,32.99 325.53,32.89 325.22,32.67 323.54,32.67 323.53,32.67 320.93,32.67 320.93,33.61 321.39,34.07 323.42,34.07 323.75,33.74 325.64,33.74 326.09,34.18 326.09,44.24 324.21,46.12 323.97,46.12 323.9,46.12 323.83,46.12 323,46.12 320.68,48.44 319.55,48.98 319.09,50.15 319.09,50.57 313.66,50.57 312.6,51.64 312.6,54.97
GND on IN1 (solid shape): 18.88,17.58 18.88,15.87 18.82,15.78 18.72,15.79 17.02,14.9 18.72,14.01 18.82,14.02 18.88,13.93 18.88,13.3 18.83,13.29 18.41,13.05 18.25,12.6 18.25,8.7 18.01,8.14 17.45,7.9 16.44,7.9 16.21,7.94 16,8.03 14.1,8.6 12.2,8.03 11.99,7.94 11.76,7.9 10,7.9 9.15,7.55 8.8,6.7 8.8,5.3 8.56,4.74 8,4.5 1,4.5 0.44,4.74 0.2,5.3 0.2,15.85 0.44,16.41 1,16.65 2.1,16.65 2.95,17 3.54,18.41 4.1,18.65 8.65,18.65 8.69,18.64 8.72,18.62 8.84,18.49 9.01,18.38 9.2,18.35 12.23,18.35 12.24,18.31 13.02,17.86 13.6,18.55 13.6,20.02 16.43,20.02
GND on IN1 (solid shape): outline of 686 points within 7.2,83.84 24.46,93.77
GND on IN1 (solid shape): outline of 321 points within 39.37,0.25 326.15,24.91
GND on IN1 (solid shape): outline of 257 points within 0.25,52.99 326.15,118.8
GND on IN2 (solid shape): 72.58,82.96 73.44,82.96 73.9,82.5 73.9,79.71 72.84,78.64 70.49,78.64 70.3,78.83 70.3,83.15 70.87,83.72 71.82,83.72
GND on IN2 (solid shape): 69.23,75.68 69.23,70.85 68.58,70.2 66.14,70.2 65.71,70.63 65.71,75.11 66.57,75.97 68.95,75.97
GND on IN2 (solid shape): 63.3,68 66.81,68 67.57,67.24 67.57,64.81 66.67,63.92 58.27,63.92 58.11,64.08 58.11,66.57 58.82,67.27 59.39,67.27 60.15,68.03 63.27,68.03
GND on IN2 (solid shape): 326.2,99.6 325.96,99.04 325.4,98.8 314.88,98.8 314.88,100.22 315.89,101.23 326.2,101.23
GND on IN2 (solid shape): 10.72,80.47 10.72,77.45 11.44,76.73 12.23,76.73 12.98,75.98 12.98,74.69 12.64,74.35 10.2,74.35 10.2,74.83 10.24,74.84 10.69,75.62 10,76.2 1,76.2 0.44,76.44 0.2,77 0.2,78.43 7.28,78.43 9.61,80.76 10.43,80.76
GND on IN2 (solid shape): 3.99,85.14 4.35,84.74 4.89,84.72 4.92,84.73 5.46,84.19 5.52,84.19 5.73,83.98 6.62,83.98 7,83.79 7.34,83.54 7.65,83.54 9.08,82.11 9.08,80.54 7.16,78.62 0.33,78.62 0.2,78.75 0.2,82.97 0.24,83.23 0.54,83.79 0.6,84.17 0.6,84.37 0.84,84.94 1.4,85.17 3.98,85.17
GND on IN2 (solid shape): 16.68,39.16 16.68,31.69 16.18,31.19 13.6,31.19 13.6,32.75 13.02,33.44 12.24,32.99 12.23,32.95 9.2,32.95 9.01,32.92 8.84,32.81 8.72,32.68 8.69,32.66 8.65,32.65 4.1,32.65 3.54,32.89 3.3,33.45 3.3,37.35 3.54,37.91 4.1,38.15 8.65,38.15 8.69,38.14 8.72,38.12 8.84,37.99 9.01,37.88 9.2,37.85 12.23,37.85 12.24,37.81 13.02,37.36 13.6,38.05 13.6,39.78 16.05,39.78
GND on IN2 (solid shape): 16.59,100.35 16.59,100.24 16.07,99.72 16.07,97.37 15.31,96.61 15.29,96.61 15.03,96.52 14.94,96.26 14.94,96.24 14.9,96.2 13.05,96.2 12.05,95.98 11.05,96.2 8.85,96.2 7.25,94.6 7.24,94.55 7.2,94.41 7.11,94.29 7.08,94.23 7.06,94.17 7.03,94.1 6.96,94.08 5.35,94.08 5.35,94.33 4.77,95.02 3.99,94.56 3.98,94.53 1.4,94.53 0.84,94.76 0.6,95.32 0.6,95.53 0.54,95.91 0.24,96.47 0.2,96.72 0.2,97.7 0.44,98.26 1,98.5 1.1,98.5 1.6,98.7 1.8,99.2 1.8,100.3 1.89,100.51 2.1,100.6 16.34,100.6
GND on IN2 (solid shape): 13.89,61.33 13.89,61.17 11.74,59.02 11.74,56.01 11.95,55.81 11.95,54.31 13.01,53.24 13.01,53.06 12.98,52.98 12.91,52.95 12.5,52.83 12.24,52.49 12.23,52.45 9.2,52.45 9.01,52.42 8.84,52.31 8.72,52.18 8.69,52.16 8.65,52.15 4.1,52.15 3.54,52.39 3.3,52.95 3.3,53.6 3.54,54.16 4.1,54.4 5.6,54.4 6.45,54.75 6.8,55.6 6.8,56.6 6.45,57.45 5.6,57.8 1,57.8 0.44,58.04 0.2,58.6 0.2,59.6 0.44,60.16 1,60.4 10,60.4 10.69,60.98 10.24,61.76 10.2,61.77 10.2,62.12 13.11,62.12
GND on IN2 (solid shape): outline of 192 points within 39.55,7.9 48,17.13
GND on IN2 (solid shape): 312.62,54.99 312.73,55.01 312.8,54.92 312.8,54.8 313.38,54.11 314.16,54.56 314.17,54.6 318.69,54.6 322.62,54.6 323.18,54.36 323.41,53.8 323.41,53.15 323.18,52.59 322.62,52.35 320.8,52.35 319.95,52 319.6,51.15 319.6,50.15 319.95,49.3 320.8,48.95 325.8,48.95 326.36,48.71 326.6,48.15 326.6,33.78 326.4,33.26 325.9,32.99 325.54,32.89 325.22,32.67 320.83,32.67 320.83,33.22 321.65,34.04 323.62,34.04 324.22,33.45 325.58,33.45 325.71,33.48 325.84,33.5 326.02,33.59 326.09,33.78 326.09,44.47 323.47,47.08 322.52,47.08 321.16,48.44 320.8,48.44 319.59,48.94 319.09,50.15 319.09,50.57 313.66,50.57 312.6,51.64 312.6,54.97
GND on IN2 (solid shape): 18.88,17.58 18.88,15.87 18.82,15.78 18.72,15.79 17.02,14.9 18.72,14.01 18.82,14.02 18.88,13.93 18.88,13.3 18.83,13.29 18.41,13.05 18.25,12.6 18.25,8.7 18.01,8.14 17.45,7.9 16.44,7.9 16.21,7.94 16,8.03 14.1,8.6 12.2,8.03 11.99,7.94 11.76,7.9 10,7.9 9.15,7.55 8.8,6.7 8.8,5.3 8.56,4.74 8,4.5 1,4.5 0.44,4.74 0.2,5.3 0.2,15.85 0.44,16.41 1,16.65 2.1,16.65 2.95,17 3.54,18.41 4.1,18.65 8.65,18.65 8.69,18.64 8.72,18.62 8.84,18.49 9.01,18.38 9.2,18.35 12.23,18.35 12.24,18.31 13.02,17.86 13.6,18.55 13.6,20.02 16.43,20.02
GND on IN2 (solid shape): outline of 581 points within 81.92,78.8 95.4,82.43
GND on IN2 (solid shape): outline of 317 points within 39.37,0.25 326.15,24.91
GND on IN2 (solid shape): outline of 257 points within 0.25,52.99 326.15,118.8
GND on IN2 (solid shape): outline of 25383 points within 45.7,24.78 192.89,77.82
GND on IN3 (solid shape): 67.57,67.24 67.57,64.81 66.59,63.83 58.13,63.83 57.95,64.01 57.95,66.62 58.61,67.27 61.9,67.27 62.63,68 66.81,68
GND on IN3 (solid shape): 72.71,82.99 74.2,82.99 75.06,82.14 75.06,78.89 74.6,78.43 71.82,78.43 71.78,78.47 70.53,78.47 70.42,78.58 70.42,79.6 71.25,80.42 71.25,83.34 71.28,83.38 71.28,83.5 71.5,83.72 71.98,83.72
GND on IN3 (solid shape): 326.2,99.6 325.96,99.04 325.4,98.8 314.88,98.8 314.88,100.22 315.89,101.23 326.2,101.23
GND on IN3 (solid shape): 73.1,75.11 73.1,72.62 72.62,72.14 69.89,72.14 69.54,71.79 66.61,71.79 66.32,72.07 66.32,72.49 65.92,72.89 65.92,74.23 70.04,74.23 70.04,73.28 70.3,73.02 70.74,73.02 70.93,73.22 70.93,74.23 70.68,74.49 70.3,74.49 70.04,74.23 65.92,74.23 65.92,74.52 67.4,76 69.14,76 69.31,75.82 70.77,75.82 71.06,76.1 72.1,76.1
GND on IN3 (solid shape): 10.72,80.47 10.72,77.45 11.44,76.73 12.23,76.73 12.98,75.98 12.98,74.69 12.64,74.35 10.2,74.35 10.2,74.83 10.24,74.84 10.69,75.62 10,76.2 1,76.2 0.44,76.44 0.2,77 0.2,78.43 7.28,78.43 9.61,80.76 10.43,80.76
GND on IN3 (solid shape): 3.99,85.14 4.35,84.74 4.89,84.72 4.92,84.73 5.46,84.19 5.52,84.19 5.73,83.98 6.62,83.98 7,83.79 7.34,83.54 7.65,83.54 9.08,82.11 9.08,80.54 7.16,78.62 0.33,78.62 0.2,78.75 0.2,82.97 0.24,83.23 0.54,83.79 0.6,84.17 0.6,84.37 0.84,84.94 1.4,85.17 3.98,85.17
GND on IN3 (solid shape): 16.68,39.16 16.68,31.69 16.18,31.19 13.6,31.19 13.6,32.75 13.02,33.44 12.24,32.99 12.23,32.95 9.2,32.95 9.01,32.92 8.84,32.81 8.72,32.68 8.69,32.66 8.65,32.65 4.1,32.65 3.54,32.89 3.3,33.45 3.3,37.35 3.54,37.91 4.1,38.15 8.65,38.15 8.69,38.14 8.72,38.12 8.84,37.99 9.01,37.88 9.2,37.85 12.23,37.85 12.24,37.81 13.02,37.36 13.6,38.05 13.6,39.78 16.05,39.78
GND on IN3 (solid shape): 16.59,100.35 16.59,100.24 16.07,99.72 16.07,97.37 15.31,96.61 15.29,96.61 15.03,96.52 14.94,96.26 14.94,96.24 13.33,94.63 9.53,94.63 9.27,94.9 7.89,94.9 7.07,94.08 5.35,94.08 5.35,94.33 4.77,95.02 3.99,94.56 3.98,94.53 1.4,94.53 0.84,94.76 0.6,95.32 0.6,95.53 0.54,95.91 0.24,96.47 0.2,96.72 0.2,97.7 0.44,98.26 1,98.5 1.1,98.5 1.6,98.7 1.8,99.2 1.8,100.3 1.89,100.51 2.1,100.6 16.34,100.6
GND on IN3 (solid shape): 13.89,61.33 13.89,60.83 11.95,58.89 11.95,54.31 13.01,53.24 13.01,53.06 12.98,52.98 12.91,52.95 12.5,52.83 12.24,52.49 12.23,52.45 9.2,52.45 9.01,52.42 8.84,52.31 8.72,52.18 8.69,52.16 8.65,52.15 4.1,52.15 3.54,52.39 3.3,52.95 3.3,53.6 3.54,54.16 4.1,54.4 5.6,54.4 6.45,54.75 6.8,55.6 6.8,56.6 6.45,57.45 5.6,57.8 1,57.8 0.44,58.04 0.2,58.6 0.2,59.6 0.44,60.16 1,60.4 10,60.4 10.69,60.98 10.24,61.76 10.2,61.77 10.2,62.12 13.11,62.12
GND on IN3 (solid shape): outline of 192 points within 39.55,7.9 48,17.13
GND on IN3 (solid shape): 312.62,54.99 312.73,55.01 312.8,54.92 312.8,54.8 313.38,54.11 314.16,54.56 314.17,54.6 318.69,54.6 322.62,54.6 323.18,54.36 323.41,53.8 323.41,53.15 323.18,52.59 322.62,52.35 320.8,52.35 319.95,52 319.6,51.15 319.6,50.15 319.95,49.3 320.8,48.95 325.8,48.95 326.36,48.71 326.6,48.15 326.6,33.78 326.4,33.26 325.9,32.99 325.52,32.88 325.2,32.65 320.94,32.65 320.94,33.51 321.52,34.08 323.39,34.08 323.99,33.49 325.75,33.49 325.84,33.5 326.02,33.59 326.09,33.78 326.09,44.48 323.5,47.07 322.51,47.07 321.14,48.44 320.8,48.44 319.59,48.94 319.09,50.15 319.09,50.57 313.66,50.57 312.6,51.64 312.6,54.97
GND on IN3 (solid shape): 18.88,17.58 18.88,15.87 18.82,15.78 18.72,15.79 17.02,14.9 18.72,14.01 18.82,14.02 18.88,13.93 18.88,13.3 18.83,13.29 18.41,13.05 18.25,12.6 18.25,8.7 18.01,8.14 17.45,7.9 16.44,7.9 16.21,7.94 16,8.03 14.1,8.6 12.2,8.03 11.99,7.94 11.76,7.9 10,7.9 9.15,7.55 8.8,6.7 8.8,5.3 8.56,4.74 8,4.5 1,4.5 0.44,4.74 0.2,5.3 0.2,15.85 0.44,16.41 1,16.65 2.1,16.65 2.95,17 3.54,18.41 4.1,18.65 8.65,18.65 8.69,18.64 8.72,18.62 8.84,18.49 9.01,18.38 9.2,18.35 12.23,18.35 12.24,18.31 13.02,17.86 13.6,18.55 13.6,20.02 16.43,20.02
GND on IN3 (solid shape): outline of 1068 points within 125.42,29.62 144.92,33.75
GND on IN3 (solid shape): outline of 1265 points within 5.17,84.3 23.61,93.77
GND on IN3 (solid shape): outline of 320 points within 39.37,0.25 326.15,24.91
GND on IN3 (solid shape): outline of 257 points within 0.25,52.99 326.15,118.8
GND on IN3 (solid shape): outline of 2725 points within 48.62,25.01 82.57,35.97
GND on GND2 (solid shape): 50.92,19.27 50.48,19.32 50.11,19.56 49.96,19.71 47.34,19.71 47.34,17.09 47.91,16.53 48.1,16.26 48.19,15.95 45.38,15.95 45.38,21.15 50.92,21.15
GND on GND2 (solid shape): 191.04,19.83 190.56,19.83 190.19,20.2 190.05,20.7 190.05,21.6 189.51,22.91 188.2,23.45 187.2,23.45 185.89,22.91 185.35,21.6 185.35,20.7 185.21,20.2 184.84,19.83 184.34,19.83 184.34,24.5 191.04,24.5
GND on GND2 (solid shape): 66.77,19.7 66.75,19.7 66.04,19.99 65.75,20.7 65.75,20.85 65.21,22.16 63.9,22.7 62.9,22.7 61.59,22.16 61.05,20.85 61.05,20.7 60.8,20.03 60.16,19.71 60.16,23.48 66.77,23.48
GND on GND2 (solid shape): 286.51,19.48 286.37,19.57 286.22,19.64 285.73,20.01 285.55,20.59 285.55,21.3 283.7,23.15 281.85,21.3 281.85,20.7 281.56,19.99 280.85,19.7 280.85,23.97 286.51,23.97
GND on GND1: outline of 459 points within 0.26,0.26 326.54,118.8 ; 1 cut-out
GND on VCC: 290.37,1.17 290.37,16.39 290.2,17.22 289.73,17.92 289.62,18.03 291.62,20.03 300.61,20.03 300.61,16.44 304.82,12.22 306.05,12.22 306.88,13.05 310.26,13.05 310.82,12.49 325.23,12.48 325.23,1.17 307.97,1.17 307.5,2.11 307.42,2.54 307.58,2.94 305.25,7.62 302.92,2.94 303.08,2.54 303,2.11 302.53,1.17
GND on VCC: 298.18,30.19 297.06,31.32 297.06,52.19 304.04,59.17 304.04,77.23 304.06,77.25 307.38,77.25 309.61,79.47 309.93,79.47 309.93,79.05 310.42,77.87 311.6,77.38 311.73,77.38 311.73,74.8 312.22,73.62 313.4,73.13 325.23,73.13 325.23,71.57 324.62,71.57 323.14,70.99 322.45,69.57 314.69,69.57 312.87,69.95 311.83,68.4 311.83,54.8 312.87,53.25 314.69,53.63 322.45,53.63 322.45,53.32 320.8,53.32 319.27,52.68 318.63,51.15 318.63,50.15 319.27,48.62 320.8,47.98 325.63,47.98 325.63,33.93 324.37,33.18 323.88,31.8 323.88,30.27 322.2,31.95 309.68,31.95 308.93,32.7 308.93,34.11 308.08,34.96 306.69,34.96 306.64,35 306.64,38.24 303.89,40.99 301.78,40.99 301.44,40.65 301.44,34.79 301.65,34.58 302.43,34.58 302.77,34.91 302.77,35.87 303.07,36.16 303.74,36.16 303.91,35.99 303.91,34.36 303.87,34.32 303.05,34.32 302.52,33.79 302.52,30.43 302.28,30.19 ; 1 cut-out
GND on VCC: 103.4,62.3 103.98,62.28 103.96,62.86 112.18,71.09 126.11,71.09 126.11,67.3 126.9,66.52 145.16,66.52 145.16,65.14 147.34,62.96 158.22,62.96 159.49,64.23 168.04,64.23 168.28,64 168.28,54.94 164.23,50.89 52.69,50.89 50.04,53.54 50.04,63.36 51.29,64.61 57.38,64.61 58.04,65.27 58.04,67.55 58.15,67.66 65,67.66 66.04,68.7 66.04,75.05 66.4,75.41 71.1,75.41 71.63,75.94 71.63,77.8 71.1,78.33 48.77,78.33 48.77,91.18 55.73,98.14 66.78,98.14 66.91,98.27 83.19,98.27 83.19,85.38 82.51,85.38 81.79,84.66 81.79,79.45 80.77,78.43 80.77,76.78 79.12,75.13 79.12,69.67 69.37,59.91 56.16,59.91 54.87,58.62 54.87,53.46 55.27,53.05 94.15,53.05
GND on VCC: 1.57,95.49 1.57,95.53 1.47,96.18 1.17,96.78 1.17,97.53 2.3,98.04 2.77,99.2 2.77,99.63 13.85,99.63 13.85,98.09 12.42,96.67 6.17,96.67 5.35,95.84 4.35,95.97 3.46,95.49
GND on VCC: 253.67,91.92 253.67,106.88 254.2,106.88 255.73,107.52 256.37,109.05 256.37,115.41 257.52,116.18 257.97,117.5 257.97,117.88 281.03,117.88 281.03,117.2 281.67,115.67 283.2,115.03 287.13,115.03 287.13,114.2 287.77,112.67 289.3,112.03 316.16,112.03 317.86,111.68 319.28,110.7 320,110.2 320.85,110.03 325.23,110.03 325.23,99.77 313.4,99.77 312.22,99.28 311.73,98.1 311.73,95.52 311.6,95.52 310.45,95.06 309.93,93.95 307.7,93.95 305.95,95.7 305.95,97.99 304.27,99.66 299.87,99.66 298.96,98.75 298.96,94.84 280.19,94.84 277.26,91.92
GND on VCC: outline of 83 points within 1.17,5.47 47.03,85.11 ; 2 cut-outs
GND on GND2: outline of 460 points within 0.26,0.26 326.54,118.8 ; 1 cut-out
GND on GND2: 159.07,21.37 159.07,25.08 166.23,25.08 166.23,22.7 165.77,22.7 165.28,22.83 164.91,23.18 164.18,23.89 163.2,24.15 162.2,24.15 160.79,23.56 160.2,22.15 160.2,21.37
GNDA on TOP (solid shape): 309.81,31.01 309.81,27.04 308.84,26.08 307.98,26.08 306.54,27.51 305.89,27.51 305.8,27.6 305.8,27.96 306.2,28.36 306.2,30.93 307.04,30.93 308.46,32.35
GNDA on GND1, GND2: 305.03,12.73 301.12,16.65 301.12,22.17 296.8,26.49 296.8,28.25 298.24,29.69 302.49,29.69 303.02,30.22 303.02,33.58 303.26,33.81 304.08,33.81 304.42,34.15 304.42,36.2 303.95,36.67 302.86,36.67 302.26,36.08 302.26,35.13 302.22,35.08 301.94,35.08 301.94,40.44 301.99,40.48 303.68,40.48 306.14,38.03 306.14,34.79 306.47,34.45 307.87,34.45 308.42,33.9 308.42,32.78 308.38,32.74 308.38,32.53 309.47,31.44 321.99,31.44 324.25,29.18 324.15,29.16 324.05,29.16 320.8,29.16 319.91,28.79 319.54,27.9 319.54,26.9 319.91,26.01 320.8,25.64 324.7,25.64 325.23,25.43 325.45,24.9 325.45,23.95 325.23,23.42 324.7,23.2 312.8,23.2 312.06,22.58 312.54,21.74 312.54,16.36 312.06,15.52 312.8,14.9 324.7,14.9 325.23,14.68 325.45,14.15 325.45,14.1 325.56,13.58 325.88,13.15 325.96,13.08 326.02,13 311.03,13 310.47,13.56 306.67,13.56 305.84,12.73
GNDA on VCC: 305.03,12.73 301.12,16.65 301.12,22.17 296.8,26.49 296.8,28.25 298.24,29.69 302.49,29.69 303.02,30.22 303.02,33.58 303.26,33.81 304.08,33.81 304.42,34.15 304.42,36.2 303.95,36.67 302.86,36.67 302.26,36.08 302.26,35.13 302.22,35.08 301.94,35.08 301.94,40.44 301.99,40.48 303.68,40.48 306.14,38.03 306.14,34.79 306.47,34.45 307.87,34.45 308.42,33.9 308.42,32.78 308.38,32.74 308.38,32.53 309.47,31.44 321.99,31.44 323.36,30.07 320.8,30.07 319.27,29.43 318.63,27.9 318.63,26.9 319.27,25.37 320.8,24.73 324.53,24.73 324.53,24.12 317.76,24.12 316.97,23.34 316.11,23.34 315.32,24.12 312.8,24.12 311.25,23.08 311.63,21.26 311.63,16.84 311.25,15.02 312.8,13.98 324.53,13.98 324.63,13.47 324.84,12.99 311.03,13 310.47,13.56 306.67,13.56 305.84,12.73
VCCSA_B+ on TOP (solid shape): 75.45,90.91 75.45,89.27 75.36,89.19 73.92,89.19 73.84,89.26 73.84,90.28 73.57,90.54 73.57,90.82 73.71,90.96 75.4,90.96
VCCSA_B+ on BOTTOM (solid shape): 79.11,90.76 79.11,89.33 78.32,88.54 74.25,88.54 73.76,89.02 73.76,90.66 73.87,90.76 75.06,90.76 75.41,90.4 75.41,89.38 75.67,89.12 76.65,89.12 76.88,89.35 76.88,90.71 77.23,91.07 78.81,91.07
VIN_1.8VALW on BOTTOM (solid shape): 169.32,103.91 169.32,102.16 169.21,102.05 167.41,102.05 167.22,102.24 167.22,104.07 167.44,104.29 168.95,104.29
VIN_1V_PRIM on TOP (solid shape): 177.21,114.1 177.21,113.14 177.01,112.95 175.31,112.95 175.16,113.1 175.16,114.1 175.33,114.27 177.04,114.27
VIN_1V_PRIM on BOTTOM (solid shape): 177.15,114.29 177.15,113.02 177.08,112.95 173.73,112.95 173.28,112.5 172.15,112.5 172.05,112.6 172.05,114.39 172.34,114.69 176.76,114.69
VIN_1VS_VCCIO on TOP (solid shape): 190.69,112.11 190.69,107.75 190.04,107.09 189.42,107.09 189.17,107.35 188,107.35 187.81,107.54 187.81,108.78 188.47,109.44 188.47,109.67 188.9,109.67 188.9,109.62 188.91,109.57 188.93,109.52 188.95,109.47 188.98,109.43 189.02,109.39 189.06,109.36 189.11,109.34 189.15,109.32 189.21,109.31 189.26,109.31 189.31,109.32 189.36,109.34 189.41,109.36 189.45,109.39 189.48,109.43 189.51,109.47 189.54,109.52 189.55,109.57 189.56,109.62 189.56,109.67 189.55,109.72 189.54,109.77 189.51,109.82 189.48,109.86 189.45,109.9 189.41,109.93 189.36,109.95 189.31,109.97 189.26,109.98 189.21,109.98 189.15,109.97 189.11,109.95 189.06,109.93 189.02,109.9 188.98,109.86 188.95,109.82 188.93,109.77 188.91,109.72 188.9,109.67 188.47,109.67 188.47,112.3 188.66,112.49 190.31,112.49
VIN_1VS_VCCIO on BOTTOM (solid shape): 188.56,110.6 188.56,109.17 188.88,108.85 189.46,108.85 189.63,108.68 189.63,107.32 189.58,107.27 189.1,107.27 189.1,107.27 188.81,107.27 188.59,107.04 188.59,107.03 188.57,107.01 188.57,105.76 188.43,105.62 187.9,105.62 187.74,105.78 187.74,108.05 187.74,108.05 187.51,108.28 187.51,109.24 187.29,109.47 187.29,110.76 187.4,110.87 188.29,110.87
VIN_VCC_EDRAM on TOP (solid shape): 46.89,61.63 46.89,59.32 47.21,58.99 49.1,58.99 49.17,58.93 49.17,57.82 49.06,57.72 48.59,57.72 47.86,56.99 47.86,56.49 48.29,56.06 49,56.06 49.12,55.94 49.12,52.92 49.01,52.81 46.86,52.81 46.52,53.15 46.52,57.78 46.34,57.96 45.7,58.6 45.7,61.63 46.01,61.93 46.59,61.93
VIN_VCC_EOPIO on TOP (solid shape): 46.17,49.44 46.17,48.01 46.25,47.93 47.54,47.93 47.63,47.84 47.63,46.76 47.53,46.67 47.28,46.67 47.07,46.46 47.07,45.31 47.37,45.01 47.37,41.82 47.11,41.55 46.31,41.55 46.04,41.82 46.04,43.52 46.05,43.53 46.07,43.64 46.05,43.76 46.04,43.76 46.04,44.39 46.05,44.47 46.04,44.55 46.04,45.98 45.63,46.39 45.23,46.39 45.11,46.51 45.11,49.59 45.25,49.74 45.87,49.74
+AC_IN on TOP (solid shape): 39.69,101.95 39.69,99.85 39.12,99.28 38.61,99.28 38.36,99.54 38.36,102.08 38.61,102.33 39.31,102.33
+AC_IN on TOP (solid shape): outline of 229 points within 39.37,103.73 54.23,107.75
+BL_PWR_SRC on TOP (solid shape): 65.16,109.62 65.16,108.68 64.32,107.83 64.29,107.84 63.94,107.69 63.96,107.31 63.99,107.28 63.88,107.17 57.18,107.17 56.86,107.49 56.86,107.6 56.88,107.62 57.03,107.98 56.86,108.33 56.86,108.76 57,108.9 60.84,108.9 60.97,109.04 62.64,109.04 63.6,109.99 64.78,109.99
+BL_PWR_SRC on BOTTOM (solid shape): outline of 162 points within 61.91,108.64 66.29,117.78
+CHARGER_SRC on TOP (solid shape): 54.36,86.07 54.36,81.5 54.61,81.25 56.64,81.25 56.9,80.99 56.9,79.61 56.82,79.39 56.9,79.18 56.9,78.95 56.82,78.73 56.9,78.52 56.9,78.2 56.64,77.95 56.01,77.95 55.76,78.2 55.76,78.71 55.12,79.34 52.45,79.34 51.69,80.1 50.8,80.1 50.68,80.23 50.68,80.82 50.78,81.1 50.68,81.37 50.68,82.17 50.79,82.47 50.68,82.77 50.68,83.23 50.74,83.32 50.85,83.3 51.44,83.51 50.85,83.72 50.74,83.69 50.68,83.79 50.68,84.8 51.06,85.18 51.31,85.18 51.6,85.03 51.89,85.18 53.09,85.18 53.6,85.69 53.6,85.95 53.85,86.2 54.23,86.2
+CHARGER_SRC on BOTTOM (solid shape): outline of 127 points within 44.58,75.06 56.77,84.55
+DC_IN on BOTTOM (solid shape): 40.87,68.33 40.87,67.54 41.22,67.19 41.22,66.47 41.41,66.27 41.73,66.27 41.77,66.3 41.77,66.31 41.87,66.38 41.94,66.48 41.95,66.48 41.98,66.52 41.98,67.43 42.03,67.57 42.05,67.7 42.05,68.04 42.44,68.42 42.65,68.63 43.15,68.63 43.33,68.57 43.51,68.62 43.52,68.63 43.61,68.63 43.95,68.29 43.95,63.82 43.73,63.6 42.03,63.6 41.81,63.82 41.75,63.82 40.15,65.43 40.02,65.43 40.01,65.43 39.93,65.47 39.85,65.48 39.78,65.48 39.65,65.61 39.65,65.97 39.78,66.1 39.93,66.1 40.26,66.06 40.46,66.31 40.46,66.33 40.54,66.41 40.54,66.65 39.44,67.76 39.44,68.75 39.55,68.86 40.34,68.86
+DC_IN on BOTTOM (solid shape): outline of 108 points within 49.66,98.44 56.2,104.31
+DC_IN on IN2 (solid shape): outline of 151 points within 39.02,104.11 43.06,106.67
+DC_IN_SS on BOTTOM (solid shape): outline of 171 points within 43.31,90.14 55.12,98.2
+DCIN_JACK on BOTTOM (solid shape): 47.71,105.67 47.71,104.65 47.45,104.39 46.66,104.39 46.37,104.1 46.37,102.54 46.69,102.22 48.57,102.22 48.58,102.22 49.26,102.22 49.47,102.01 49.47,100.52 50.93,99.06 51.21,99.06 51.28,98.98 51.33,98.92 51.39,98.87 51.68,98.58 51.68,96.58 51.53,96.43 49.7,96.43 49.31,96.82 49.31,97.76 48.26,98.8 46,98.8 46,105.34 46.59,105.93 47.45,105.93
+EC_DEBUG_VCC on BOTTOM (solid shape): 304.41,74.12 304.41,73.41 303.98,72.98 302.95,72.98 302.85,73.08 302.85,73.85 303,74.01 303.44,74.01 303.45,74.01 303.6,74.01 303.74,74.15 304.39,74.15
+EDP_VDD on TOP (solid shape): 70.89,114.04 70.89,113.53 70.92,113.51 71.38,113.51 72.14,112.74 72.14,111.16 72.11,111.11 72.05,111.12 72.04,111.14 70.95,111.14 70.87,111.22 70.87,112.49 70.23,113.12 70.23,113.38 70.36,113.51 70.66,113.51 70.72,113.56 70.72,114.04 70.74,114.06 70.87,114.06
+LCDVDD on TOP (solid shape): 72.77,117.44 72.77,116.17 72.65,116.05 72.01,116.05 71.76,115.79 71.76,115.6 71.73,115.45 71.75,115.34 71.76,115.33 71.76,114.01 71.38,113.63 71.1,113.63 71.05,113.68 71.05,114.19 71.02,114.22 70.59,114.22 70.56,114.19 70.56,113.71 70.49,113.63 70.23,113.63 69.98,113.89 69.98,114.27 70.61,114.9 70.61,115.52 70.78,115.81 70.61,116.09 70.61,116.17 70.49,116.3 69.99,116.3 69.85,116.43 69.85,117.57 69.98,117.7 72.52,117.7
+PBATT on BOTTOM (solid shape): 215.32,40.74 215.32,38.53 208.22,38.53 207.99,38.75 207.99,40.81 208.27,41.09 214.97,41.09
+PWR_SRC on TOP (solid shape): 44.75,59.84 44.8,59.78 44.88,59.72 45,59.6 45,58.71 44.96,58.66 44.95,58.66 44.67,58.38 44,58.38 43.59,57.98 41.65,57.98 41.32,58.31 41.32,59.42 41.74,59.84
+PWR_SRC on TOP (solid shape): 43.56,48.86 43.56,47.85 43.7,47.71 43.89,47.71 44.05,47.59 44.26,47.58 44.29,47.59 44.4,47.48 44.4,46.65 44.4,46.64 44.4,46.33 44.24,46.17 43.01,46.17 42.72,45.88 41.67,45.88 41.02,46.53 41.02,47.68 41.04,47.7 41.04,48.76 41.4,49.12 43.31,49.12
+PWR_SRC on TOP (solid shape): outline of 304 points within 62.6,78.45 70.34,95.97
+PWR_SRC on BOTTOM (solid shape): 101.97,116.72 101.97,114.85 102.57,114.26 102.57,112.33 102.21,111.97 101.86,111.97 100.87,112.96 100.87,116.77 100.95,116.86 101.83,116.86
+PWR_SRC on BOTTOM (solid shape): 194.31,97 194.31,94.58 194.06,94.33 193.17,94.33 192.79,94.71 192.79,97 193.17,97.38 193.93,97.38
+PWR_SRC on BOTTOM (solid shape): 184.46,104.54 184.46,104.08 184.42,104.05 183.97,104.05 183.97,103.52 183.97,103.51 183.72,103.51 183.72,104.05 183.17,104.05 183.17,103.51 182.93,103.51 182.92,103.52 182.92,104.05 182.4,104.05 182.33,104.11 182.33,104.68 182.4,104.75 182.4,104.76 182.56,104.92 184.08,104.92
+PWR_SRC on BOTTOM (solid shape): 70.11,95.59 70.11,94.58 70.18,94.51 70.18,94.42 70.21,94.42 70.21,94.04 70.23,94.02 70.23,92.7 70.12,92.59 68.62,92.59 68.45,92.42 68.45,87.6 68.33,87.47 68.09,87.47 68.07,87.48 67.45,87.48 67.3,87.64 67.3,90.95 67.32,90.95 67.32,92.05 66.93,92.44 66.93,95.29 66.94,95.3 66.96,95.41 66.94,95.52 66.93,95.53 66.93,95.59 67.22,95.87 69.83,95.87
+PWR_SRC on BOTTOM (solid shape): outline of 2576 points within 30.91,30.93 237.72,58.83
+PWR_SRC on IN1 (solid shape): 184.45,104.71 184.45,103.52 184.79,103.18 184.84,103.18 184.84,102.7 184.52,102.38 182.58,102.38 182.26,102.7 182.26,104.35 182.89,104.98 184.18,104.98
+PWR_SRC on IN1 (solid shape): outline of 87 points within 191.48,95.09 194.4,99.13
+PWR_SRC on IN1 (solid shape): outline of 5585 points within 53.43,56.23 70.64,96.03
+PWR_SRC_AC on BOTTOM (solid shape): 54.74,86.44 54.74,84.12 54.8,84.05 54.8,83.88 54.79,83.87 54.15,83.87 54.12,83.85 54.12,83.33 54.11,83.31 53.69,83.31 53.66,83.34 53.66,83.85 53.65,83.87 52.96,83.87 52.93,83.84 52.93,83.34 52.9,83.31 52.48,83.31 52.45,83.35 52.45,83.79 52.45,83.79 52.45,83.84 52.4,83.89 50.94,83.89 50.5,83.44 50.5,83.43 50.47,83.4 50.47,82.93 50.38,82.84 50.18,82.84 50.03,82.7 48.78,82.7 48.68,82.8 48.68,84.79 48.77,84.88 48.85,84.88 48.86,84.87 49,84.87 49,84.22 49.37,83.85 49.9,83.85 50.27,84.22 50.27,84.6 50.32,84.65 51.03,84.65 51.45,85.07 51.8,85.09 51.96,85.41 52,85.66 51.87,85.88 51.87,86.32 52.02,86.47 54.71,86.47
+PWR_SRC_R on BOTTOM (solid shape): 276.05,28.84 276.05,28.09 275.51,27.55 275.51,26.71 275.27,26.47 275.14,26.47 275.07,26.53 275.07,28.6 275.45,28.98 275.91,28.98
+REGCTL_PNP10 on TOP (solid shape): 275.47,90.39 275.47,90.01 274.99,89.53 274.99,88.15 274.99,88.14 274.99,87.06 274.77,86.84 274.27,86.84 274.2,86.9 274.2,89.48 275.24,90.52 275.34,90.52
+RREF on TOP (solid shape): 293.56,50.13 296.17,50.13 296.38,50.34 296.5,50.34 296.55,50.29 296.55,49.51 296.48,49.43 295.79,49.43 295.53,49.69 292.67,49.69 292.23,50.13 292.23,50.64 292.36,50.77 292.93,50.77
+SDC_IN on TOP (solid shape): 53.81,98.47 53.81,97.25 54.07,97 54.07,96.49 53.99,96.26 54,96.02 54,95.5 54.23,95.27 54.23,95.09 54.7,94.62 54.7,94.62 54.7,94.09 54.92,93.88 54.92,92.22 54.17,91.47 51.37,91.47 49.22,93.63 48.96,93.88 47.44,93.88 47.16,94.16 47.09,94.16 47.09,98.42 47.25,98.58 53.7,98.58
+SDC_IN on BOTTOM (solid shape): 54.67,94.98 54.79,94.98 54.86,94.92 54.86,94.8 55.07,94.59 55,94.24 55.26,94.01 55.27,94 55.55,93.72 55.55,93.32 55.5,93.27 54.99,93.27 54.98,93.26 54.96,93.26 54.59,92.89 54.59,92.36 54.79,92.16 54.79,91.83 54.87,91.75 54.87,89.93 54.53,89.93 54.08,89.47 54.08,89.35 53.86,89.12 53.9,88.81 53.41,88.33 51.54,88.33 50.53,87.32 50.53,85.92 50.48,85.87 49.99,85.87 49.99,86.42 49.63,86.77 49.28,86.42 49.28,85.87 48.72,85.87 48.64,85.95 48.64,86.82 48.34,87.13 47.79,87.13 47.5,86.84 47.19,86.84 47.05,86.98 47.05,89.7 47.3,89.94 48.78,89.94 48.81,89.97 49.62,89.97 50.17,90.52 50.17,91.13 50.17,91.14 50.19,91.26 50.17,91.38 50.17,91.38 50.17,92.67 50.59,93.09 53.34,93.09 53.72,93.48 53.72,94.1 54.61,94.99 54.67,94.99
+SDREG2 on TOP (solid shape): 301.56,54.77 301.56,54.22 301.51,54.17 301.25,54.17 300.33,53.25 299.49,53.25 299.45,53.29 299.45,53.49 300.77,54.8 301.53,54.8
+TBT_SVR_IND on TOP (solid shape): 25.02,81.96 25.02,81.8 25.14,81.67 25.22,81.67 25.27,81.66 25.36,81.58 25.36,81.12 25.14,80.9 25.14,80.2 24.92,79.98 24.92,79.38 24.16,78.61 24.16,78.61 23.7,78.16 23.7,75.99 21.32,75.99 20.92,76.39 20.92,79.39 21.22,79.69 22.28,79.69 22.28,79.7 22.66,79.7 23.91,80.95 24.31,80.95 24.59,81.23 24.59,81.68 24.67,81.76 24.67,81.93 24.74,82.01 24.96,82.01
+TBT_SVR_IND on BOTTOM (solid shape): 23.29,80.36 23.29,76.85 23.09,76.66 21.36,76.66 21.06,76.96 21.06,79.94 21.62,80.5 23.15,80.5
+TBTA_VBUS on TOP (solid shape): 7.29,91.27 8.38,91.27 8.47,91.36 9.77,91.36 9.85,91.27 9.85,90.94 9.78,90.86 8.43,90.86 8.36,90.94 7.16,90.94 7.09,90.86 6.4,90.86 6.27,90.99 6.27,91.37 6.45,91.55 7.01,91.55
+TBTA_VBUS on TOP (solid shape): 7.14,88.76 8.38,88.76 8.47,88.84 9.77,88.84 9.85,88.76 9.85,88.43 9.78,88.35 8.43,88.35 8.36,88.43 7.16,88.43 6.88,88.15 6.42,88.15 6.3,88.27 6.3,88.73 6.42,88.86 7.03,88.86
+TBTA_VBUS on BOTTOM (solid shape): 10.06,88.56 10.06,87.61 9.23,87.61 8.51,88.34 8.51,88.76 8.56,88.81 9.81,88.81
+TBTA_VBUS on BOTTOM (solid shape): 11.96,84.04 14.48,84.04 14.61,83.91 14.61,81.37 14.23,80.99 12.68,80.99 12.65,81.01 12.6,81.02 12.55,81.02 12.5,81.02 12.45,81.01 12.42,80.99 10.16,80.99 9.37,81.78 9.37,82.83 9.1,83.11 12.73,83.11 12.73,83.06 12.74,83 12.75,82.95 12.78,82.91 12.81,82.87 12.84,82.83 12.89,82.8 12.93,82.78 12.98,82.76 13.03,82.75 13.08,82.75 13.14,82.76 13.19,82.78 13.23,82.8 13.27,82.83 13.31,82.87 13.34,82.91 13.36,82.95 13.38,83 13.39,83.06 13.39,83.11 13.38,83.16 13.36,83.21 13.34,83.25 13.31,83.3 13.27,83.33 13.23,83.36 13.19,83.39 13.14,83.4 13.08,83.41 13.03,83.41 12.98,83.4 12.93,83.39 12.89,83.36 12.84,83.33 12.81,83.3 12.78,83.25 12.75,83.21 12.74,83.16 12.73,83.11 9.1,83.11 8.92,83.29 8.92,84.17 9.2,84.45 11.55,84.45
+TBTA_VBUS on BOTTOM (solid shape): outline of 137 points within 13.58,93.06 18.55,98.41
+TBTA_VBUS on IN2 (solid shape): outline of 986 points within 6.15,81.65 17.24,96.1
+TBTA_VBUS on VCC: 10.47,81.65 6.32,85.81 6.32,94.33 6.18,95 5.78,95.56 6.38,96.16 12.63,96.16 14.35,97.88 14.35,99.63 17.25,99.63 17.25,94.1 14.73,91.59 12.65,91.59 11.53,90.47 11.53,81.91 11.28,81.65
+TBTA_VBUS_1 on TOP (solid shape): 32.39,58.93 32.39,58.58 32.26,58.45 31.66,58.45 31.05,59.06 30.23,59.06 30.14,59.15 30.14,59.37 30.2,59.43 31.89,59.43
+TBTA_VBUS_1 on TOP (solid shape): 26.99,59.36 26.99,59.09 27.12,58.96 27.31,58.96 27.37,58.9 27.37,58.32 26.23,57.18 26.23,57.13 26.22,57.11 26.22,55.47 26.08,55.33 24.96,55.33 24.64,55.64 24.64,57.55 25.54,58.45 25.99,58.02 26.13,58.62 26.13,58.92 26.16,58.96 26.42,58.96 26.55,59.09 26.55,59.4 26.61,59.47 26.89,59.47
+TBTA_VBUS_1 on TOP (solid shape): 46.44,116.47 46.44,116.45 46.45,116.2 46.48,115.95 46.48,114.61 47.32,113.77 47.45,113.58 47.59,113.4 47.6,113.3 47.52,113.24 47.42,113.21 47.33,113.15 47.26,113.12 47.19,113.15 46.66,112.87 47.22,112.64 47.28,112.67 47.35,112.65 47.67,112.6 47.88,112.85 47.94,112.93 48.05,112.9 48.39,112.6 48.77,112.32 49.68,111.41 52.62,111.41 52.83,111.2 52.83,108.72 51.78,107.66 48.33,107.66 48.11,107.88 47.04,107.88 47.04,107.37 46.59,107.37 46.57,107.36 46.55,107.36 46.55,107.88 45.84,107.88 45.84,107.36 45.35,107.36 45.35,107.88 44.57,107.88 43.94,108.5 43.94,112.54 43.4,113.09 43.4,114.58 43.94,115.12 44.09,115.18 44.35,115.18 45.04,115.87 45.31,116.49 45.38,116.82 45.48,116.92 45.98,116.92
+TBTA_VBUS_1 on BOTTOM (solid shape): 26.27,99.4 26.27,98.87 26.03,98.64 25.66,98.64 25.66,98.65 23.07,98.65 22.87,98.44 22.87,97.54 22.8,97.47 20.89,97.47 20.85,97.44 20.7,97.44 20.65,97.39 20.65,95.2 20.33,94.88 20.33,94.41 20.2,94.28 19.36,94.28 19.18,94.46 19.18,95.85 19.2,95.87 19.2,99.41 19.31,99.51 19.79,99.51 19.79,99.52 26.15,99.52
+TBTA_VBUS_1 on IN1 (solid shape): 26.85,58.45 26.85,58.11 26.7,57.96 26.7,56.26 26.16,55.72 16.39,55.72 16.19,55.91 16.19,57.88 16.58,58.26 24.12,58.26 24.22,58.36 25.53,58.36 25.53,58.31 25.54,58.26 25.56,58.21 25.59,58.16 25.62,58.12 25.66,58.08 25.71,58.05 25.75,58.03 25.81,58.01 25.86,58.01 25.91,58.01 25.96,58.01 26.02,58.03 26.06,58.05 26.11,58.08 26.15,58.12 26.18,58.16 26.21,58.21 26.23,58.26 26.24,58.31 26.24,58.36 26.24,58.42 26.23,58.47 26.21,58.52 26.18,58.56 26.15,58.61 26.11,58.64 26.06,58.67 26.02,58.69 25.96,58.71 25.91,58.72 25.86,58.72 25.81,58.71 25.75,58.69 25.71,58.67 25.66,58.64 25.62,58.61 25.59,58.56 25.56,58.52 25.54,58.47 25.53,58.42 25.53,58.36 24.22,58.36 24.6,58.74 24.61,58.74 24.93,59.06 26.24,59.06
+TBTA_VBUS_1 on IN1 (solid shape): outline of 188 points within 19.67,97.5 33.53,111.6
+TBTA_VBUS_1 on IN2 (solid shape): 24.51,99.41 24.51,98.01 24.01,97.5 20.77,97.5 20.7,97.44 20.7,94.84 20.16,94.3 19.2,94.3 19.18,94.36 19.16,94.41 19.14,94.46 19.1,94.5 19.06,94.53 19.02,94.56 18.97,94.58 18.92,94.59 18.87,94.6 18.81,94.59 18.76,94.58 18.71,94.56 18.67,94.53 18.63,94.5 18.6,94.46 18.57,94.41 18.55,94.36 18.53,94.3 18.01,94.3 17.43,94.87 17.43,96.83 18.47,96.83 18.47,96.78 18.48,96.73 18.49,96.68 18.52,96.63 18.55,96.59 18.58,96.55 18.62,96.52 18.67,96.5 18.72,96.48 18.77,96.48 18.82,96.48 18.88,96.48 18.92,96.5 18.97,96.52 19.01,96.55 19.05,96.59 19.08,96.63 19.1,96.68 19.12,96.73 19.13,96.78 19.13,96.83 19.12,96.88 19.1,96.93 19.08,96.98 19.05,97.02 19.01,97.06 18.97,97.09 18.92,97.11 18.88,97.13 18.82,97.14 18.77,97.14 18.72,97.13 18.67,97.11 18.62,97.09 18.58,97.06 18.55,97.02 18.52,96.98 18.49,96.93 18.48,96.88 18.47,96.83 17.43,96.83 17.43,97.41 18.54,98.52 18.84,98.52 19.86,99.54 24.39,99.54
+TBTA_VBUS_1 on IN3 (solid shape): 46.63,116.64 46.63,114.79 42.98,111.15 41.66,111.15 41.47,110.97 41.28,110.97 41.12,110.81 37.9,110.81 37.89,110.85 37.57,111.09 37.25,110.85 37.24,110.81 35.15,110.81 35.14,110.84 34.8,111.01 34.52,110.75 34.51,110.71 34.13,110.71 34.12,110.75 33.72,110.96 33.48,110.57 33.49,110.54 33.28,110.33 31.5,110.33 31.46,110.29 31.26,110.29 30.65,109.68 30.57,109.65 30.49,109.69 29.99,109.73 30.03,109.23 30.07,109.15 30.04,109.07 28.95,107.98 28.13,107.98 27.94,108.17 27.94,111.6 28.27,111.93 37.1,111.93 37.55,111.97 37.98,112.11 37.98,112.11 38.1,112.11 38.22,112.22 38.22,112.23 38.71,112.6 39.08,113.08 40.9,114.9 42.36,114.9 43.07,115.01 43.67,115.06 43.89,115.12 44.1,115.19 44.6,115.49 44.87,115.74 45.08,116.03 45.26,116.41 45.38,116.76 45.6,116.97 46.29,116.97
+TBTA_VBUS_1 on VCC: 16.17,56.26 15.09,57.34 15.09,75.79 12.04,78.84 12.04,90.26 12.86,91.08 14.94,91.08 17.76,93.89 17.76,99.63 25.6,99.63 27.13,100.27 27.77,101.8 27.77,112.03 37.1,112.03 38.63,112.67 39.27,114.2 39.27,115.03 43.2,115.03 44.73,115.67 45.37,117.2 45.37,117.88 47.5,117.88 47.5,113.74 42.44,108.68 38.35,108.68 20.2,90.53 20.2,78.05 18.67,76.53 18.67,74.92 20.45,73.14 20.45,62.18 19.56,61.29 19.56,57.35 18.47,56.26
+USB_EX2_PWR on BOTTOM (solid shape): 25.72,29.11 25.72,28.29 25.53,28.1 24.01,28.1 23.56,27.65 23.56,26.19 23.31,25.94 22.16,25.94 21.66,25.43 20.64,25.43 20.2,25.88 20.2,28.35 20.64,28.8 21.86,28.8 21.86,28.77 22,28.77 22.04,28.73 22.48,28.73 22.8,29.05 24.7,29.05 24.96,29.3 25.53,29.3
+USB_EX2_PWR on IN2 (solid shape): 20.29,27.69 20.61,27.69 21.34,26.96 21.34,25.49 21.15,25.3 18.48,25.3 16.32,27.46 15.81,27.46 15.37,27.91 15.37,29.56 15.56,29.75 18.23,29.75
+USB_EX3_PWR on TOP (solid shape): 29.02,45.24 29.02,44.35 28.77,44.1 28.51,44.1 28.17,44.36 27.83,44.1 24.13,44.1 24.01,43.97 23.94,43.97 23.81,43.85 23.18,43.85 22.86,44.16 19.94,44.16 19.81,44.29 19.81,45.31 20,45.5 23.24,45.5 23.69,45.94 28.32,45.94
+USB_EX3_PWR on BOTTOM (solid shape): 22.48,47.34 22.48,44.54 22.23,44.29 20.51,44.29 20.45,44.35 20.45,47.47 20.7,47.72 22.1,47.72
+USB_EX3_PWR on IN3 (solid shape): 20.78,48.53 20.81,48.45 20.77,48.37 20.74,48.35 20.68,48.33 20.61,48.35 20.07,48.1 20.61,47.85 20.68,47.87 20.96,47.77 21.24,47.88 21.31,47.85 21.41,47.79 21.52,47.77 21.54,47.77 22.48,46.83 22.48,45.43 22.1,45.05 19.18,45.05 17.02,47.21 15.5,47.21 14.86,47.85 14.86,48.58 15.12,48.97 15.09,49.43 15.08,49.46 15.24,49.62 19.69,49.62
+VCHGR on BOTTOM (solid shape): 205.49,41.04 205.83,41.04 206.16,40.71 206.16,40.48 206.36,40.28 207.42,40.28 207.71,39.99 207.71,38.27 207.9,38.08 207.9,37.6 207.82,37.53 204.38,37.53 203.13,38.77 200.21,38.77 200.15,38.83 200.15,40.1 200.28,40.23 203.42,40.23 203.67,40.48 203.67,40.86 203.85,41.04 204.5,41.04 204.5,40.47 204.85,40.11 205.21,40.47 205.21,41.05 205.48,41.05
+VHDMI_VCC on BOTTOM (solid shape): 17.91,72.99 17.91,72.23 17.66,71.98 16.64,71.98 16.39,71.72 16.39,71.35 14.73,71.35 14.61,71.47 14.61,72.5 14.65,72.5 14.85,72.64 14.91,72.88 14.93,72.96 15.01,72.99 16.51,72.99 16.77,73.25 17.66,73.25
+VHDMI_VCC on IN2 (solid shape): 15.5,72.74 15.5,69.56 15.24,69.31 14.35,69.31 13.97,69.69 13.97,71.21 13.34,71.85 12.58,71.85 12.32,72.1 12.32,72.85 14.25,72.85 14.25,72.8 14.26,72.75 14.28,72.7 14.3,72.66 14.33,72.61 14.37,72.58 14.41,72.55 14.46,72.52 14.51,72.51 14.56,72.5 14.61,72.5 14.66,72.51 14.71,72.52 14.76,72.55 14.8,72.58 14.83,72.61 14.87,72.66 14.89,72.7 14.9,72.75 14.91,72.8 14.91,72.85 14.9,72.91 14.89,72.95 14.87,73 14.83,73.04 14.8,73.08 14.76,73.11 14.71,73.13 14.66,73.15 14.61,73.16 14.56,73.16 14.51,73.15 14.46,73.13 14.41,73.11 14.37,73.08 14.33,73.04 14.3,73 14.28,72.95 14.26,72.91 14.25,72.85 12.32,72.85 12.32,72.99 12.7,73.37 14.86,73.37
BGATE_ISL88738 on BOTTOM (solid shape): 207.67,42.22 207.67,40.75 207.46,40.53 206.61,40.53 206.47,40.67 206.47,41 207,41.54 207,42.28 207.05,42.34 207.56,42.34
BOOT1_ISL88738 on BOTTOM (solid shape): 61.85,90.34 61.85,89.1 62.08,88.87 62.08,88.28 62.05,88.26 61.19,88.26 61.11,88.33 61.11,88.89 61.67,89.45 61.67,90.29 61.75,90.37 61.83,90.37
BOOT2_ISL88738 on BOTTOM (solid shape): 64.57,92.2 64.57,92.16 64.61,92.16 64.62,92.15 65.8,92.15 65.88,92.08 65.88,91.08 65.84,91.04 65.19,91.04 65.18,91.05 65.19,91.23 65.18,91.35 65.18,91.35 65.18,91.41 64.65,91.94 64.56,91.94 64.54,91.95 64.38,92.11 63.19,92.11 63.17,92.13 63.17,92.3 63.21,92.33 64.44,92.33
BST_3V on BOTTOM (solid shape): 233.94,29.68 233.94,28.04 233.88,27.99 233.61,27.99 233.36,28.24 233.36,28.57 232.41,29.52 231.48,29.52 231.38,29.62 231.38,30.62 231.48,30.72 232.91,30.72
BST_5V on BOTTOM (solid shape): 38.51,47.17 38.51,46.37 38.46,46.32 37.81,46.32 37.37,46.77 36.39,46.77 36.32,46.83 36.32,46.96 36.39,47.02 37.57,47.02 37.77,47.22 38.46,47.22
BST_+1VALWP on TOP (solid shape): 187.03,101.45 187.03,101.07 186.95,100.98 186.63,100.98 186.38,100.74 186.38,100.56 186.18,100.36 185.55,100.36 185.49,100.42 185.49,101.73 185.74,101.99 186.5,101.99
BST_+1VALWP on BOTTOM (solid shape): 187.05,101.47 187.05,101.1 186.95,101 186.49,101 186.4,100.91 185.92,100.91 185.85,100.97 185.85,101.61 186.19,101.94 186.57,101.94
BST_+1VALWP_C on TOP (solid shape): 184.92,101.39 184.92,100.43 184.75,100.26 183,100.26 182.88,100.37 182.88,101.28 183.13,101.53 184.77,101.53
CORE_SNUB on TOP (solid shape): 70.42,86.49 70.42,83.75 70.27,83.6 69.17,83.6 68.61,84.16 68.61,86.5 68.69,86.58 70.33,86.58
CORE_SW on TOP (solid shape): 72.89,86.56 73.24,86.56 73.41,86.39 76.39,86.39 76.77,86.01 76.77,85.92 76.76,85.9 76.59,85.55 76.66,85.16 76.68,85.12 76.64,85.08 76.64,84.8 76.04,84.21 75.66,84.21 75.39,84.09 75.32,83.8 75.33,83.77 75.11,83.55 75.11,82.14 75.08,82.11 72.88,82.11 72.78,82.22 72.78,83.15 72.2,83.72 71.68,83.72 71.48,83.92 71.48,83.99 71.17,84.3 71.17,86.43 71.31,86.57 72.87,86.57
CORE_SW on BOTTOM (solid shape): outline of 84 points within 70.98,79.52 76.85,85.96
CPU_B+ on TOP (solid shape): 68.84,82.9 68.84,81.5 68.61,81.27 68.61,81.27 68.29,80.96 68.29,79.13 68.84,78.58 72.77,78.58 72.84,78.64 72.84,79.48 72.9,79.55 75.01,79.55 75.15,79.41 75.15,78.54 74.89,78.29 74.55,78.29 74.16,77.9 74.14,77.9 74.03,77.78 74,77.78 73.77,77.7 73.69,77.46 73.69,77.43 73.64,77.37 72.96,77.37 72.71,77.12 67.93,77.12 67.46,76.65 66.54,76.65 66.26,76.93 61.98,76.93 61.72,77.18 61.72,77.95 61.98,78.2 64.52,78.2 64.9,78.58 65.53,78.58 65.69,78.74 65.7,78.74 65.74,78.79 65.74,79.24 65.74,79.24 65.74,81.97 66.03,82.26 66.99,82.26 67.81,83.08 68.65,83.08
CPU_B+ on BOTTOM (solid shape): 78.17,92.61 78.17,91.85 76.77,91.85 76.77,91.85 76.27,91.85 76.2,91.92 76.2,92.49 76.35,92.64 78.14,92.64
CPU_B+ on BOTTOM (solid shape): outline of 105 points within 60.96,74.45 72.14,82.86
CPU_B+ on IN2 (solid shape): outline of 183 points within 68.26,81.12 78.74,92.8
EN_1.0V_PRIM_COREP on BOTTOM (solid shape): 174.8,112.72 174.8,112.38 174.42,111.99 173.61,111.99 173.52,112.08 173.52,112.55 173.81,112.85 174.68,112.85
EN_1.0V_PRIM_COREP on BOTTOM (solid shape): 178.01,114.48 178.01,112.15 177.87,112.01 177.46,112.01 177.31,112.16 177.31,114.34 176.95,114.7 176.95,114.92 177.05,115.02 177.47,115.02
EN_1.8VALW on BOTTOM (solid shape): 167.06,100.2 167.06,98.91 166.9,98.75 164.61,98.75 164.55,98.81 164.55,100.58 164.85,100.88 166.37,100.88
EN_1VS_VCCIO on BOTTOM (solid shape): 190.25,111.68 190.25,109.47 190.11,109.33 189.11,109.33 188.81,109.62 188.81,111.11 189.49,111.78 190.15,111.78
EN_VCC_EDRAM on TOP (solid shape): 49.65,57.42 49.65,56.58 49.48,56.41 48.28,56.41 48.15,56.54 48.15,56.81 48.84,57.5 49.57,57.5
EN_VCC_EDRAM on TOP (solid shape): 46.26,57.72 46.26,57.72 46.37,57.61 46.37,57.44 46.38,57.43 46.38,57.31 46.37,57.3 46.37,55.2 46.22,55.06 46.2,55.06 45.95,55 45.81,54.78 45.8,54.77 45.7,54.67 45.32,54.67 45.23,54.76 45.23,57.57 45.24,57.58 45.24,57.9 45.28,57.94 46.04,57.94
EN_VCC_EOPIO on TOP (solid shape): 45.94,45.56 45.94,44.31 45.52,43.9 45.4,43.77 45.4,42.6 45.28,42.47 44.72,42.47 44.64,42.56 44.64,45.69 44.72,45.77 45.73,45.77
FB_1.8VALW on BOTTOM (solid shape): 168.54,100.69 170.94,100.69 171.03,100.6 171.03,100.17 170.94,100.07 167.41,100.07 167.23,100.26 167.23,100.69 167.42,100.89 168.34,100.89
GPU_B+ on TOP (solid shape): 65.9,72.93 65.9,70.02 65.86,69.98 64.02,69.98 63.72,70.28 63.72,72.97 65.02,72.97 65.31,73.26 65.57,73.26
GPU_B+ on TOP (solid shape): 56.73,65.51 56.91,65.32 56.91,64.38 56.58,64.05 54.69,64.05 54.56,64.18 54.56,65.39 54.7,65.53 56.66,65.53
GPU_B+ on BOTTOM (solid shape): 58.04,66.47 58.04,64.04 57.7,63.7 57.7,60.42 57.44,60.16 57.03,60.16 57.03,60.17 56.31,60.17 56.22,60.26 56.22,63.41 55.63,64 53.89,64 53.75,64.13 53.75,65.39 53.95,65.59 56.6,65.59 57.05,65.64 57.03,66.09 57.03,66.43 57.13,66.53 57.98,66.53
