# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_SPKR_R+:
  vias: v2(295.73,7.37) v2(295.7,6.79) v3(296.33,7.11)
INT_SPKR_R-:
  vias: v1(292.23,7.91) v2(293.58,8.04) v2(293.58,7.42)
INTRUDER#: length 21.5
  TOP w0.112: v2(141.35,64.72) 141.49,64.86 v3(142.05,64.86) 142.84,64.86 143.24,65.27 143.33,65.36 143.38,65.36 143.39,65.37 145.01,65.37 145.65,64.73 147.4,64.73 150.17,61.97 RC69.1
  IN1 w0.076: v2(141.35,64.72) 141.35,65.25 140.33,66.27 139.17,66.27 138.5,66.94 137.2,66.94 136.78,67.36 136.78,68.24 136.52,68.5 136.52,69.75 136,70.28 v2(136,70.67)
  BOTTOM w0.076: UC1.AP16 v2(136,70.67)
IR_CAM_DET#: length 80.7
  TOP w0.102: v2(147.44,100.42) 147.81,100.04 RC345.1
  IN1 w0.076: 148.16,84.88 148.16,84.74 147.85,84.42 146.56,84.42 145.93,83.79 145.93,83.49 146.28,83.14 v2(146.28,82.28)
  IN1 w0.102: v2(147.44,100.42) 147.2,100.19 147.2,97.96 147.79,97.37 147.79,96.08 148.6,95.27 148.6,92.41 148.51,92.32 148.51,86.42 148.16,86.07 148.16,84.88
  BOTTOM w0.076: UC1.H5 143.04,83.94 143.26,83.72 143.26,82.34 143.45,82.15 146.15,82.15 v2(146.28,82.28)
  BOTTOM w0.102: v2(147.44,100.42) 147.48,100.46 147.48,105.42 145.75,107.16 137.63,107.16 v1(132.25,112.54) 127.56,117.23 104.49,117.23 104.15,116.89 JIR1.1
ISEN1_GT: length 54.9
  TOP w0.203: PU602.9 53.99,68.61 54.31,68.29 55.07,68.29 v2(55.32,68.04) ; PC635.2 56.5,67.04 PR634.1
  TOP w0.254: PC635.2 56.83,67.54 56.36,68.01 55.35,68.01 v2(55.32,68.04) ; v2(75.12,66.91) 75.95,66.91 77.35,68.31 v1(77.35,68.38) 77.35,71.34 77.76,71.76 PR677.1 78.08,71.9 PR675.2
  IN2 w0.254: v2(55.32,68.04) 55.32,68.19 54.59,68.93 52.58,68.93 52.02,68.37 52.02,67.53 51.74,67.25 51.63,67.25 49.13,64.74 49.13,63.44 50.48,62.08 57.01,62.08 57.61,62.68 62.46,62.68 63.5,61.65 73.48,61.65 75.74,63.91 75.74,66.29 v2(75.12,66.91)
ISEN2_GT: length 44.5
  TOP w0.203: PU602.10 54.39,68.77 54.54,68.62 55.6,68.62 v2(55.7,68.73)
  TOP w0.254: PR615.1 57.37,69.39 PC638.2 57.35,69.37 56.53,68.55 55.88,68.55 v2(55.7,68.73) ; PR668.2 69.28,64.12 PR670.2 70.47,61.35 v2(70.28,61.16)
  IN2 w0.254: v2(70.28,61.16) 63.41,61.16 62.34,62.22 58.02,62.22 57.48,61.69 49.48,61.69 48.7,62.47 48.7,65.19 50.93,67.41 50.93,67.94 52.45,69.46 54.97,69.46 v2(55.7,68.73)
  BOTTOM w0.102: v2(70.28,61.16) v3(71.12,61.16)
ISH_I2C2_SCL: length 183.9
  TOP w0.112: RZ76.1 274.09,77.97 274.09,78.44 v2(273.93,78.61)
  IN1 w0.119: v2(273.93,78.61) 274.07,78.75 274.07,78.97 273.94,79.1 273.24,79.1 272.19,78.05 272.19,63.41 270.48,61.7 270.48,58.36 268.82,56.7 265.13,56.7 264.09,57.74 262.82,57.74 262.14,57.07 262.14,55.84 261.82,55.52 260.89,55.52 260.33,56.08 259.14,56.08 258.43,55.37 251.94,55.37 244.51,47.94 242.04,47.94 241.09,46.99 238.8,46.99 238.45,46.64 232.32,46.64 232.06,46.9 208.53,46.9 206.83,48.59 205.56,48.59 199.21,54.93 198.82,54.93 193.43,60.33 191.36,60.33 189.08,62.61 181.85,62.61 181.2,61.96 178.91,61.96 178.26,62.61 177.63,62.61 170.8,69.44 170.8,69.81 168.2,72.41 164.06,72.41 163.79,72.67 163.79,72.88 v2(163.6,73.08)
  IN3 w0.135: v2(138.71,76.97) 138.9,76.77 138.9,76.61 139.19,76.32 145.49,76.32 146.31,75.5 147.42,75.5 148.27,76.36 149.2,76.36 149.7,76.86 149.94,76.86 151.11,76.86 159.62,76.86 162.89,73.59 163.56,73.59 163.76,73.38 163.76,73.25 v2(163.6,73.08)
  BOTTOM w0.076: v2(138.71,76.97) 138.88,76.79 UC1.AD12
  BOTTOM w0.112: RC362.1 165.67,71 165.56,70.89 165.42,70.89 165.3,70.78 165.3,70.55 165.05,70.3 164.01,70.3 163.71,70.6 163.71,72.97 v2(163.6,73.08)
ISH_I2C2_SCL_R: length 5.4
  TOP w0.112: v2(273.92,75.74) 274.06,75.88 274.06,76.41 RZ76.2
  BOTTOM w0.112: v2(273.92,75.74) 274.04,75.61 274.04,75.36 273.73,75.04 272.21,75.04 271.83,74.66 271.83,74.4 271.7,74.27 JNGFF2.32
ISH_I2C2_SDA: length 183.1
  TOP w0.112: RZ77.1 274.4,77.86 274.4,77.87 274.33,77.93 274.33,78.43 v2(274.51,78.61)
  IN1 w0.119: v2(164.18,73.08) 164.04,72.94 164.04,72.77 164.16,72.65 168.3,72.65 171.04,69.91 171.04,69.54 177.73,62.85 178.37,62.85 179.02,62.2 181.1,62.2 181.75,62.86 189.18,62.86 191.46,60.58 193.53,60.58 198.93,55.18 199.32,55.18 205.66,48.84 206.93,48.84 208.63,47.14 232.17,47.14 232.42,46.89 238.35,46.89 238.7,47.24 240.99,47.24 241.94,48.18 244.4,48.18 251.84,55.62 258.33,55.62 259.03,56.33 260.44,56.33 260.99,55.77 261.72,55.77 261.89,55.95 261.89,57.17 262.71,57.99 264.19,57.99 265.24,56.95 268.72,56.95 270.24,58.46 270.24,61.8 271.94,63.51 271.94,78.15 273.14,79.35 274.04,79.35 274.32,79.08 274.32,78.8 v2(274.51,78.61)
  IN3 w0.135: v2(164.18,73.08) 164.03,73.23 164.03,73.49 163.67,73.85 163,73.85 159.73,77.12 152.29,77.12 151.11,77.12 149.81,77.12 149.6,77.12 149.09,76.62 148.38,76.62 148.38,76.62 148.17,76.62 147.31,75.76 146.42,75.76 145.6,76.58 139.3,76.58 139.16,76.71 139.16,76.83 139.3,76.97 v2(139.3,76.98)
  BOTTOM w0.076: v2(139.3,76.98) 139.53,76.74 UC1.AD11
  BOTTOM w0.112: RC363.1 164.81,70.89 164.95,70.89 165.07,70.78 165.07,70.65 164.95,70.54 164.11,70.54 163.95,70.7 163.95,72.85 v2(164.18,73.08)
ISH_I2C2_SDA_R: length 5.5
  TOP w0.112: RZ77.2 274.29,76.38 274.29,75.95 v2(274.5,75.75)
  BOTTOM w0.112: JNGFF2.34 272.2,74.27 272.07,74.4 272.07,74.56 272.31,74.8 273.82,74.8 274.28,75.26 274.28,75.57 274.46,75.75 v2(274.5,75.75)
ISH_UART0_CTS#: length 187.4
  TOP w0.102: v3(279.05,51.02) 279.55,50.51 v2(279.59,50.51) 280.08,50.51 RZ80.1
  IN2 w0.102: v2(146.78,79.49) 146.78,79.66 147.12,80 149.28,80 151.44,77.84 152.45,77.84 152.74,78.13 152.74,78.94 153.42,79.62 166.54,79.62 166.86,79.3 166.86,78.38 167.07,78.16 168.39,78.16 169.24,77.32 170.3,77.32 170.94,76.68 170.94,74.51 175.82,69.64 175.82,69.32 177.97,67.18 179.08,67.18 185.71,60.55 185.83,60.55 189.94,56.44 189.94,56.29 190.32,55.91 191.41,55.91 202.58,44.74 203.45,44.74 206.3,41.89 206.3,41.14 207.09,40.35 211.64,40.35 213.16,38.83 227.27,38.83 227.33,38.89 236.73,38.89 237.26,38.36 237.58,38.36 237.82,38.6 242.11,38.6 242.35,38.36 246.39,38.36 247.9,36.85 247.9,35.88 248.52,35.26 250.53,35.26 250.82,35.54 252.29,35.54 253.04,34.79 256.51,34.79 256.65,34.93 258.12,34.93 258.82,34.23 258.82,32.59 260.87,30.54 262.33,30.54 264.33,28.54 266.37,28.54 266.47,28.63 272.44,28.63 273.43,29.62 273.76,29.62 273.8,29.66 278.04,29.66 279.91,31.53 279.91,43.63 280.29,44.01 280.29,45.73 280.71,46.15 280.71,49.52 279.72,50.51 v2(279.59,50.51)
  BOTTOM w0.076: UC1.U4 143.83,79.53 144.75,79.53 144.87,79.41 145.24,79.41 145.25,79.41 145.77,79.26 146.25,79.26 146.48,79.49 v2(146.78,79.49)
ISH_UART0_CTS#_R: length 2.4
  TOP w0.102: v2(282.13,50.39) 282.13,50.49 281.92,50.7 RZ80.2
  BOTTOM w0.102: JNGFF1.62 281.98,50.55 v2(282.13,50.39)
ISH_UART0_RTS#: length 186.2
  TOP w0.102: RZ81.1 279.9,51.15 v2(279.62,51.15)
  IN2 w0.102: v2(148.63,79.58) 148.81,79.4 149.59,79.4 151.36,77.63 152.53,77.63 152.95,78.05 152.95,78.86 153.51,79.42 165.4,79.42 166.86,77.96 168.31,77.96 169.15,77.12 170.22,77.12 170.7,76.63 170.7,74.36 175.62,69.45 175.62,69.15 177.99,66.77 179.17,66.77 185.6,60.35 185.69,60.35 189.74,56.29 189.74,56.2 190.29,55.66 191.38,55.66 202.5,44.53 203.37,44.53 206.1,41.81 206.1,41.06 207,40.15 211.55,40.15 213.08,38.63 236.71,38.63 237.17,38.16 237.9,38.16 238.13,38.39 242.01,38.39 242.39,38.02 246.32,38.02 247.58,36.76 247.58,35.91 248.43,35.05 250.71,35.05 250.99,35.34 252.14,35.34 252.89,34.59 256.6,34.59 256.73,34.72 257.62,34.72 257.89,34.46 257.89,33.23 260.83,30.29 262.3,30.29 264.27,28.32 266.44,28.32 266.55,28.43 272.56,28.43 273.53,29.41 274.56,29.41 274.61,29.46 278.12,29.46 280.12,31.46 280.12,43.55 280.49,43.92 280.49,45.65 280.91,46.07 280.91,50.21 280.02,51.11 279.67,51.11 v2(279.62,51.15)
  BOTTOM w0.076: v2(148.63,79.58) 148.02,80.2 v3(147.83,80.2) 145.75,80.2 145.7,80.14 144.56,80.14 UC1.U3
ISH_UART0_RTS#_R: length 2.7
  TOP w0.102: v3(282.34,51.89) 282.34,51.69 v2(282.07,51.43) 282.06,51.43 281.74,51.43 281.57,51.61 RZ81.2
  BOTTOM w0.102: v2(282.07,51.43) 282.06,51.43 281.91,51.43 281.53,51.05 JNGFF1.64
ISH_UART0_RXD: length 188.8
  TOP w0.102: v2(286.16,49.74) 285.86,49.44 v3(285.79,49.44) RZ78.1
  IN2 w0.102: v2(286.16,49.74) 286.16,49.42 285.47,48.73 282.23,48.73 281.48,47.98 281.48,43.79 280.57,42.88 280.57,33.03 280.74,32.86 280.74,30.26 280.63,30.15 279.85,30.15 277.72,28.02 266.72,28.02 266.57,27.87 264.14,27.87 262.13,29.88 258.86,29.88 258.64,30.1 258.64,30.63 256.99,32.28 256.99,33.92 256.72,34.19 253.99,34.19 253.88,34.08 251.08,34.08 250.61,34.55 248.36,34.55 246.25,36.66 245.66,36.66 245.17,37.15 243.28,37.15 243.07,36.93 232.4,36.93 231.59,37.75 221.25,37.75 220.57,38.42 212.99,38.42 211.47,39.95 206.92,39.95 205.89,40.97 205.89,41.72 203.29,44.33 202.42,44.33 191.29,55.45 190.14,55.45 189.49,56.11 189.49,56.22 185.61,60.1 185.49,60.1 179.13,66.47 178.98,66.47 178.91,66.54 177.78,66.54 175.41,68.91 175.41,69.37 170.5,74.28 170.5,76.55 170.13,76.91 169.07,76.91 168.22,77.76 166.78,77.76 165.32,79.22 153.59,79.22 153.15,78.77 153.15,77.96 152.62,77.43 151.28,77.43 149.53,79.17 148.42,79.17 v2(148.01,79.58)
  BOTTOM w0.076: UC1.U1 145.86,79.8 146.08,80.02 147.58,80.02 v2(148.01,79.58)
ISH_UART0_RXD_R: length 3.2
  TOP w0.102: RZ78.2 283.48,49.83 283.31,49.83 283.3,49.83 v2(283.26,49.83)
  BOTTOM w0.102: JNGFF1.58 281.76,49.55 281.84,49.47 282.82,49.47 283.18,49.83 v2(283.26,49.83)
ISH_UART0_TXD: length 190.5
  TOP w0.102: RZ79.1 v2(286.16,50.4)
  IN2 w0.102: v2(286.16,50.4) 286.31,50.4 286.69,50.03 286.69,49.65 285.56,48.52 282.57,48.52 281.68,47.63 281.68,43.7 280.78,42.8 280.78,33.1 280.94,32.94 280.94,30.17 280.72,29.95 279.93,29.95 277.8,27.82 266.8,27.82 266.64,27.65 264.06,27.65 262.03,29.68 258.78,29.68 258.44,30.01 258.44,30.54 256.79,32.19 256.79,33.83 256.64,33.98 254.09,33.98 253.93,33.82 251.05,33.82 250.6,34.28 248.35,34.28 246.29,36.33 243.79,36.33 243.39,36.73 232.32,36.73 231.5,37.54 221.16,37.54 220.48,38.22 212.81,38.22 211.29,39.74 206.84,39.74 205.74,40.84 204.8,40.84 204.03,41.6 204.03,42.43 191.5,54.96 190.31,54.96 189.23,56.04 189.23,56.2 185.53,59.9 185.37,59.9 179.01,66.26 177.77,66.26 175.21,68.82 175.21,69.16 170.25,74.13 170.25,76.14 169.68,76.71 168.98,76.71 168.14,77.55 166.69,77.55 165.23,79.01 153.68,79.01 153.35,78.69 153.35,77.88 152.7,77.23 151.19,77.23 149.48,78.93 147.96,78.93 v2(147.37,79.53)
  BOTTOM w0.076: UC1.U2 145.09,79.58 145.27,79.58 145.3,79.57 145.5,79.51 145.9,79.51 146.23,79.85 147.05,79.85 v2(147.37,79.53)
ISH_UART0_TXD_R: length 3.5
  TOP w0.102: RZ79.2 283.69,50.22 283.06,50.22 282.96,50.32 v3(282.81,50.32) 282.66,50.18 v2(282.66,49.85)
  BOTTOM w0.102: v2(282.66,49.85) 281.92,49.85 281.72,50.05 JNGFF1.60
ISUMN_GT: length 66.3
  TOP w0.112: PR673.2 76.73,72.47 76.16,71.9 v4(76.16,71.32) 76.16,70.44 75.48,69.75 71.31,69.75 v2(70.97,70.1) 70.77,70.1 69.56,68.89 68.38,68.89 68.21,68.73 PR666.2 ; v2(53.39,64.54) 53.37,64.54 52.81,65.1 PR632.1 52.82,65.35 PR638.1 ; v2(69.66,70.02) 69.23,70.02 69.03,69.82 63.15,69.82 61.8,68.47 59.87,68.47 59.31,67.91 58.28,67.91 PC635.1 57.35,68.11 PC638.1
  IN2 w0.124: v2(70.97,70.1) 70.98,70.1 71.33,69.74 72.12,69.74 72.82,69.05 73.8,69.05 74.38,68.47 74.38,63.55 73.03,62.19 63.87,62.19 62.74,63.32 53.57,63.32 53.39,63.5 v2(53.39,64.54)
  BOTTOM w0.112: v2(53.39,64.54) 53.39,65.5 53.6,65.7 PC624.2 PC626.2 52.67,66.08 PR633.2 50.95,66.08 PC641.1 ; v2(69.66,70.02) 70.89,70.02 v2(70.97,70.1) 70.97,70.71 PH602.2
ISUMN_IA: length 33.5
  TOP w0.112: PC645.1 79,79.11 v2(78.97,79.09) ; v2(60.2,75.72) 59.48,76.45 PR644.2 PR640.2
  IN2 w0.124: v2(78.97,79.09) 78.69,79.09 76.94,77.34 73.62,77.34 v2(73.22,76.93) 65.53,76.93 65.33,76.73 61.07,76.73 60.87,76.53 60.81,76.53 60.2,75.91 v2(60.2,75.72)
  BOTTOM w0.112: v2(60.2,75.72) 60.01,75.91 59.77,75.91 v1(59.63,76.05) 59.23,76.45 PC642.2 PC646.2 PR656.2 ; v2(78.97,79.09) 79.17,79.29 79.17,80.87 79.66,81.35 PL610.2 ; v2(73.22,76.93) 73.22,77.27 72.95,77.54 PH605.2
ISUMN_VSA: length 63
  TOP w0.254: v2(49.96,78.63) 49.96,78.64 50.33,78.27 PR641.2 50.33,77.2 PR636.2
  IN3 w0.254: v2(49.96,78.63) 49.99,78.6 49.99,77.36 51.17,76.17 51.95,76.17 52.52,76.74 53.26,76.74 54.85,75.15 57.03,75.15 58.05,76.18 60.62,76.18 61.29,76.85 64.05,76.85 64.26,77.06 65.03,77.06 65.98,78.01 66.28,78.01 69.53,81.26 69.53,83.11 69.14,83.51 69.14,86.17 69.81,86.84 70.26,87.29 70.26,90.22 71.38,91.34 74.03,91.34 76.22,93.53 78.53,93.53 78.72,93.33 78.72,92.25 79.47,91.51 84.03,91.51 84.29,91.76 v2(84.29,91.98)
  BOTTOM w0.254: PL614.2 83.66,87.89 83.31,88.23 83.31,89.88 83.7,90.26 84.24,90.26 84.89,90.91 PH604.2 84.39,91.61 84.39,91.88 v2(84.29,91.98) ; v2(49.96,78.63) 49.96,78.64 49.53,78.2 PC644.1 49.41,77.23 PC637.2 PR643.1 PC633.2
ISUMP_GT: length 55.6
  TOP w0.112: v2(53.67,67.84) 53.67,67.96 53.19,68.45 PU602.7 ; PR667.1 67.11,67.96 68.28,69.13 69.36,69.13 71.01,70.78 PR628.1 71.07,70.66 71.58,70.15 v2(71.71,70.15) 72.32,70.15 72.47,69.99 v4(74.84,69.99) 75.38,69.99 75.92,70.54 75.92,71.95 PR674.1
  IN2 w0.124: v2(71.71,70.15) 72.11,70.15 72.95,69.3 73.91,69.3 74.64,68.57 74.64,63.44 73.13,61.94 63.77,61.94 62.64,63.07 53.47,63.07 52.98,63.56 52.98,65.48 53.84,66.34 53.84,67.67 v2(53.67,67.84)
  BOTTOM w0.112: PR658.2 51.74,67.04 PR633.1 52.67,67 PC626.1 PC624.1 53.6,67.76 v2(53.67,67.84)
ISUMP_IA: length 37.2
  TOP w0.112: v2(79.01,82.66) 79.1,82.57 PR661.2 79,81.69 PR657.1 79.02,80.73 79.06,80.69 79.72,80.69 v3(80.28,81.25)
  TOP w0.203: v2(55.87,73.74) 55.87,73.29 55.54,72.96 PU602.19
  IN2 w0.124: v2(79.01,82.66) 79.01,80.24 78.37,79.61 78.37,79.13 76.83,77.59 73.32,77.59 72.98,77.25 65.5,77.25 65.23,76.98 60.96,76.98 60.76,76.78 59.59,76.78 56.84,74.03 56.16,74.03 v2(55.87,73.74)
  BOTTOM w0.102: 56.43,73.78 55.9,73.78 v2(55.87,73.74)
  BOTTOM w0.112: 56.43,73.78 PR653.2 PR656.1 PC646.1 PC642.1
ISUMP_VSA: length 56
  TOP w0.102: v2(82.19,92.02) v3(82.19,92.69)
  TOP w0.203: v2(51.77,76.69) 51.77,75.94 51.99,75.72 PU602.27
  TOP w0.254: PR624.2 82.93,88.94 v2(82.53,89.33)
  IN3 w0.254: v2(82.19,92.02) 82.14,91.97 79.52,91.97 79.1,92.4 79.1,93.53 78.69,93.94 76.12,93.94 73.89,91.7 71.22,91.7 69.78,90.25 69.78,87.49 69.61,87.33 68.72,86.43 68.72,83.34 69.1,82.96 69.1,81.33 66.13,78.37 65.83,78.37 64.88,77.41 64.11,77.41 63.9,77.2 60.96,77.2 60.31,76.55 57.72,76.55 56.77,75.6 54.93,75.6 53.44,77.09 53.42,77.09 53.41,77.1 52.17,77.1 v2(51.77,76.69)
  BOTTOM w0.254: v2(51.77,76.69) 51.39,76.31 PC633.1 PR643.2 PC637.1 48.51,76.31 48.49,76.29 ; v2(82.53,89.33) 82.22,89.65 PR642.1 82.22,91.99 v2(82.19,92.02)
ITP_PMODE: length 115.4
  TOP w0.112: v2(98.81,103.12) 100.54,103.12 101.12,103.7 105.61,103.7 106.42,104.52 v1(107.13,104.52) 116.81,104.52 119.98,107.69 126.19,107.69 127.16,106.72 135.19,106.72 135.65,107.18 138.32,107.18 139.21,106.29 151.42,106.29 152.97,104.74 152.97,103.07 153.49,102.55 RC115.1 153.91,102.11 153.91,101.17 153.15,100.41 153.15,95.08 148.72,90.65 142.63,90.65 141.78,89.79 141.78,88.44 v2(140.43,87.09)
  BOTTOM w0.076: v2(140.43,87.09) 140.54,86.98 140.54,86.43 141.03,85.94 UC1.E8
  BOTTOM w0.112: JXDP1.46 75.31,107.15 77.58,109.42 90.21,109.42 95.46,104.17 97.76,104.17 v2(98.81,103.12)
JDIMM1_EVENT#: length 3.6
  TOP w0.102: RD14.1 78.74,24.95 78.74,23.91 v2(79.06,23.59)
  BOTTOM w0.102: JDIMM1.134 79.57,24.11 v2(79.06,23.59)
JDIMM2_EVENT#: length 82.3
  TOP w0.102: RD27.1 v3(81.98,25.38) 82.43,25.38 v2(82.75,25.06)
  IN2 w0.102: v2(158.37,26.6) 157.46,25.69 137.09,25.69 136.33,26.44 134.97,26.44 134.21,25.69 115.27,25.69 113.87,24.29 95.25,24.29 v2(94.66,23.7)
  IN3 w0.102: v2(94.66,23.7) 94.04,24.32 83.49,24.32 v2(82.75,25.06)
  BOTTOM w0.102: v2(158.37,26.6) 158.68,26.91 JDIMM2.134
JTAG_CLK: length 83.2
  TOP w0.112: UE1.C8 264.02,42.48 v2(263.62,42.88) ; v2(268.5,77.86) v1(268.5,78.4)
  BOTTOM w0.112: v2(263.62,42.88) 262.69,43.81 262.69,44.76 262.41,45.04 262.41,46.36 262.58,46.53 262.58,48.09 261.83,48.84 261.83,49.32 262.21,49.7 262.21,51.36 262.25,51.4 262.25,54.42 260.3,56.37 260.3,58.25 259.53,59.02 259.53,69.01 260.72,70.21 263.05,70.21 264.64,71.79 264.64,74 v2(268.5,77.86) 269.78,79.14 286.59,79.14 286.76,78.97 292.48,78.97 292.86,78.58 298.99,78.58 299.67,77.9 300.81,77.9 301.49,77.21 301.51,77.21 301.75,76.97 301.75,76.42 302.02,76.15 302.69,76.15 302.82,76.02 RPE7.3 302.82,75.21 302.7,75.09 302.25,75.09 301.51,74.35 JDEG1.4
JTAG_RST#: length 7.6
  TOP w0.112: UE1.G13 266.94,46.67 v3(266.94,48.23) 266.94,48.62 266.78,48.79 265.53,48.79 JTAG1.1 264.94,49.38 CE30.1 RE65.1 RE63.1
JTAG_TDI: length 74.9
  TOP w0.102: v2(280.99,76.71) v1(281.82,76.71)
  TOP w0.107: v2(265.32,43.59) 265.32,43.49 UE1.E9
  IN1 w0.102: v2(280.99,76.71) 279.59,75.32 279.59,69.03 277.91,67.34 277.91,62.35 276.56,61 276.56,56.85 274.57,54.86 273.14,54.86 v2(271.94,53.65)
  IN3 w0.102: v2(300.99,72.48) 300.99,73.4 299.36,75.02 294.13,75.02 293.31,74.2 293.31,73.06 291.85,71.6 284.02,71.6 280.99,74.63 v2(280.99,76.71)
  BOTTOM w0.102: v2(265.32,43.59) 265.36,43.59 265.73,43.95 266.05,43.95 266.5,44.41 266.5,44.52 266.79,44.8 267.37,44.8 270.69,48.13 270.69,51.69 272.09,53.08 272.09,53.5 v2(271.94,53.65) ; RPE7.1 303.82,74.61 303.38,74.16 302.61,74.16 302.51,74.06 JDEG1.2 302.51,72.93 302.07,72.48 v2(300.99,72.48)
JTAG_TDO: length 67.6
  TOP w0.107: v2(266.02,40.39) UE1.F6
  IN1 w0.102: v2(301.1,74.63) 299.81,73.35 298.9,73.35 297.93,72.38 297.93,70.81 297.6,70.48 297.44,70.48 297.12,70.16 297.12,67.83 298.25,66.7 298.25,63.68 297.68,63.11 297.68,61.52 297.85,61.35 297.85,58.87 296.84,57.87 296.73,57.87 294.92,56.06 294.92,52.44 294.72,52.24 294.72,50.65 293.78,49.7 292.66,49.7 291.84,48.88 291.84,48.01 291.42,47.58 291.42,45.29 286.53,40.4 280.73,40.4 279.56,39.23 272.51,39.23 272.01,39.73 271.4,39.73 271.05,40.08 267.06,40.08 266.98,40 266.4,40 v2(266.02,40.39)
  BOTTOM w0.102: JDEG1.5 301.01,74.55 v2(301.1,74.63) 302.12,75.66 RPE7.4
JTAG_TMS: length 72.1
  TOP w0.107: v2(263.62,39.59) UE1.C5
  IN1 w0.102: v2(302.97,74.62) 302.35,73.99 301.89,73.99 300.82,72.93 298.77,72.93 298.58,72.74 298.58,71.47 299.47,70.58 299.47,69.5 298.45,68.49 298.45,63.6 297.88,63.02 297.88,61.61 298.05,61.44 298.05,58.79 296.93,57.66 296.81,57.66 295.12,55.97 295.12,52.35 294.93,52.15 294.93,50.56 293.86,49.49 292.75,49.49 292.04,48.79 292.04,47.92 291.62,47.5 291.62,45.2 286.61,40.19 281.04,40.19 279.88,39.02 274.59,39.02 274.01,38.45 273.64,38.45 273.12,38.97 272.14,38.97 271.83,39.28 269.68,39.28 269.58,39.18 264.17,39.18 263.76,39.59 v2(263.62,39.59)
  BOTTOM w0.102: RPE7.2 303.32,74.97 v2(302.97,74.62) 302.94,74.59 302.46,74.59 302.01,74.15 JDEG1.3
KB_DET#: length 151.4
  TOP w0.102: v2(154.77,97.99) v1(154.77,96.49) 154.77,96.02 153.93,95.18 RC288.1 153.29,94.46 146.75,87.91 142.82,87.91 141.52,86.62 v2(141.52,86.51) ; v2(161.92,77.17) 161.69,77.17 161.38,77.48 161.38,79.77 160.23,80.91 160.23,94.15 v2(159.78,94.6)
  IN2 w0.102: v2(242.99,31.52) 241.39,31.52 239.66,33.25 235.5,33.25 234.72,34.04 222.04,34.04 219.48,36.59 212.08,36.59 210.56,38.12 205.2,38.12 202.31,41 202.31,41.48 195.49,48.3 195.38,48.3 190.54,53.14 189.46,53.14 188.31,54.3 187.9,54.3 182.82,59.37 182.82,60.04 181.36,61.5 180.1,61.5 178.68,62.92 178.68,63.86 178.12,64.42 176.57,64.42 172.39,68.61 171.46,68.61 170.28,69.78 170.28,70.04 164.85,75.48 164.51,75.48 164.26,75.73 164.26,76.45 163.88,76.83 162.26,76.83 v2(161.92,77.17) ; v2(159.78,94.6) 159.11,94.6 155.71,97.99 v2(154.77,97.99)
  BOTTOM w0.076: UC1.D8 141.43,86.61 v2(141.52,86.51)
  BOTTOM w0.102: JKBTP1.20 243.35,30.5 242.99,30.87 v2(242.99,31.52)
LAN_ACTLED_YEL#: length 2.6
  TOP w0.102: QL1.6 296.47,79.29 296.8,78.96 RL14.1 v3(296.8,77.43)
LAN_ACTLED_YEL_R#: length 13.7
  TOP w0.102: RL14.2 299.37,76.8 v1(300.8,76.8) 304.15,76.8 304.38,77.03 305.43,77.03 305.66,76.8 306.74,76.8 307.08,76.46 309.28,76.46 JLOM1.10
LAN_DISABLE#_R: length 5.6
  TOP w0.102: RL5.1 RL7.2 RL9.1 272.46,89.4 v3(273.08,90.02) 273.41,90.02 273.9,90.52 UL1.3
LAN_MDIN0: length 5
  TOP w0.089: RL72.1 281.42,91.14 279.57,91.14 279.27,91.44 279.27,92.21 278.86,92.62 UL1.14
LAN_MDIN0_L: length 20
  TOP w0.089: v2(286.16,90.23) 285.99,90.39 285.99,90.77 285.56,91.21 v4(284.61,91.21) 283.84,91.21 RL72.2
  BOTTOM w0.089: TL1.2 293.5,80.73 293,80.23 292.78,80.23 291.84,81.17 288.77,81.17 286,83.94 286,90.07 v2(286.16,90.23)
LAN_MDIN1: length 4.1
  TOP w0.089: UL1.18 279.49,94.22 280.07,93.63 281.5,93.63 RL74.1
LAN_MDIN1_L: length 18.8
  TOP w0.089: RL74.2 283.84,93.62 285,93.62 288.3,90.33 288.3,88.9 288.06,88.67 287.74,88.67 v2(287.55,88.48)
  BOTTOM w0.089: TL1.6 293.11,85.81 292.61,85.31 289.18,85.31 287.1,87.39 287.1,88.49 287.24,88.63 287.4,88.63 v2(287.55,88.48)
LAN_MDIN2: length 4.2
  TOP w0.089: UL1.21 278.95,95.42 279,95.36 v4(279.53,95.36) 279.82,95.36 280.47,96.01 281.46,96.01 RL76.1
LAN_MDIN2_L: length 18.6
  TOP w0.089: RL76.2 283.93,95.95 285,95.95 285.09,96.04 285.09,96.24 v2(284.92,96.41)
  BOTTOM w0.089: TL1.8 293.74,88.35 293.23,87.85 292.83,87.85 v4(290.06,90.62) 288.79,91.89 288.79,95.58 287.18,97.2 285.38,97.2 285.13,96.94 285.13,96.62 v2(284.92,96.41)
LAN_MDIN3: length 5.1
  TOP w0.089: RL78.1 281.5,98.46 v4(280.67,98.46) 280.12,98.46 279.03,97.37 279.03,96.65 278.94,96.56 278.82,96.56 278.76,96.62 UL1.24
LAN_MDIN3_L: length 15.8
  TOP w0.089: v2(284.75,98.95) 284.89,98.81 284.89,98.55 284.8,98.46 283.83,98.46 RL78.2
  BOTTOM w0.089: TL1.12 293.5,93.43 292.99,92.93 292.16,92.93 v4(291.66,93.43) 290.82,94.27 290.82,95.24 286.44,99.62 285.18,99.62 284.93,99.37 284.93,99.13 v2(284.75,98.95)
LAN_MDIP0: length 4.9
  TOP w0.089: UL1.13 278.9,92.22 279.02,92.1 279.02,91.33 279.46,90.89 v4(280.64,90.89) 281.56,90.89 RL71.1
LAN_MDIP0_L: length 20.3
  TOP w0.089: RL71.2 283.36,90.87 283.45,90.96 285.45,90.96 285.74,90.67 285.74,90.39 v2(285.57,90.23)
  BOTTOM w0.089: v2(285.57,90.23) 285.75,90.05 285.75,83.84 288.67,80.92 291.73,80.92 292.67,79.98 292.98,79.98 293.5,79.46 TL1.1
LAN_MDIP1: length 4.1
  TOP w0.089: RL73.1 281.51,93.35 279.96,93.35 279.49,93.82 UL1.17
LAN_MDIP1_L: length 18.8
  TOP w0.089: v2(287.55,89.06) 287.7,88.92 287.96,88.92 288.05,89.01 288.05,90.22 284.9,93.37 283.84,93.37 RL73.2
  BOTTOM w0.089: v2(287.55,89.06) 287.37,88.88 287.14,88.88 286.85,88.59 286.85,87.29 289.08,85.06 292.61,85.06 293.12,84.54 TL1.5
LAN_MDIP2: length 4.2
  TOP w0.089: RL75.1 281.55,95.72 v4(280.8,95.72) 280.54,95.72 279.9,95.08 279,95.08 278.95,95.02 UL1.20
LAN_MDIP2_L: length 18.5
  TOP w0.089: v2(285.51,96.41) 285.34,96.24 285.34,95.93 285.1,95.7 283.75,95.7 RL75.2
  BOTTOM w0.089: TL1.7 293.76,87.08 293.25,87.59 292.73,87.59 288.54,91.78 288.54,95.48 287.08,96.94 285.49,96.94 285.38,96.84 285.38,96.53 v2(285.51,96.41)
LAN_MDIP3: length 5.1
  TOP w0.089: UL1.23 278.75,96.22 278.84,96.31 279.05,96.31 279.29,96.55 279.29,97.26 279.52,97.5 v4(279.53,97.5) 279.53,97.51 280.2,98.18 281.51,98.18 RL77.1
LAN_MDIP3_L: length 15.8
  TOP w0.089: RL77.2 283.85,98.21 284.91,98.21 285.14,98.45 285.14,98.76 v2(285.33,98.95)
  BOTTOM w0.089: v2(285.33,98.95) 285.18,99.11 285.18,99.27 285.28,99.37 286.34,99.37 290.57,95.14 290.57,94.16 292.05,92.67 292.99,92.67 293.5,92.16 TL1.11
LAN_TEST_EN: length 2.2
  TOP w0.102: UL1.30 275.5,98.99 RL12.1
LAN_WAKE#: length 307.2
  TOP w0.102: v2(280.74,87.92) 280.93,88.11 RL70.1 ; RC323.1 169.92,52.39 v1(169.31,52.39) 164.58,52.39 163.43,53.55 162.49,53.55 v2(162.31,53.72) ; v2(273.31,90.52) 273.5,90.71 UL1.2
  TOP w0.107: v2(270.83,37.9) 270.83,37.98 UE1.L3
  IN1 w0.076: 144.95,63.93 144.82,63.8 144.82,63.7 144.4,63.28 143.91,63.28 143.18,64 142.7,64 141.97,64.74 141.97,65.12 140.43,66.66 139.25,66.66 137.44,68.46 137.44,71.55 v2(137.88,71.99)
  IN1 w0.102: v2(162.31,53.72) 162.31,54.66 160.65,56.32 154.1,56.32 146.5,63.93 144.95,63.93 ; v2(270.83,37.9) 272.87,37.9 274.49,36.28 274.49,35.81 274.86,35.44 275.37,35.44 276.2,36.28 276.54,36.28 277.4,37.14 277.4,37.44 277.63,37.66 279.83,37.66 281,38.83 283.31,38.83 283.52,39.05 v2(284,39.05) 286.32,39.05 292.23,44.95 292.23,46.74 294.85,49.36 294.85,49.61 295.54,50.29 295.54,51.9 295.74,52.1 295.74,55.73 297.07,57.05 297.18,57.05 298.66,58.53 298.66,61.23 299.02,61.59 299.02,64.66 298.91,64.78 298.91,65.25 299.02,65.36 299.02,68.41 300.1,69.5 v2(300.1,70.83)
  IN2 w0.102: v2(181.38,57.34) 181.38,56.75 184.03,54.1 184.82,54.1 199.73,39.19 201.13,39.19 204.45,35.86 206.94,35.86 208.47,34.33 215.24,34.33 217.47,32.11 227.83,32.11 229.3,30.64 233.07,30.64 233.87,29.84 237.94,29.84 238.32,29.46 246.05,29.46 246.51,29 248.21,29 249.21,28 249.21,25.82 252.13,22.9 256.37,22.9 256.54,22.9 258.21,24.57 259.44,24.57 259.67,24.34 260.14,24.34 261.96,22.52 268.93,22.52 269.39,22.07 272.5,22.07 273.03,22.6 273.03,22.94 273.4,23.31 275.61,23.31 v2(275.82,23.1) ; v2(300.1,70.83) 299.66,70.83 299.16,71.33 294.73,71.33 294.68,71.28 283.21,71.28 281.37,73.12 281.37,87.6 281.05,87.6 v2(280.74,87.92) 280.42,87.6 279.53,87.6 276.61,90.52 v2(273.31,90.52)
  BOTTOM w0.076: UC1.AM15 137.52,72.35 v2(137.88,71.99)
  BOTTOM w0.102: v2(162.31,53.72) 162.75,53.72 164.23,52.24 177.24,52.24 181.38,56.39 v2(181.38,57.34) ; v2(284,39.05) 284,38.96 284.73,38.23 284.73,34.41 284.02,33.7 281.97,33.7 280.65,32.38 280.65,28.62 280.94,28.33 280.94,27.12 280.03,26.21 277.45,26.21 275.78,24.54 275.78,23.14 v2(275.82,23.1)
LCD_CBL_DET#: length 120.6
  TOP w0.102: v2(79.92,92.5) 80.01,92.41 81.16,92.41 81.28,92.54 81.28,93.6 79.89,95 79.89,97 78.68,98.2 78.68,99.35 79.5,100.17 79.5,102.96 82.04,105.5 v1(82.04,108.87) 82.04,112.87 80.18,114.73 v2(79.2,114.73)
  IN1 w0.102: v2(110.08,93.1) 109.89,93.29 108.7,93.29 108.6,93.19 105.92,93.19 105.82,93.09 105.82,93.09 105.53,92.79 88.07,92.79 87.39,92.12 86.22,92.12 85.92,92.42 84.47,92.42 81.87,92.42 81.21,91.77 80.22,91.77 79.92,92.07 79.92,92.5 v2(79.92,92.5)
  IN2 w0.102: v2(110.08,93.1) 110.76,93.78 114.69,93.78 115.36,93.11 116.14,93.11 116.66,93.63 116.66,94.18 117.89,95.4 123.24,95.4 126.39,92.25 126.39,89.89 126.71,89.57 126.71,85.47 126.41,85.17 126.41,84.59 127.38,83.61 127.38,83.29 127.55,83.12 127.55,82.58 126.89,81.92 126.89,77.39 127.68,76.59 127.68,75.81 128.8,74.69 128.99,74.69 130.63,73.06 133.36,73.06 133.42,72.99 135.98,72.99 136.27,73.28 136.27,74.72 137.02,75.47 138.82,75.47 139.7,76.36 142.61,76.36 v2(143.05,75.91)
  BOTTOM w0.076: v2(143.05,75.91) 143.63,76.48 UC1.AC3 ; v2(110.08,93.1) 110.17,93.2 110.17,93.62 RC287.1
  BOTTOM w0.102: JEDP1.40 78.2,116.8 78.81,116.2 78.81,115.13 v2(79.2,114.73)
LCD_TST: length 250.8
  TOP w0.102: RE20.1 263.59,34.87 264.08,35.35 v2(264.08,35.7) 264.41,36.03 264.43,36.03
  TOP w0.107: 264.43,36.03 264.82,36.42 UE1.D1
  IN2 w0.102: v2(248.17,40.95) 248.17,40.65 249.35,39.46 250.3,39.46 251.75,38.02 252.96,38.02 253.05,38.11 254.96,38.11 255.65,37.41 257.36,37.41 257.77,36.99 259.59,36.99 260.62,35.97 260.62,35.16 260.97,34.81 263.19,34.81 v2(264.08,35.7) ; v2(242.64,50.38) 242.46,50.2 210.16,50.2 191.1,69.25 190.57,69.25 189.01,70.81 189.01,71.98 178.29,82.7 178.29,82.78 176.84,84.23 176.84,86.82 178.23,88.21 178.23,90.5 175.58,93.15 175.58,95.24 172.15,98.67 172.15,99.75 168.64,103.27 168.43,103.27 163.34,108.36 159.26,108.36 159.19,108.44 158.52,108.44 150.79,116.17 145.85,116.17 145.21,115.54 109.95,115.54 107.49,113.07 103.57,113.07 101.99,114.65 89.79,114.65 89.09,113.95 80.86,113.95 79.48,115.33 77.93,115.33 77.28,115.99 70.63,115.99 v2(70.45,115.81)
  BOTTOM w0.102: JEDP1.24 70.2,116.28 70.45,116.03 v2(70.45,115.81) ; v2(242.64,50.38) 242.66,50.37 242.66,49.36 240.97,47.66 240.97,43.55 242.24,42.27 245.04,42.27 v3(245.19,42.12) 246.36,40.95 v2(248.17,40.95)
LCD_VCC_TEST_EN: length 248.5
  TOP w0.102: v1(70.17,103.87) 70.17,104.22 70.41,104.46 DV3.2 69.4,105.43 v2(69.34,105.5)
  TOP w0.107: UE1.E1 265.62,36.53 265.12,36.03 v2(265.12,35.7)
  IN2 w0.102: v2(69.34,105.5) 69.34,105.5 70.15,105.5 70.91,106.26 72.53,106.26 72.8,105.99 72.8,105.71 73.05,105.45 74.66,105.45 77.35,108.15 92.45,108.15 93.25,107.35 97.59,107.35 97.91,107.67 100.7,107.67 101.22,107.16 105.04,107.16 105.39,106.81 119.53,106.81 121.81,109.09 125.47,109.09 127.41,111.03 142.16,111.03 143.31,109.88 143.31,109.18 143.72,108.77 150.63,108.77 157.99,101.41 157.99,100.21 160.09,98.11 161.29,98.11 161.57,97.83 163.05,97.83 164.59,96.28 166.31,96.28 167.98,94.61 170.9,94.61 172.01,93.5 172.01,91.18 171.52,90.69 171.52,87.05 172.01,86.56 172.01,81.61 172.91,80.71 172.91,79.7 176.92,75.69 178.01,75.69 179.95,73.75 179.95,71.56 182.05,69.46 182.67,69.46 182.85,69.65 183.46,69.65 184.81,68.29 184.81,67.04 189.88,61.97 189.88,61.21 191.19,59.9 191.83,59.9 197.3,54.43 197.9,54.43 207.77,44.56 209.2,44.56 221.25,44.56 222.37,43.44 231.46,43.44 232.12,42.78 236.84,42.78 237.22,42.41 248.45,42.41 251,39.85 251,39.05 251.83,38.22 252.88,38.22 252.97,38.31 255.62,38.31 255.74,38.43 256.47,38.43 257.17,37.72 257.33,37.72 257.86,37.19 259.68,37.19 261.26,35.61 261.95,35.61 262.66,36.33 264.56,36.33 265.12,35.76 v2(265.12,35.7)
LED_10_GRN#: length 2.6
  TOP w0.102: QL2.6 295.24,81.26 295.24,82.48 RL19.1 295.81,82.52 v3(296.2,82.91)
LED_10_GRN_R#: length 38.6
  TOP w0.102: v2(292.74,82.64) 292.86,82.52 v3(293.31,82.52) RL19.2
  IN3 w0.102: v2(292.74,82.64) 293.25,83.15 293.25,85.69 292.18,86.76 292.18,95.84 292.62,96.29 292.62,99.61 293.5,100.49 306.83,100.49 JLOM1.11
LED_100_ORG#: length 2.1
  TOP w0.102: v3(297.36,82.26) RL20.1 298.37,82.21 QL1.3
LED_100_ORG_R#: length 42.5
  TOP w0.102: RL20.2 v2(298.32,83.93) v3(298.32,84.49)
  IN3 w0.102: JLOM1.13 308.64,96.39 308.64,98.3 306.71,100.23 293.69,100.23 292.86,99.41 292.86,96.24 292.4,95.78 292.4,87.17 293.78,85.79 297.59,85.79 298.32,85.06 v2(298.32,83.93)
LG1_ISL88738:
  vias: v1(63.04,89.54) v2(63.48,89.86) v2(63.88,89.43)
LG2_ISL88738: length 8.1
  TOP w0.102: v2(64.38,90.43) v3(64.38,91.11)
  IN3 w0.762: 60.77,84.11 60.77,84.68 61.29,85.2 61.29,86.41 62.17,87.28 63.38,87.28 64.58,88.49 64.58,89.25
  vias: v2(60.1,83.71) v2(60.1,83.13) v2(64.77,90.02)
LID_CL#: length 262.9
  TOP w0.102: RE26.1 281.64,45.05 v2(282.33,44.35) ; UZ1.3 153.47,116.67 152.78,115.98 152.78,114.39 153.1,114.08 155.53,114.08 160.07,109.54 161.62,109.54 v1(163,108.17) 163.28,107.88 v2(163.28,106.73) ; v2(250.75,33.57) 250.75,33.03 251.06,32.72 UZ10.2
  IN1 w0.102: v2(163.28,106.73) 164.76,105.25 164.76,101.37 163.22,99.83 163.22,93.59 163.84,92.97 163.84,87 162.14,85.3 161.38,85.3 160.94,84.87 160.94,83.37 161.09,83.23 163.5,83.23 163.84,82.89 163.84,81.29 163.47,80.92 163.47,79.77 164.61,78.63 v2(165.03,78.63)
  IN2 w0.102: v2(288.37,22.27) 288.7,21.94 288.7,21.46 292.72,17.44 293.96,17.44 299.96,11.44 299.96,10.26 300.49,9.73 301.67,9.73 302.89,8.52 307.99,8.52 v2(310.72,5.79) ; v2(165.03,78.63) 164.77,78.38 164.77,77.59 165.01,77.35 168.06,77.35 169.2,76.21 169.2,74.76 173.8,70.16 173.8,69.49 174.27,69.02 174.72,69.02 177.68,66.06 178.89,66.06 185.25,59.7 185.38,59.7 189.03,56.05 189.03,55.95 190.23,54.76 191.42,54.76 203.76,42.41 203.76,41.58 205.8,39.54 211.2,39.54 212.73,38.02 220.36,38.02 221.04,37.34 231.42,37.34 232.23,36.53 243.3,36.53 243.7,36.13 246.21,36.13 248.26,34.07 250.25,34.07 v2(250.75,33.57) 253.69,33.57 254.31,32.95 254.31,30.31 254.57,30.04 258.12,30.04 258.7,29.46 261.95,29.46 263.98,27.44 266.71,27.44 266.89,27.62 277.97,27.62 280.1,29.75 280.91,29.75 281.43,30.27 v2(281.43,32.1) 281.43,32.74 280.99,33.18 280.99,42.23 282.12,43.36 282.12,44.14 v2(282.33,44.35)
  BOTTOM w0.102: v2(310.72,5.79) 311.49,6.56 JLED1.5 ; v2(281.43,32.1) 281.48,32.1 281.88,32.49 284.6,32.49 285.12,31.97 285.12,28.57 288.75,24.94 288.75,24.46 289.36,23.85 289.36,23.27 v2(288.37,22.27)
LID_CL#_NB: length 12.2
  TOP w0.102: RE25.2 280.72,46.18 RE26.2 282.55,46.18 CE8.1
  TOP w0.107: RE25.2 280.54,46.21 279.47,47.27 276.01,47.27 275.35,46.62 v1(275.21,46.62) 274.92,46.33 274.7,46.33 274.69,46.32 274.15,46.32 273.42,45.6 273.42,45.37 272.84,44.79 UE1.N11
LID_CL#_PCH: length 38.1
  BOTTOM w0.076: UC1.AW7 141.76,67.76 142.08,67.44 142.08,65.53 142.64,64.97 142.87,64.97 143.17,65.27 143.2,65.27 143.23,65.3 143.66,65.3 143.7,65.27 143.78,65.27 144.75,64.29 146.19,64.29 147.22,63.26 147.22,62.25
  BOTTOM w0.102: 147.22,62.25 147.22,61.37 147.59,61 147.59,60.87 148.3,60.16 149.82,60.16 149.94,60.27 157.67,60.27 158.41,61 161.91,61 162.41,61.51 168.89,61.51 169.72,62.34 171.64,62.34 T268.1
LINE1_L: length 2.7
  TOP w0.203: CA43.1 302.17,28.69 301.91,28.69 301.71,28.9 UA1.22
LINE1_R: length 2.2
  TOP w0.203: UA1.21 301.31,28.83 302.14,28.01 CA44.1
LM393_P: length 19.7
  TOP w0.102: PU1201.8 38.74,75.19 PC1201.2 37.95,74.62 37.31,74.62 v2(37.26,74.67) 36.73,75.2 36.73,75.33 36.35,75.71 34.27,75.71 34.19,75.63 33.02,75.63 32.71,75.94 32.01,75.94 31.8,75.74 31.8,75.36 31.68,75.23 31.68,74.82 32.03,74.47 32.21,74.47 32.71,73.96 PC949.2 32.71,72.79 PU903.5 31.8,72.66 30.96,73.5 30.96,74.09 30.58,74.47 30.28,74.47 29.29,75.46 PR950.2
  BOTTOM w0.102: PD1801.1 37.11,74.52 v2(37.26,74.67) v3(37.83,75.23)
LOM_ACTLED_YEL#: length 42.6
  TOP w0.102: v3(299.46,79.01) 298.63,79.84 QL1.1 297.42,79.84 v2(297.31,79.72) ; UL1.26 277.1,97.87 v2(277.75,98.52)
  IN3 w0.102: v2(297.31,79.72) 295.66,81.37 291.28,81.37 290.71,81.95 290.71,87.6 290.45,87.85 290.45,99.15 289.37,100.24 279.47,100.24 v2(277.75,98.52)
LOM_CABLE_DETECT#: length 93.3
  TOP w0.102: v2(283.52,33.28) 283.81,33.57 RE505.1 ; v3(297.19,83.83) 296.9,83.53 v2(296.17,83.53) 295.59,84.11 UL2.4
  TOP w0.107: v2(263.52,35.71) 263.52,35.79 264.44,36.71 264.44,36.87 264.82,37.25 UE1.D2
  IN1 w0.102: v2(301.12,70.07) 299.73,68.69 299.73,61.79 300.58,60.95 300.58,57.6 298.38,55.4 298.38,53.3 297.26,52.19 297.26,50.58 295.89,49.21 295.89,48.81 293.4,46.32 293.4,44.61 292.74,43.95 292.74,42.8 288.9,38.97 288.04,38.97 285.08,36.01 285.08,34.84 v2(283.52,33.28) 283.05,33.28 281.39,34.93 279.69,34.93 279.31,35.31 277.32,35.31 276.79,34.79 276.79,32.38 276.17,31.75 275.73,31.75 274.31,33.17 271.91,33.17 271.37,33.71 269.28,33.71 268.21,34.78 267.62,34.78 267.09,35.32 263.91,35.32 v2(263.52,35.71)
  IN3 w0.102: v2(301.12,70.07) 302.39,71.34 302.39,74.14 298.1,78.42 298.1,81.09 296.17,83.03 v2(296.17,83.53)
LOM_SPD10LED_GRN#: length 40.2
  TOP w0.102: v2(290.2,87.22) 290.2,85.96 291.4,84.76 ; QL2.1 291.6,81.12 290.83,81.88 290.83,84.2 291.4,84.76 ; RL30.2 296.05,84.76 UL2.2 v1(291.72,84.76) 291.4,84.76 ; UL1.25 277.5,97.91 277.73,98.14 278.01,98.14 v2(278.39,98.52)
  IN3 w0.102: v2(290.2,87.22) 290.2,99.03 289.44,99.79 279.66,99.79 v2(278.39,98.52)
LOM_SPD100LED_ORG#: length 44.1
  TOP w0.102: v2(277.12,98.52) 276.7,98.1 UL1.27 ; v2(292.23,85.69) 292.51,85.41 UL2.1 293.85,85.41 294.44,86 RL29.2 294.44,86.89 295.02,87.47 297.06,87.47 297.31,87.22 297.31,86.37 297.35,86.33 297.35,86.02 297.31,85.98 v3(297.31,85.71) 297.55,85.46 297.55,83.22 296.47,82.14 QL1.4
  IN3 w0.102: v2(292.23,85.69) 291.72,86.2 291.72,88.23 290.71,89.25 290.71,99.54 289.55,100.69 279.28,100.69 v2(277.12,98.52)
LPM_ZVM_N: length 97.9
  TOP w0.254: PR1303.1 v2(43.84,54.13) ; v2(113.13,70.68) 113.13,69.6 110.09,66.56 110.09,64.9 109.64,64.46 107.46,64.46 106.02,63.03 106.02,59.69 102.29,55.95 81.9,55.95 79.83,53.88 59.6,53.88 58.08,55.4 56.74,55.4 56.68,55.47 v2(56.68,55.48) ; v2(41.48,41.8) v3(42.52,41.8) 43.11,41.22 PR1314.1
  IN2 w0.254: v2(41.48,41.8) 41.48,51.77 v2(43.84,54.13)
  IN3 w0.254: v2(43.84,54.13) 47.96,54.13 48.75,54.93 53.91,54.93 54.37,55.39 56.58,55.39 v2(56.68,55.48)
  BOTTOM w0.076: UC1.AR56 113.42,70.4 v2(113.13,70.68)
LPS_PROTECT#: length 1.8
  BOTTOM w0.102: PR1248.2 44.62,73.22 45.75,73.22 PT1.1
LPSS_UART2_RXD: length 31.4
  BOTTOM w0.102: RC402.1 152.08,74.26 152.47,74.65 153.75,74.65 153.89,74.79 153.89,75.13 154.31,75.55 RC330.1 ; JUART1.3 163.81,66.64 162.45,68.01 162.45,69.8 161.94,70.31 158.17,70.31 157.95,70.53 156.59,70.53 155.79,71.32 155.79,74.82 v1(155.62,75) 155.07,75.55 RC330.1 ; RC330.1 154.32,75.96 154.22,76.06 154.22,76.38 153.74,76.87 149.74,76.87 149.3,76.43 149.3,75.67 148.83,75.2 147.75,75.2 147.55,75.41 146.38,75.41 145.97,75.82 UC1.AD1
LPSS_UART2_TXD: length 30.2
  BOTTOM w0.102: UC1.AD2 145.14,76.1 145.96,76.1 146.46,75.6 147.63,75.6 147.83,75.39 148.75,75.39 149.1,75.74 149.1,76.5 149.67,77.07 153.85,77.07 154.52,76.4 RC403.1 154.66,76.4 RC331.1 155.75,78.37 157.08,78.37 157.31,78.14 157.31,76.33 158.29,75.36 158.29,73.74 158.61,73.41 159.07,73.41 159.32,73.17 159.32,72.87 159.71,72.48 160.06,72.48 v1(161.27,71.26) 162.7,69.84 162.7,68.14 163.39,67.44 JUART1.2
LX1_ISL88738: length 7.6
  TOP w0.102: v3(64.73,89.48) 63.51,88.26 v2(63.1,88.26)
  IN3 w0.762: 58.36,86.9 61.22,89.76 62.61,89.76
  vias: v2(54.06,86.89) v2(54.65,86.89) v2(55.23,87.03) v2(55.24,86.42) v2(55.16,81.68) v2(55.62,85.16) v2(55.62,84.1) v2(55.62,83.04) v2(55.72,81.68) v2(55.81,87.02) v2(55.8,86.45) v2(56.35,85.16) v2(56.28,81.68) v2(56.38,87.02) v2(56.37,86.45) v2(56.95,87.03) v2(56.95,86.46) v2(57.53,87.02) v2(57.53,86.45) v2(63.1,88.82)
LX2_ISL88738: length 0.5
  TOP w0.102: v2(66.2,90.6) v3(66.2,91.14)
  vias: v2(60.18,80.89) v2(60.19,80.29) v2(60.49,82.6) v2(60.76,80.89) v2(60.77,80.3) v2(60.9,83.02) v2(61.3,82.62) v2(61.36,80.9) v2(61.36,80.3) v2(61.47,83.53) v2(61.8,83.03) v2(61.94,80.91) v2(62.04,85.92) v2(62.04,84.86) v2(62.11,83.53) v2(62.19,82.59) v2(62.19,82.01) v2(62.19,81.43) v2(62.77,85.92) v2(63.5,85.92) v2(66.21,90.02)
LX_1.8VALW: length 1
  BOTTOM w0.102: 164.02,103.85 v1(164.02,104.87)
LX_3V: length 3.1
  BOTTOM w0.254: PU100.6 235.78,27.78 235.75,27.76 233.11,27.76 PU100.20
  vias: v1(229.17,21.88) v2(229.24,22.57) v2(229.87,22.57)
LX_5V: length 2.9
  BOTTOM w0.254: 36.02,47.26 36.02,44.88 36.11,44.8 PU102.6
  vias: v1(37.63,49.13) v2(37.31,50.89) v2(37.36,50.23)
LX_DDR: length 1.9
  BOTTOM w0.102: PR202.1 28.97,30.4 v3(28.77,30.19)
LX_VCC_EDRAM:
  vias: v3(54.65,56.27)
LX_VCC_EOPIO: length 0.7
  TOP w0.102: 53.85,45.5 v1(54.55,45.5)
M2280_DEVSLP: length 266.9
  TOP w0.076: JNGFF3.38 29.1,14.69
  TOP w0.102: 29.1,14.69 29.1,14.79 27.76,16.14 24.16,16.14 23.87,16.43 RN37.2 23.48,17.31 23.48,17.86 24.36,18.75 24.36,20.82 v1(23.69,21.49) 23.37,21.81 21.58,21.81 v2(21.53,21.86)
  IN1 w0.102: v2(147.77,84.91) 147.77,86.12 148.3,86.66 148.3,92.4 148.4,92.5 148.4,95.19 147.59,96 147.59,97.28 146.41,98.46 146.41,100.91 144.18,103.13 144.18,106.38 141.03,109.54 v2(139.32,109.54)
  IN2 w0.102: v2(139.32,109.54) 139.16,109.7 130.03,109.7 127.79,107.46 126.99,107.46 126.33,108.12 122.13,108.12 119.84,105.84 119.16,105.84 118.43,105.11 109.07,105.11 105.42,105.11 104.45,106.08 93.23,106.08 92.42,106.89 77.38,106.89 75,104.51 71.86,104.51 71.55,104.82 59.42,104.82 58.99,104.39 55.62,104.39 53.92,106.08 51.05,106.08 50.08,107.05 45.49,107.05 44.17,105.73 42.68,105.73 41.58,106.84 40.44,106.84 38.25,104.65 38.25,103.79 35.12,100.65 35.12,95.33 34.54,94.76 34.54,93.07 35.03,92.58 35.03,91.34 35.84,90.54 35.84,85.6 39.22,82.22 39.22,82.03 39.85,81.39 39.85,80.28 39.55,79.98 39.05,79.98 38.86,79.79 38.86,78.38 37.78,77.3 37.78,74.55 v2(36.94,73.71) ; v2(21.53,21.86) 23.22,23.55 23.22,29.73 23.62,30.13 23.62,32.1 24.01,32.48 24.01,38 22.86,39.15 22.86,43.27 23.94,44.35 23.94,53.88 28.35,58.29 30.19,58.29 30.63,58.74 31.87,58.74 32.22,59.09 39.56,59.09 41.12,60.65 41.12,62.68 39.76,64.04 39,64.04 38.45,63.49 36.21,63.49 35.66,64.04 35.66,67.77 36.72,68.83 v2(36.88,68.83)
  IN3 w0.102: v2(36.88,68.83) 37.28,69.24 37.28,73.36 v2(36.94,73.71)
  BOTTOM w0.076: v2(147.77,84.91) 147.77,84.74 147.07,84.04 145.41,84.04 145.28,83.99 145.15,83.99 144.92,84.05 144.92,84.05 144.79,84.05 144.57,83.98 144.41,83.98 UC1.J3
M2280_PCIE_SATA#: length 262.7
  IN1 w0.102: v2(147.27,87.4) 147.27,88.54 147.66,88.94 147.66,92.33 147.99,92.66 147.99,94.8 146,96.78 146,100.74 143.45,103.29 143.45,105.37 139.74,109.08 138.41,109.08 v2(138.18,109.31)
  IN2 w0.102: v2(138.18,109.31) 138.03,109.47 130.09,109.47 127.87,107.25 126.91,107.25 126.24,107.92 122.21,107.92 119.92,105.63 119.25,105.63 118.52,104.9 108.98,104.9 108.98,104.9 106.8,104.9 105.33,104.9 104.47,105.77 100.8,105.77 100.7,105.87 93.15,105.87 92.34,106.69 77.47,106.69 75.07,104.29 71.79,104.29 71.46,104.62 59.5,104.62 59.07,104.18 55.54,104.18 54.29,105.43 45.84,105.43 42.97,102.56 41.82,102.56 40.83,103.55 39.55,103.55 38.02,102.02 38.02,95.5 38.74,94.79 38.74,91.91 39.57,91.07 39.57,90.53 40.66,89.45 40.66,88.13 42.5,86.29 42.5,83.68 42.61,83.56 42.61,75.82 43.35,75.09 43.35,70.59 42.59,69.84 42.59,61.83 39.64,58.88 32.32,58.88 31.94,58.5 30.68,58.5 30.22,58.04 28.39,58.04 25.11,54.76 25.11,48.34 24.55,47.78 24.55,45.25 24.14,44.84 24.14,44.43 24.14,44.27 23.07,43.19 23.07,39.23 24.21,38.09 24.21,32.3 23.83,31.92 23.83,30.05 23.42,29.64 23.42,22.96 v2(21.62,21.16)
  BOTTOM w0.076: UC1.G4 143.83,84.84 144.98,84.84 145.1,84.89 145.28,84.89 145.41,84.84 145.85,84.84 146.95,85.93 146.95,87.07 v2(147.27,87.4) 147.58,87.7 148.74,87.7
  BOTTOM w0.102: 148.74,87.7 v3(149.23,87.7) 151.06,87.7 153.81,84.95 157.71,84.95 159.8,87.04 162.04,87.04 162.78,87.78 RPC4.4 ; v2(21.62,21.16) 20.79,20.33 20.79,18.6 21.35,18.04 JNGFF3.69
M3042_DEVSLP: length 185.1
  IN1 w0.076: 148.96,84.88 148.96,84.85 148.15,84.04 146.56,84.04 146.29,83.78 v2(146.29,83.64)
  IN1 w0.102: v2(149.11,93.72) 149.11,92.63 148.71,92.23 148.71,85.72 148.96,85.48 148.96,84.88
  IN2 w0.102: v2(172.93,102.48) 177.19,98.21 177.19,96.16 177.93,95.43 177.93,93.07 179.76,91.24 179.76,86.75 178.56,85.55 178.56,84.66 186.46,76.77 187.1,76.77 190.35,73.51 190.35,71.46 190.64,71.17 191.2,71.17 210.85,51.52 239.96,51.52 241.32,52.88 242.04,52.88 254.16,64.99 255.25,64.99 257.18,66.93 265.36,66.93 270.6,72.17 v2(271.45,72.17)
  BOTTOM w0.076: UC1.J2 145.01,83.78 145.28,83.51 145.68,83.51 145.81,83.64 v2(146.29,83.64)
  BOTTOM w0.102: v2(172.93,102.48) 172.93,101.18 174,100.1 174,97.93 173.18,97.1 170.48,97.1 168.71,95.33 167.41,95.33 166.65,96.09 152.59,96.09 v1(151.17,94.67) 150.74,94.24 149.95,94.24 149.43,93.72 v2(149.11,93.72) ; JNGFF2.30 271.2,72.42 v2(271.45,72.17)
M3042_PCIE#_SATA: length 154.6
  TOP w0.107: v2(269.2,46.06) 268.82,45.68 UE1.J12
  IN1 w0.102: v2(176.69,81.79) 176.69,82.2 176.53,82.35 175.95,82.35 174.9,83.41 163.83,83.41 163.32,83.92 162.3,83.92 v2(161.74,84.49)
  IN2 w0.102: v2(269.2,46.06) 269.2,46.31 269.1,46.42 269.1,48.99 268.19,49.9 268.19,52.22 267.05,53.36 264.49,53.36 264,53.84 259.21,53.84 259.01,54.05 251.3,54.05 244.93,47.68 237.91,47.68 237.4,47.17 232.88,47.17 231.96,48.1 209.42,48.1 192.44,65.07 191.54,65.07 189.06,67.55 189.06,68.49 183.48,74.08 183.48,75.13 179.54,79.06 178.67,79.06 177.87,79.87 177.87,80.61 v2(176.69,81.79)
  BOTTOM w0.076: UC1.H3 144.16,84.17 144.63,84.17 144.73,84.21 144.73,84.21 144.73,84.21 144.76,84.22 144.95,84.22 144.97,84.21 145.17,84.15 145.25,84.15 145.38,84.21 146.49,84.21 148.12,85.85 149.02,85.85 RC412.2 149.91,86.33
  BOTTOM w0.102: v2(161.74,84.49) 161.23,83.98 v3(158.35,83.98) 153.87,83.98 151.52,86.33 149.91,86.33
MASK_BASE_LEDS#: length 20.3
  TOP w0.102: v2(252.71,32.07) UZ10.4
  BOTTOM w0.102: v2(252.71,32.07) v3(253.46,32.83) 253.92,33.28 253.92,39.87 249.45,44.34 QZ7.5
ME_FW_EC: length 49.2
  TOP w0.107: v2(266.81,46.06) 266.81,46 UE1.G12
  IN2 w0.102: v2(239.55,46.56) 240.14,45.97 243.68,45.97 244.55,46.84 246.39,46.84 251.58,52.04 255.33,52.04 256.5,53.21 257.97,53.21 259,52.17 259.56,52.17 261.85,49.88 262.57,49.88 266.39,46.06 v2(266.81,46.06)
  BOTTOM w0.102: SW1.1 240.37,48.51 240.37,48.25 240.18,48.06 238.9,48.06 RC221.1 238.56,47.64 238.19,47.27 237.3,47.27 237.15,47.42 237.15,49.07 236.86,49.36 236.02,49.36 235.56,48.9 v3(235.56,47.92) 235.56,47.4 236.61,46.34 239.33,46.34 v2(239.55,46.56)
ME_FWP: length 183.7
  TOP w0.112: v2(143.78,51.15) 143.39,51.55 137.23,51.55 135.83,52.95 RC223.1
  IN1 w0.102: 187.42,41.59 187.42,41.73 186.32,42.83 185.44,42.83
  IN1 w0.119: v2(143.78,51.15) 143.78,51.14 145.61,49.31 148.18,49.31 155.42,42.07 180.7,42.07 181.46,42.83 185.44,42.83 ; 187.42,41.59 188.23,40.78 189.14,40.78 191.69,38.23 191.69,37.14 195.85,32.97 196.38,32.97 198.8,30.55 199.37,30.55 202.37,27.55 207.98,27.55 208.67,28.24 213.22,28.24 214.38,29.39 218.68,29.39 219.1,29.39 220.13,29.39 221.45,30.71 225.91,30.71 226.32,30.31 228.11,30.31 228.15,30.27 228.19,30.27 228.42,30.04 228.42,29.99 228.78,29.64 229.57,29.64 231.32,29.64 231.82,29.62 233.5,27.94 233.94,27.5 234.56,27.5 234.69,27.5 235.84,26.34 236.28,25.9 236.3,25.9 236.3,25.9 236.39,25.9 237.79,24.49 239.32,24.49 239.5,24.68 240.14,24.68 240.52,24.3 242.85,24.3 243.27,23.88 v2(244.47,23.88)
  BOTTOM w0.102: RC221.2 237.64,49.77 240.92,53.05 242.21,53.05 242.55,52.71 SW1.3 243.85,50.43 243.85,49.87 v3(241.73,47.76) 241.17,47.19 241.17,43.72 242.42,42.47 248.38,42.47 250.75,40.1 250.75,35.75 248.57,33.57 245.94,33.57 245.65,33.86 245.65,34.76 245.55,34.86 245.11,34.86 244.97,34.72 241.79,34.72 241.32,34.25 241.32,32.31 241.91,31.71 241.91,27.67 244.22,25.36 244.22,24.13 v2(244.47,23.88)
ME_RESET#: length 2.4
  BOTTOM w0.112: RC225.1 RC227.1 149.22,102.01 149.08,101.87 UC12.2
ME_SUS_PWR_ACK: length 148.8
  TOP w0.102: v2(138.74,70.02) 139.01,69.75 140.05,69.75 140.18,69.63 140.18,68.26 v1(141.35,67.09) 144.56,67.09 146.02,65.63 146.6,65.63 146.61,65.63 147.77,65.63 150.86,62.54 151.41,62.54 152.04,61.9 154.04,60.58 159.09,60.58 159.78,61.27 RC74.1 160.25,61.16 159.7,60.61 159.7,59.91 160.05,59.57 v2(160.31,59.57)
  TOP w0.107: UE1.B13 263.22,46.86 262.79,47.3 261.86,47.3 261.75,47.19 v2(261.75,46.06)
  IN1 w0.102: v2(160.31,59.57) 160.53,59.35 160.53,59.21 161.23,58.51 161.23,56.45 162.37,55.31 164.07,55.31 166.95,52.44 172.67,52.44 172.76,52.35 180.28,52.35 181.1,51.53 183.02,51.53 183.56,51 189.58,51 190.12,50.46 190.89,50.46 197.41,43.94 198.01,43.94 200.76,41.19 200.79,41.21 200.88,41.21 200.93,41.17 201.41,41.17 201.46,41.21 202.82,41.21 204.08,39.95 204.93,39.95 205.1,39.95 206.39,38.66 210.74,38.66 211.52,37.88 215.95,37.88 216.08,37.88 216.85,38.65 216.93,38.65 217.09,38.82 230.02,38.82 230.23,39.02 236.36,39.02 236.99,38.39 238.68,38.39 238.85,38.56 241.33,38.56 241.55,38.35 244.58,38.35 244.61,38.38 246.5,38.38 247.25,39.13 247.68,39.13 249.49,40.94 249.66,40.94 251.12,40.94 251.35,41.17 256.35,41.17 258.39,43.21 258.39,43.65 258.39,43.82 260.4,45.83 261.52,45.83 v2(261.75,46.06)
  BOTTOM w0.076: UC1.AR13 138.36,70.4 v2(138.74,70.02)
MEC_XTAL1: length 13
  TOP w0.112: UE1.A1 260.96,36.79 260.48,36.3 260.48,33.13 260.74,32.87 260.74,31.85 260.55,31.66 260.55,31.28 260.1,30.83 v3(259.95,30.83) 258.77,30.83 258.12,31.48 CE28.1 256.94,31.48 256.18,30.72 YE1.1
MEC_XTAL2: length 2.8
  TOP w0.112: YE1.2 256.41,33.22 CE29.1 RE290.2
MEC_XTAL2_R: length 7.7
  TOP w0.112: RE290.1 258.74,33.95 258.74,36.24 v3(260.04,37.54) 260.8,38.3 261.93,38.3 262.01,38.39 UE1.A3
MEDIACARD_IRQ#: length 225.8
  TOP w0.102: RR19.1 295.98,54.5 v2(296.12,54.64) 296.19,54.64 296.45,54.39 UR1.32
  IN1 w0.102: v2(286.12,38.46) 286.2,38.46 289.33,41.6 290.26,41.6 291.92,43.26 291.92,44.32 292.58,44.98 292.58,46.66 295.07,49.15 295.07,49.54 295.74,50.21 295.74,51.82 296.12,52.2 v2(296.12,54.64)
  IN2 w0.102: v2(288.32,21.67) 287.85,22.14 287.85,22.91 285.64,25.11 281.07,25.11 279.49,23.53 272.85,23.53 271.84,22.52 269.22,22.52 269.02,22.73 263.24,22.73 261.89,24.08 261,24.08 260.3,24.78 258.13,24.78 256.45,23.1 252.35,23.1 249.85,25.6 249.85,29.85 248.65,31.05 244.99,31.05 244.82,30.89 241.42,30.89 240.95,31.36 240.95,31.39 239.49,32.85 233.2,32.85 232.42,33.63 221.87,33.63 219.69,35.81 209.01,35.81 207.53,37.28 205.45,37.28 201.37,41.37 200.34,41.37 188.98,52.74 188.3,52.74 186.76,54.28 186.76,54.83 185.31,56.28 184.67,56.28 179.05,61.9 178.81,61.9 172.3,68.4 171.37,68.4 169.89,69.88 167.76,69.88 165.05,72.59 161.71,72.59 160.84,73.45 159.64,73.45 159.16,72.98 159.16,70.75 158.7,70.28 158.49,70.07 151.36,70.07 150.93,69.64 146.01,69.64 145.26,70.38 144.03,70.38 143,69.35 143,69.21 142.82,69.02 141.25,69.02 141.09,69.18 141.09,71.01 141.42,71.33 v2(141.48,71.33)
  BOTTOM w0.076: v2(141.48,71.33) 141.4,71.33 UC1.AN8
  BOTTOM w0.102: v2(286.12,38.46) 285.47,37.81 285.47,34.09 285.32,33.94 v3(285.32,32.37) 285.32,28.66 288.8,25.18 289.29,25.18 289.64,24.83 289.64,22.83 288.48,21.67 v2(288.32,21.67)
MEM_INTERLEAVED: length 24.4
  IN1 w0.076: 144.57,82.77 144.57,81.4 143.4,80.22 v2(143.12,80.22)
  IN1 w0.102: v2(144.72,96.2) 145.98,96.2 147.15,95.03 147.15,93.15 145.36,91.36 145.36,88.47 144.57,87.69 144.57,82.77
  BOTTOM w0.076: UC1.P2 144.67,81.13 144.36,80.82 143.5,80.82 143.12,80.44 v2(143.12,80.22)
  BOTTOM w0.102: v3(142.23,95.99) 142.43,96.2 RC371.1 RC372.1 v2(144.72,96.2)
MEM_SMBCLK: length 13.8
  TOP w0.112: QC2.6 148.36,81.54 148.65,81.83 v2(148.65,82.94) 148.65,83.03 148.06,83.62 CC320.1
  IN1 w0.076: v2(148.65,82.94) 148.65,80.88 148.25,80.47 145.02,80.47 144.36,79.81 142.27,79.81 142.19,79.88 142.19,79.98 v2(142.42,80.2)
  BOTTOM w0.076: RC12.1 148.65,83.41 v2(148.65,82.94) ; UC1.R7 142.14,80.49 v2(142.42,80.2)
MEM_SMBDATA: length 13.2
  TOP w0.112: v2(149.24,82.94) 149.04,82.74 149.04,82.41 149.14,82.3 149.35,82.3 QC2.3
  IN1 w0.076: v2(149.24,82.94) 148.86,82.56 148.86,80.79 148.33,80.27 145.11,80.27 144.44,79.6 142.18,79.6 141.99,79.8 141.99,80 v2(141.78,80.21)
  BOTTOM w0.076: v2(149.24,82.94) 149.24,83.4 RC14.1 ; v2(141.78,80.21) 141.49,80.51 UC1.R8
MPHYP_PWR_EN: length 33.4
  TOP w0.102: RC387.1 165.2,71.39 v1(165.2,72.42) 165.2,72.72 v2(164.84,73.08)
  IN2 w0.102: v2(139.65,71.94) 140.14,71.94 140.71,72.51 142.74,72.51 143.56,71.69 145.17,71.69 145.17,71.69 145.34,71.69 147.87,71.69 148.16,71.4 152.18,71.4 152.34,71.24 157.46,71.24 158.3,72.08 158.3,74.24 158.64,74.58 162.5,74.58 162.86,74.95 163.69,74.95 164.84,73.8 v2(164.84,73.08)
  BOTTOM w0.076: UC1.AM10 140.06,72.35 v2(139.65,71.94)
MSCLK: length 72.6
  TOP w0.112: UE1.H10 v2(268.42,44.39)
  IN3 w0.135: v2(268.42,44.39) 267.55,45.26 267.55,45.96 268.74,47.15 268.74,51.61 269.05,51.92 271.17,51.92 272.02,52.76 272.88,52.76 273.55,52.09 276.11,52.09 277.44,53.43 277.44,55.21 277.73,55.5 280.29,55.5 281.22,56.42 284.65,56.42 286.09,54.98 292.5,54.98 293.02,55.5 293.53,55.5 294.6,56.57 294.6,59.75 294.07,60.28 294.07,63.25 294.5,63.67 294.5,66.62 293.23,67.89 293.23,70.31 294.27,71.36 296.34,71.36 296.84,71.86 298.29,71.86 298.79,71.36 300.07,71.36 300.36,71.65 300.36,71.91 v2(300.52,72.07)
  BOTTOM w0.112: RE72.2 300.87,75.26 300.87,75.11 300.38,74.62 300.38,73.99 300.51,73.86 JDEG1.6 300.51,72.93 300.38,72.8 300.38,72.22 v2(300.52,72.07) 300.35,71.9 300.35,71.64 300.03,71.32 298.4,71.32 296.83,72.89 296.83,73.55 RE30.1
