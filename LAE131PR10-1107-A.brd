# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D0: length 87.1
  IN1 w0.119: v2(101.87,71.83) 101.58,72.12 101.58,72.29 101.95,72.66 101.95,72.84 101.81,72.99 101.64,72.99 101.28,72.63 101.11,72.63 100.93,72.81 100.93,72.98 101.29,73.34 101.29,73.51 101.13,73.67 100.92,73.67 100.56,73.31 100.39,73.31 100.03,73.67 94.08,73.67 89.21,68.8 81.33,68.8 81.21,68.68 81.21,68.24 81.09,68.12 80.89,68.12 80.77,68.24 80.77,68.68 80.65,68.8 80.43,68.8 80.3,68.67 80.3,68.24 80.18,68.12 79.95,68.12 79.83,68.24 79.83,68.58 79.71,68.7 79.51,68.7 79.35,68.54 79.35,68.23 79.25,68.12 78.93,68.12 48.49,37.69 48.49,36.09 47.04,34.64 47.04,31.35 v2(47.1,31.29)
  BOTTOM w0.076: v2(101.87,71.83) 102.48,72.44 103.05,72.44 103.41,72.81 104.88,72.81 UC1.AL71
  BOTTOM w0.112: JDIMM1.7 47.82,31.13 47.71,31.02 47.21,31.02 47.1,31.13 v2(47.1,31.29)
DDR_A_D1: length 87.9
  IN1 w0.119: v2(47.1,29.77) 46.71,30.16 46.71,34.78 48.16,36.23 48.16,37.83 79.46,69.13 89.07,69.13 93.94,74 101.26,74 103.39,71.87 v2(103.6,71.87)
  BOTTOM w0.076: UC1.AL68 106.84,72.16 106.63,71.95 106.12,71.95 105.96,71.88 105.78,71.88 105.62,71.93 105.48,71.93 105.26,71.87 105.14,71.87 105.06,71.9 105.03,71.91 104.52,71.91 104.28,71.67 103.81,71.67 v2(103.6,71.87)
  BOTTOM w0.112: v2(47.1,29.77) 46.66,30.21 46.66,32.06 46.82,32.22 JDIMM1.3
DDR_A_D2: length 88.6
  IN1 w0.119: v2(50.71,29.74) 50.71,29.95 51.13,30.38 51.13,32.1 51.91,32.88 51.91,36.94 78.81,63.84 87.77,63.84 87.92,63.99 87.92,65.59 88.04,65.71 88.28,65.71 88.4,65.59 88.4,63.99 88.52,63.87 88.75,63.87 88.87,63.99 88.87,65.59 88.99,65.71 89.23,65.71 89.35,65.59 89.35,63.99 89.47,63.87 89.72,63.87 89.83,63.99 89.83,65.58 89.96,65.71 90.29,65.71 95.09,70.5 v2(99.92,70.5)
  BOTTOM w0.076: UC1.AN68 106.26,71.29 105.76,71.29 105.53,71.05 104.59,71.05 104.55,71.01 102.83,71.01 102.3,70.48 101.64,70.48 101.25,70.08 100.34,70.08 v2(99.92,70.5)
  BOTTOM w0.112: v2(50.71,29.74) 51.32,30.36 JDIMM1.21
DDR_A_D3: length 88.1
  IN1 w0.119: v2(50.71,28.22) 50.63,28.15 50.33,28.15 50.21,28.27 50.21,32.13 50.77,32.69 50.77,33.83 50.89,33.95 51.08,33.95 51.24,34.11 51.24,34.6 51.12,34.72 50.89,34.72 50.77,34.84 50.77,35.08 50.89,35.2 51.12,35.2 51.24,35.32 51.24,35.56 51.12,35.68 50.91,35.68 50.77,35.82 50.77,36.04 50.89,36.16 51.12,36.16 51.24,36.27 51.24,37.21 78.54,64.51 82.74,64.51 82.86,64.63 82.86,66.4 82.98,66.52 83.23,66.52 83.35,66.4 83.35,65.43 83.46,65.31 83.7,65.31 83.82,65.43 83.82,66.4 83.94,66.52 90.15,66.52 94.86,71.23 96.51,71.23 v2(97.11,71.84)
  BOTTOM w0.076: UC1.AN69 106.08,71.68 105.83,71.68 105.61,71.76 105.48,71.76 105.25,71.69 105.15,71.69 105.14,71.69 105.13,71.69 105.11,71.69 104.99,71.75 104.59,71.75 104.35,71.5 102.6,71.5 102.13,71.04 98.78,71.04 98.48,71.35 97.61,71.35 v2(97.11,71.84)
  BOTTOM w0.112: JDIMM1.16 50.07,27.59 v2(50.71,28.22)
DDR_A_D4: length 87.8
  IN1 w0.119: v2(47.1,28.25) 47.1,28.25 47.55,28.25 47.66,28.36 47.66,29.01 47.49,29.18 47.49,34.61 48.83,35.95 48.83,37.55 79.07,67.79 81.23,67.79 81.9,68.46 89.35,68.46 94.22,73.33 99.89,73.33 101.31,71.91 v2(101.31,71.78)
  BOTTOM w0.076: v2(101.31,71.78) 101.31,71.83 102.11,72.63 102.98,72.63 103.32,72.97 104.63,72.97 104.73,73.08 104.97,73.08 105.09,73.04 105.21,72.98 105.39,72.81 UC1.AL70
  BOTTOM w0.112: JDIMM1.4 47.07,25.79 46.42,26.45 46.42,28.33 46.53,28.44 46.9,28.44 v2(47.1,28.25)
DDR_A_D5: length 88.2
  IN1 w0.119: v2(47.1,26.72) 47.84,26.72 47.96,26.84 47.96,27.06 47.84,27.18 47.61,27.18 47.49,27.3 47.49,27.54 47.61,27.66 47.88,27.66 48,27.78 48,29.23 47.82,29.41 47.82,34.47 49.17,35.81 49.17,37.41 79.21,67.45 81.37,67.45 82.04,68.12 89.49,68.12 94.36,73 99.3,73 100.19,72.11 v2(100.19,71.79)
  BOTTOM w0.076: UC1.AL69 105.98,72.81 105.72,73.08 105.55,73.08 105.36,73.15 105.36,73.15 105.23,73.19 105.15,73.2 105.08,73.21 105.02,73.23 104.95,73.25 104.68,73.25 104.56,73.14 103.25,73.14 102.91,72.79 101.19,72.79 v2(100.19,71.79)
  BOTTOM w0.112: v2(47.1,26.72) 48.07,25.74 JDIMM1.8
DDR_A_D6: length 86.5
  IN1 w0.119: v2(50.71,31.27) 50.58,31.4 50.58,32.02 51.57,33.02 51.57,37.07 78.68,64.18 83.07,64.18 83.22,64.32 83.22,64.85 83.35,64.98 83.56,64.98 83.69,64.85 83.69,64.32 83.81,64.2 84.04,64.2 84.17,64.34 84.17,66.06 84.29,66.18 85.81,66.18 85.93,66.06 85.93,64.32 86.05,64.2 86.29,64.2 86.41,64.32 86.41,66.06 86.52,66.18 86.76,66.18 86.88,66.06 86.88,64.32 87,64.2 87.24,64.2 87.36,64.32 87.36,66.06 87.48,66.18 90.29,66.18 95,70.89 100.8,70.89 101.11,70.58 v2(101.11,70.49)
  BOTTOM w0.076: v2(101.11,70.49) 101.14,70.49 101.28,70.64 102.22,70.64 102.75,71.17 104.49,71.17 104.53,71.22 105.27,71.22 UC1.AN70
  BOTTOM w0.112: JDIMM1.17 50.32,31.65 v2(50.71,31.27)
DDR_A_D7: length 85.7
  IN1 w0.119: v2(50.71,26.7) 49.87,27.53 49.87,32.27 50.44,32.83 50.44,36.88 79.73,66.18 80.86,66.18 80.98,66.06 80.98,65.4 81.1,65.28 81.33,65.28 81.46,65.41 81.46,66.06 81.58,66.18 81.85,66.18 81.98,66.05 81.98,65.42 82.1,65.3 82.31,65.3 82.45,65.43 82.45,66.73 82.57,66.85 90.01,66.85 94.72,71.56 96.28,71.56 v2(96.56,71.84)
  BOTTOM w0.076: 96.89,71.46 97.22,71.13 98.4,71.13 98.66,70.88 102.2,70.88 102.67,71.34 104.42,71.34 104.56,71.48 UC1.AN71
  BOTTOM w0.102: 96.89,71.46 96.85,71.5
  BOTTOM w0.112: v2(96.56,71.84) 96.56,71.79 96.85,71.5 ; JDIMM1.20 51.07,26.33 v2(50.71,26.7)
DDR_A_D8: length 82
  IN1 w0.119: v2(100.65,69.01) 99.75,68.11 99.75,65.64 97.43,63.32 79.03,63.32 52.93,37.21 52.93,35.97 52.81,35.85 52.55,35.85 52.43,35.74 52.43,35.5 52.55,35.38 52.81,35.38 52.93,35.26 52.93,35.02 52.81,34.9 52.55,34.9 52.43,34.78 52.43,32.66 52.07,32.29 52.07,27.67 v2(53.04,26.7)
  BOTTOM w0.076: v2(100.65,69.01) 100.65,69.02 101.78,70.15 102.43,70.15 102.97,70.68 104.69,70.68 104.73,70.72 105.12,70.72 105.39,70.45 UC1.AR70
  BOTTOM w0.112: v2(53.04,26.7) 53.07,26.66 JDIMM1.28
DDR_A_D9: length 83.7
  IN1 w0.119: v2(100.59,69.6) 100.92,69.6 101.16,69.36 101.16,68.66 100.09,67.59 100.09,65.5 97.57,62.98 79.17,62.98 53.26,37.07 53.26,34.12 52.77,33.62 52.77,32.42 52.4,32.05 52.4,28.86 v2(53.04,28.22)
  BOTTOM w0.076: UC1.AR68 106.31,70.65 105.76,70.65 105.53,70.89 104.66,70.89 104.62,70.84 102.9,70.84 102.37,70.31 101.71,70.31 101.32,69.92 101.03,69.92 100.81,69.7 100.69,69.7 v2(100.59,69.6)
  BOTTOM w0.112: v2(53.04,28.22) 52.07,27.25 JDIMM1.24
DDR_A_D10: length 80.6
  IN1 w0.076: 101.67,63.02 101.67,63.05 103.37,64.75 103.37,67.8 103.13,68.04 102.59,68.04 v2(101.97,67.41)
  IN1 w0.119: v2(55.96,28.22) 57.42,29.68 57.42,33.66 57.04,34.04 57.04,34.57 57.15,34.69 57.45,34.69 57.57,34.8 57.57,35.05 57.45,35.17 57.11,35.17 56.99,35.29 56.99,35.52 57.11,35.64 57.45,35.64 57.57,35.76 57.57,36.76 68.02,47.21 68.02,48.14 80.25,60.37 99.01,60.37 101.59,62.95 101.59,62.95 101.67,63.02
  BOTTOM w0.076: UC1.AU71 104.78,69.02 103.72,69.02 102.75,68.04 102.32,68.04 101.97,67.69 v2(101.97,67.41)
  BOTTOM w0.112: JDIMM1.38 55.57,27.83 v2(55.96,28.22)
DDR_A_D11: length 81.7
  IN1 w0.076: v2(103.38,69.83) 103.53,69.67 103.53,64.42 101.67,62.55
  IN1 w0.119: v2(55.96,26.7) 57.76,28.49 57.76,31.92 57.91,32.07 57.91,36.62 68.65,47.36 68.65,47.53 68.36,47.83 68.36,48 68.53,48.17 68.7,48.17 68.99,47.87 69.16,47.87 69.35,48.06 69.35,48.23 69.05,48.52 69.05,48.69 80.39,60.03 99.15,60.03 101.67,62.55
  BOTTOM w0.076: v2(103.38,69.83) 103.73,70.18 104.5,70.18 104.66,70.02 105.03,70.02 105.06,70.04 105.14,70.07 105.26,70.07 105.48,70 105.62,70 105.78,70.06 106.37,70.06 106.39,70.08 106.63,70.08 106.84,69.88 UC1.AU68
  BOTTOM w0.112: JDIMM1.42 56.57,26.09 v2(55.96,26.7)
DDR_A_D12: length 80.5
  IN1 w0.119: v2(53.04,31.27) 53.11,31.33 53.11,31.98 53.22,32.09 54.23,32.09 54.35,32.21 54.35,32.45 54.23,32.57 53.22,32.57 53.11,32.69 53.11,32.92 53.23,33.05 54.23,33.05 54.36,33.18 54.36,33.43 54.25,33.54 53.73,33.54 53.6,33.67 53.6,35.29 53.72,35.41 54.24,35.41 54.36,35.53 54.36,35.77 54.24,35.88 53.72,35.88 53.6,36 53.6,36.93 54.19,37.53 54.36,37.53 54.38,37.5 54.55,37.5 54.72,37.67 54.72,37.84 54.7,37.86 54.7,38.03 54.87,38.2 55.03,38.2 55.06,38.18 55.23,38.18 55.4,38.35 55.4,38.51 55.37,38.54 55.37,38.71 55.54,38.88 55.71,38.88 55.74,38.85 55.9,38.85 56.07,39.02 56.07,39.19 56.05,39.21 56.05,39.38 79.31,62.64 97.71,62.64 100.42,65.36 100.42,67.45 101.74,68.77 v2(101.74,69.55)
  BOTTOM w0.076: v2(101.74,69.55) 102.17,69.98 102.5,69.98 103.04,70.51 104.83,70.51 UC1.AR71
  BOTTOM w0.112: v2(53.04,31.27) 53.32,31.55 JDIMM1.29
DDR_A_D13: length 81.8
  IN1 w0.119: v2(102.82,69.77) 102.82,69.38 100.76,67.31 100.76,65.22 97.85,62.31 79.45,62.31 56.84,39.7 56.84,39.31 54.52,36.99 54.13,36.99 53.93,36.8 53.93,36.49 54.05,36.37 54.57,36.37 54.69,36.25 54.69,35.06 54.57,34.94 54.05,34.94 53.93,34.82 53.93,34.05 54.1,33.88 54.56,33.88 54.69,33.75 54.69,31.99 54.54,31.84 54.46,31.84 54.33,31.72 54.33,30.29 53.78,29.74 v2(53.04,29.74)
  BOTTOM w0.076: v2(102.82,69.77) 102.82,69.92 103.25,70.35 104.57,70.35 104.73,70.19 104.99,70.19 105.11,70.24 105.13,70.24 105.14,70.25 105.15,70.24 105.25,70.24 105.48,70.18 105.61,70.18 105.83,70.25 106.08,70.25 UC1.AR69
  BOTTOM w0.112: JDIMM1.25 52.32,30.46 v2(53.04,29.74)
DDR_A_D14: length 80.7
  IN1 w0.076: 101.83,63.66 102.84,64.67 v2(102.84,66.93)
  IN1 w0.119: v2(55.96,29.74) 56.96,29.74 57.08,29.87 57.08,30.63 56.97,30.75 56.57,30.75 56.45,30.87 56.45,31.11 56.57,31.23 56.97,31.23 57.08,31.35 57.08,32.11 56.97,32.23 56.78,32.23 56.66,32.35 56.66,32.59 56.78,32.71 56.97,32.71 57.08,32.83 57.08,33.37 56.97,33.49 56.78,33.49 56.66,33.61 56.66,35.86 56.78,35.98 57.12,35.98 57.24,36.1 57.24,36.28 57.11,36.4 56.78,36.4 56.66,36.52 56.66,36.73 56.79,36.86 57.2,36.86 67.02,46.68 67.02,46.85 66.73,47.15 66.73,47.32 66.9,47.48 67.07,47.48 67.36,47.19 67.53,47.19 67.68,47.34 67.68,47.51 67.41,47.77 67.41,48 80.11,60.7 98.87,60.7 101.83,63.66
  BOTTOM w0.076: UC1.AU70 105.26,68.85 103.78,68.85 102.53,67.59 102.53,67.24 v2(102.84,66.93)
  BOTTOM w0.112: JDIMM1.41 56.32,31.83 56.59,31.57 56.59,30.37 v2(55.96,29.74)
DDR_A_D15: length 80.8
  IN1 w0.076: 101.67,63.97 102.47,64.77 102.47,67.38 102.62,67.53 102.88,67.53 v2(102.93,67.48)
  IN1 w0.119: 101.67,63.97 98.73,61.04 79.98,61.04 66.25,47.32 66.25,47.15 66.55,46.85 66.55,46.68 66.39,46.53 66.22,46.53 65.93,46.82 65.76,46.82 65.6,46.67 65.6,46.5 65.9,46.2 65.9,46.03 65.74,45.88 65.57,45.88 65.28,46.17 65.11,46.17 64.94,46 64.94,45.83 65.24,45.54 65.24,45.37 64.39,44.52 64.22,44.52 63.93,44.82 63.76,44.82 63.59,44.65 63.59,44.48 63.88,44.19 63.88,44.02 63.72,43.85 63.55,43.85 63.25,44.15 63.08,44.15 62.91,43.98 62.91,43.81 63.21,43.51 63.21,43.34 63.04,43.17 62.87,43.17 62.58,43.47 62.41,43.47 62.24,43.3 62.24,43.13 62.53,42.84 62.53,42.67 62.36,42.5 62.19,42.5 61.9,42.79 61.73,42.79 61.56,42.62 61.56,42.46 61.86,42.16 61.86,41.99 61.7,41.83 61.53,41.83 61.23,42.13 61.06,42.13 60.89,41.96 60.89,41.79 61.19,41.49 61.19,41.32 57.06,37.2 56.64,37.2 56.32,36.88 56.32,31.63 v2(55.96,31.27)
  BOTTOM w0.076: v2(102.93,67.48) 102.93,67.7 103.9,68.67 105.34,68.67 105.42,68.75 105.6,68.75 105.98,69.13 UC1.AU69
  BOTTOM w0.112: v2(55.96,31.27) 55.32,31.91 JDIMM1.37
DDR_A_D16: length 66.8
  IN3 w0.076: v2(109.1,74.7) 108.51,75.29 107.33,75.29 104.56,72.52 ; 101.48,72.23 103.43,72.23
  IN3 w0.112: 103.43,72.23 103.72,72.52 104.56,72.52
  IN3 w0.117: v2(97.22,26.7) 96.02,27.9 96.02,32.82 95.75,33.09 95.75,45.44 96.33,46.02 96.33,60.42 92.21,64.54 92.21,68.29 96.15,72.23 101.48,72.23
  BOTTOM w0.076: UC1.AF65 v2(109.1,74.7)
  BOTTOM w0.112: JDIMM1.194 96.57,26.05 v2(97.22,26.7)
DDR_A_D17: length 65.4
  IN3 w0.076: v2(109.74,74.7) 109.35,74.31 107.19,74.31 106.84,73.96 106.84,73.26 105.09,71.52 105.09,70.68 104.68,70.26 102.03,70.26
  IN3 w0.117: 102.03,70.26 101.98,70.26 101.75,70.03 100.15,70.03 99.9,69.78 95.11,69.78 93.21,67.88 93.21,65.07 95.59,62.68 95.76,62.68 95.97,62.9 96.14,62.9 96.3,62.73 96.3,62.57 96.09,62.35 96.09,62.19 97.33,60.94 97.33,44.1 97.25,44.02 96.93,44.02 96.8,43.89 96.8,43.73 96.93,43.6 97.2,43.6 97.33,43.47 97.33,43.28 97.2,43.15 96.93,43.15 96.8,43.02 96.8,42.81 96.93,42.68 97.2,42.68 97.33,42.55 97.33,42.36 97.2,42.23 96.87,42.23 96.75,42.11 96.75,35.07 97.24,34.58 97.24,34.42 97.35,34.31 97.46,34.31 97.58,34.19 97.58,33.96 97.46,33.84 97.35,33.84 97.24,33.72 97.24,33.49 97.35,33.37 97.46,33.37 97.58,33.25 97.58,33.02 97.46,32.9 97.35,32.9 97.24,32.79 97.24,32.57 97.35,32.45 97.52,32.45 97.64,32.33 97.64,32.1 97.52,31.98 97.35,31.98 97.24,31.87 97.24,31.28 v2(97.22,31.27)
  BOTTOM w0.076: UC1.AF64 v2(109.74,74.7)
  BOTTOM w0.112: JDIMM1.195 96.82,31.67 v2(97.22,31.27)
DDR_A_D18: length 65.7
  IN3 w0.076: 101.15,64.16 102.87,65.88 102.87,66.4 103.34,66.87 103.34,67.27 103.9,67.82 104.85,67.82 107.12,70.09 107.12,71.01 107.25,71.15 107.25,72.12 107.45,72.31 108.55,72.31 v2(109.1,72.87)
  IN3 w0.112: 100.99,64.01 101.15,64.16
  IN3 w0.117: 100.99,64.01 100.25,63.27 100.25,57.11 100.48,56.88 100.48,39 100.72,38.76 100.72,36.06 100.63,35.97 100.03,35.97 99.91,35.86 99.91,35.66 100.04,35.53 100.59,35.53 100.72,35.4 100.72,35.21 100.59,35.08 100.04,35.08 99.91,34.95 99.91,34.76 100.04,34.63 100.33,34.63 100.46,34.5 100.46,34.32 100.33,34.18 100.04,34.18 99.91,34.05 99.91,33.87 100.04,33.74 100.59,33.74 100.72,33.61 100.72,33.39 100.59,33.26 100.04,33.26 99.91,33.13 99.91,32.95 100.04,32.82 100.59,32.82 100.72,32.68 100.72,32.5 100.59,32.37 100.13,32.37 100,32.24 100,32.06 100.13,31.93 100.61,31.93 100.72,31.83 100.72,26.47 101.03,26.16 101.71,26.16 101.85,26.02 101.85,25.77 101.72,25.64 99.66,25.64 99.52,25.78 99.52,25.99 99.65,26.12 100.03,26.12 100.19,26.28 100.19,26.57 100.06,26.7 v2(99.76,26.7)
  BOTTOM w0.076: UC1.AK65 v2(109.1,72.87)
  BOTTOM w0.112: v2(99.76,26.7) 99.76,26.58 99.07,25.89 99.07,25.66 JDIMM1.204
DDR_A_D19: length 67.1
  IN3 w0.076: 102.17,67.82 102.29,67.82 103.39,68.92 104.94,68.92 105.8,69.78 105.8,71.36 107.67,73.23 109.37,73.23 v2(109.74,72.87)
  IN3 w0.112: 102.03,67.82 102.17,67.82
  IN3 w0.117: 102.03,67.82 101.67,67.82 101.27,67.42 101.27,65.7 99.26,63.68 99.26,60.61 99.14,60.49 98.73,60.49 98.6,60.36 98.6,60.17 98.73,60.04 99.13,60.04 99.26,59.91 99.26,59.7 99.13,59.57 98.73,59.57 98.6,59.44 98.6,59.25 98.73,59.12 99.13,59.12 99.26,58.99 99.26,58.8 99.13,58.67 98.73,58.67 98.6,58.54 98.6,58.36 98.73,58.23 99.13,58.23 99.26,58.1 99.26,57.91 99.13,57.78 98.72,57.78 98.6,57.66 98.6,57.48 98.73,57.35 99.11,57.35 99.26,57.2 99.26,57.02 99.13,56.89 98.72,56.89 98.6,56.77 98.6,56.56 98.72,56.44 99.35,56.44 99.48,56.31 99.48,56.12 99.35,55.99 98.73,55.99 98.6,55.86 98.6,55.68 98.73,55.54 99.35,55.54 99.48,55.41 99.48,55.23 99.35,55.1 98.73,55.1 98.6,54.97 98.6,54.78 98.73,54.65 99.35,54.65 99.48,54.52 99.48,54.33 99.35,54.2 98.72,54.2 98.6,54.08 98.6,53.85 98.72,53.73 99.06,53.73 99.19,53.6 99.19,53.41 99.06,53.28 98.74,53.28 98.6,53.14 98.6,38.49 98.91,38.17 98.91,30.5 99.03,30.38 99.25,30.38 99.37,30.26 99.37,30.03 99.25,29.91 99.03,29.91 98.91,29.8 98.91,29.29 99.03,29.18 99.41,29.18 99.76,29.53 v2(99.76,29.74)
  BOTTOM w0.076: UC1.AK64 v2(109.74,72.87)
  BOTTOM w0.112: JDIMM1.203 98.82,30.68 v2(99.76,29.74)
DDR_A_D20: length 66.2
  IN3 w0.076: 103.64,71.34 103.77,71.47 104.27,71.47 104.68,71.88 104.68,72.38 107.42,75.12 108.04,75.12 v2(108.47,74.7)
  IN3 w0.112: 101.75,71.34 103.64,71.34
  IN3 w0.117: v2(97.22,28.22) 96.49,28.95 96.49,32.82 96.08,33.23 96.08,45.3 96.67,45.89 96.67,60.55 92.54,64.68 92.54,68.16 95.73,71.34 101.75,71.34
  BOTTOM w0.076: UC1.AF66 v2(108.47,74.7)
  BOTTOM w0.112: JDIMM1.190 95.57,26.57 v2(97.22,28.22)
DDR_A_D21: length 65.5
  IN3 w0.076: v2(107.83,74.7) 107.83,74.88 107.76,74.96 107.49,74.96 106.66,74.12 106.66,73.39 104.28,71.01 101.6,71.01
  IN3 w0.117: v2(97.22,29.74) 97.15,29.67 96.94,29.67 96.83,29.79 96.83,33.14 96.71,33.25 96.53,33.25 96.42,33.37 96.42,33.8 96.53,33.92 96.79,33.92 96.9,34.03 96.9,34.44 96.42,34.93 96.42,44.21 96.58,44.37 96.89,44.37 97,44.48 97,44.71 96.89,44.82 96.54,44.82 96.42,44.94 96.42,45.17 96.53,45.28 96.86,45.28 97,45.41 97,60.69 92.87,64.82 92.87,68.02 95.87,71.01 101.6,71.01
  BOTTOM w0.076: UC1.AF67 v2(107.83,74.7)
  BOTTOM w0.112: v2(97.22,29.74) 95.82,31.14 JDIMM1.191
DDR_A_D22: length 63.9
  IN3 w0.076: v2(107.83,72.87) 107.7,72.73 107.4,72.73 105.96,71.29 105.96,69.63 105.09,68.76 103.46,68.76 102.4,67.7 102.4,67.24 102.25,67.09 102.25,66.12 102.05,65.92 102.03,65.92
  IN3 w0.117: 102.03,65.92 101.99,65.88 101.93,65.88 99.59,63.54 99.59,56.84 99.82,56.61 99.82,53.21 99.62,53.02 99.62,53.01 99.55,52.94 99.08,52.94 98.95,52.81 98.95,52.64 99.08,52.51 99.69,52.51 99.82,52.38 99.82,52.16 99.69,52.03 99.09,52.03 98.96,51.9 98.96,51.72 99.09,51.58 99.54,51.58 99.67,51.45 99.67,51.27 99.54,51.14 99.08,51.14 98.95,51.01 98.95,50.82 99.08,50.69 99.55,50.69 99.68,50.55 99.68,50.37 99.56,50.24 99.08,50.24 98.95,50.11 98.95,49.93 99.08,49.8 99.57,49.8 99.7,49.67 99.7,49.48 99.57,49.35 99.08,49.35 98.95,49.22 98.95,49.03 99.08,48.9 99.57,48.9 99.7,48.77 99.7,48.59 99.57,48.46 99.08,48.46 98.95,48.32 98.95,48.14 99.08,48.01 99.58,48.01 99.71,47.88 99.71,47.69 99.58,47.56 99.08,47.56 98.95,47.43 98.95,47.24 99.08,47.11 99.55,47.11 99.68,46.98 99.68,46.8 99.55,46.67 99.08,46.67 98.95,46.54 98.95,46.35 99.08,46.22 99.55,46.22 99.68,46.09 99.68,45.9 99.55,45.77 99.07,45.77 98.94,45.64 98.94,45.46 99.07,45.33 99.55,45.33 99.68,45.19 99.68,45.01 99.55,44.88 99.07,44.88 98.94,44.75 98.94,44.56 99.07,44.43 99.55,44.43 99.68,44.3 99.68,44.12 99.55,43.98 99.08,43.98 98.95,43.85 98.95,43.64 99.08,43.51 99.55,43.51 99.68,43.38 99.68,43.19 99.55,43.06 99.08,43.06 98.94,42.92 98.94,38.63 99.25,38.31 99.25,30.94 99.36,30.83 99.64,30.83 99.76,30.95 v2(99.76,31.27)
  BOTTOM w0.076: UC1.AK67 v2(107.83,72.87)
  BOTTOM w0.112: JDIMM1.207 99.82,31.33 v2(99.76,31.27)
DDR_A_D23: length 64.7
  IN3 w0.076: 102.03,65.52 102.47,65.95 102.47,67.08 102.56,67.17 102.56,67.63 103.52,68.59 105.38,68.59 106.95,70.16 106.95,71.08 107.09,71.22 107.09,72.18 107.4,72.49 108.09,72.49 v2(108.47,72.87)
  IN3 w0.117: 102.03,65.52 99.92,63.41 99.92,56.97 100.15,56.74 100.15,42.86 100.01,42.72 99.4,42.72 99.28,42.6 99.28,42.42 99.41,42.29 99.9,42.29 100.03,42.16 100.03,41.94 99.9,41.81 99.46,41.81 99.33,41.68 99.33,41.5 99.46,41.37 99.9,41.37 100.03,41.24 100.03,41.05 99.9,40.92 99.41,40.92 99.28,40.79 99.28,40.6 99.41,40.47 99.91,40.47 100.04,40.34 100.04,40.13 99.91,40 99.41,40 99.28,39.87 99.28,39.68 99.41,39.55 99.88,39.55 100.01,39.42 100.01,39.23 99.88,39.1 99.41,39.1 99.28,38.97 99.28,38.76 99.44,38.59 100.25,38.59 100.38,38.46 100.38,38.28 100.25,38.14 99.73,38.14 99.6,38.01 99.6,37.8 99.73,37.67 100.25,37.67 100.38,37.54 100.38,37.35 100.25,37.22 99.71,37.22 99.58,37.09 99.58,36.88 99.71,36.75 100.25,36.75 100.38,36.62 100.38,36.45 100.25,36.32 99.71,36.32 99.58,36.18 99.58,32.02 100.39,31.21 100.39,28.11 100.27,28 99.88,28 99.76,28.11 v2(99.76,28.22)
  BOTTOM w0.076: UC1.AK66 v2(108.47,72.87)
  BOTTOM w0.112: JDIMM1.208 100.07,25.86 100.22,26 100.22,27.77 v2(99.76,28.22)
DDR_A_D24: length 68.3
  IN3 w0.112: 101.48,72.82 102.07,72.82 103.66,74.42 103.66,75.48
  IN3 w0.117: v2(103.18,77.41) 103.18,77.15 103.66,76.66 103.66,75.48 ; 101.48,72.82 95.99,72.82 91.69,68.51 91.69,64.32 95.81,60.2 95.81,46.24 95.23,45.66 95.23,32.88 95.5,32.61 95.5,26.44 95.38,26.32 94.8,26.32 94.68,26.44 v2(94.68,26.7)
  BOTTOM w0.076: 104.47,76.31 105.32,75.46 UC1.AF70 ; 104.41,76.37 104.19,76.59 103.37,76.59 103.29,76.66 103.29,77.3 v2(103.18,77.41)
  BOTTOM w0.107: 104.47,76.31 104.41,76.37
  BOTTOM w0.112: JDIMM1.186 94.57,26.59 v2(94.68,26.7)
DDR_A_D25: length 70.5
  IN3 w0.117: v2(99.16,77.06) 99.16,76.98 98.61,76.42 94.96,76.42 88.41,69.87 88.41,34.11 89.47,33.05 89.47,32.88 89.35,32.77 89.35,32.6 89.52,32.43 89.68,32.43 89.8,32.55 89.97,32.55 90.13,32.39 90.13,32.22 90.01,32.1 90.01,31.94 90.18,31.77 90.35,31.77 90.46,31.89 90.63,31.89 91.08,31.44 91.08,27.76 v2(92.14,26.7)
  BOTTOM w0.076: 105.88,75.77 106,75.65 106.23,75.65 106.3,75.63 106.84,75.36 UC1.AF68
  BOTTOM w0.112: 105.88,75.77 105.79,75.77 104.96,76.61 104.55,76.61 103.37,77.79 99.89,77.79 v2(99.16,77.06) ; v2(92.14,26.7) 92.14,26.51 91.57,25.95 JDIMM1.174
DDR_A_D26: length 67.8
  IN3 w0.117: v2(92.14,31.27) 92.14,32.02 92.01,32.16 92.01,33.45 92.66,34.1 92.66,51.02 92.77,51.14 93.21,51.14 93.33,51.26 93.33,51.47 93.21,51.59 92.84,51.59 92.71,51.72 92.71,51.9 92.84,52.03 93.22,52.03 93.33,52.14 93.33,52.36 93.21,52.48 92.86,52.48 92.73,52.61 92.73,52.82 92.86,52.95 93.18,52.95 93.32,53.08 93.32,53.27 93.18,53.4 92.86,53.4 92.73,53.53 92.73,53.72 92.86,53.85 93.18,53.85 93.32,53.98 93.32,54.16 93.18,54.3 92.86,54.3 92.73,54.43 92.73,54.61 92.86,54.74 93.18,54.74 93.32,54.87 93.32,55.06 93.18,55.19 92.86,55.19 92.73,55.32 92.73,55.51 92.86,55.64 93.18,55.64 93.32,55.77 93.32,55.95 93.18,56.08 92.86,56.08 92.73,56.21 92.73,56.43 92.86,56.56 93.02,56.56 93.13,56.68 93.13,56.84 92.86,57.12 92.86,57.3 92.99,57.43 93.25,57.43 93.36,57.55 93.36,59.39 89.41,63.35 89.41,69.45 95.2,75.25 99.84,75.25 v2(99.85,75.24)
  BOTTOM w0.076: v2(99.85,75.24) 99.85,74.71 101.13,73.42 102.78,73.42 103.57,74.21 104.59,74.21 104.67,74.13 UC1.AH71
  BOTTOM w0.112: JDIMM1.173 91.32,32.23 92.14,31.41 v2(92.14,31.27)
DDR_A_D27: length 70.8
  IN3 w0.112: 102.59,75.48 102.72,75.36 102.72,74.68 102.59,74.56
  IN3 w0.117: v2(94.68,29.74) 94.23,30.2 94.23,50.36 94.8,50.93 94.8,59.8 90.69,63.91 90.69,68.92 95.67,73.91 101.94,73.91 102.59,74.56 ; v2(100.4,76.55) 100.59,76.36 101,76.36 101.37,75.99 102.08,75.99 102.59,75.48
  BOTTOM w0.076: 101.22,76.31 101.69,75.84 102.52,75.84 102.78,75.57 104.12,75.57 104.66,75.03 105.02,75.03 105.02,75.03 105.11,75.06 105.31,75.06 105.4,75.03 105.4,75.03 105.4,75.03 105.41,75.02 105.64,75.02 105.78,75.07 106.26,75.07 106.37,74.99 106.63,74.99 106.84,74.79 UC1.AH68
  BOTTOM w0.112: JDIMM1.183 93.82,30.6 v2(94.68,29.74) ; v2(100.4,76.55) 100.59,76.36 101,76.36 101.05,76.31 101.22,76.31
DDR_A_D28: length 67.9
  IN3 w0.112: 101.48,73.15 102.12,73.15 103.29,74.32 103.29,75.48
  IN3 w0.117: v2(102.5,77.19) 103.29,76.4 103.29,75.48 ; 101.48,73.15 95.86,73.15 91.35,68.65 91.35,64.19 95.48,60.06 95.48,46.38 94.89,45.8 94.89,32.74 95.16,32.47 95.16,28.15 95.05,28.03 94.87,28.03 v2(94.68,28.22)
  BOTTOM w0.076: 102.74,76.31 102.82,76.22 104.13,76.22 UC1.AF71 ; v2(102.5,77.19) 102.5,76.54 102.68,76.37
  BOTTOM w0.107: 102.74,76.31 102.68,76.37
  BOTTOM w0.112: JDIMM1.182 93.57,27.11 v2(94.68,28.22)
DDR_A_D29: length 69.8
  IN3 w0.112: 102.05,73.59 102.95,74.49 102.95,75.48
  IN3 w0.117: 102.05,73.59 101.94,73.49 95.72,73.49 91.02,68.79 91.02,64.05 95.13,59.94 95.13,50.8 94.94,50.61 94.94,50.44 95.12,50.27 95.12,50.1 94.99,49.98 94.68,49.98 94.56,49.86 94.56,49.64 94.67,49.53 95.03,49.53 95.14,49.42 95.14,49.22 95.03,49.11 94.67,49.11 94.56,49 94.56,48.75 94.67,48.63 95.02,48.63 95.14,48.51 95.14,48.31 95.02,48.19 94.69,48.19 94.56,48.06 94.56,47.87 94.69,47.74 95.03,47.74 95.14,47.62 95.14,47.41 95.03,47.29 94.67,47.29 94.56,47.18 94.56,46.93 94.67,46.82 95,46.82 95.11,46.71 95.11,46.48 95,46.37 94.68,46.37 94.56,46.25 94.56,32.6 94.83,32.33 94.83,31.41 v2(94.68,31.27) ; 102.95,75.48 102.95,76.05 102.57,76.42 101.53,76.42 v2(100.89,77.06)
  BOTTOM w0.076: UC1.AF69 106.08,75.26 105.82,75.26 105.72,75.22 105.72,75.22 105.64,75.19 105.43,75.19 105.34,75.23 105.09,75.23 105.08,75.23 104.99,75.19 104.73,75.19 104.04,75.89 102.81,75.89 102.49,76.21 101.74,76.21 101,76.95
  BOTTOM w0.112: v2(94.68,31.27) 94.82,31.41 JDIMM1.187 ; 101,76.95 v2(100.89,77.06)
DDR_A_D30: length 69.3
  IN3 w0.117: v2(92.14,29.74) 91.86,29.74 91.75,29.86 91.75,31.71 91.13,32.33 91.13,32.49 91.67,33.04 91.67,33.2 91.51,33.37 91.34,33.37 90.8,32.83 90.64,32.83 89.07,34.39 89.07,69.59 95.07,75.58 98.03,75.58 98.14,75.7 98.14,75.85 98.02,75.98 v2(97.69,75.98)
  BOTTOM w0.076: UC1.AH70 105.39,74.13 105.25,73.99 105.24,73.99 105.24,73.99 105.04,73.89 104.99,73.87 104.7,73.87 104.65,73.92 104.52,74.04 103.64,74.04 102.85,73.25 99.72,73.25 97.69,75.29 v2(97.69,75.98)
  BOTTOM w0.112: JDIMM1.169 90.32,32.36 91.31,31.37 91.31,30.58 v2(92.14,29.74)
DDR_A_D31: length 69.9
  IN3 w0.117: v2(97.05,75.98) 94.99,75.98 88.74,69.73 88.74,34.25 91.42,31.58 91.42,27.95 91.53,27.83 92.03,27.83 92.14,27.95 v2(92.14,28.22)
  BOTTOM w0.076: v2(97.05,75.98) 97.05,75.69 99.65,73.09 102.91,73.09 103.7,73.88 104.45,73.88 104.58,73.76 104.63,73.7 105.03,73.7 105.1,73.74 105.59,73.74 105.98,74.13 UC1.AH69
  BOTTOM w0.112: v2(92.14,28.22) 91.03,27.11 91.03,26.46 90.57,26 JDIMM1.170
DDR_A_D32: length 75.5
  IN1 w0.076: v2(103.7,62.57) 103.54,62.57 102.75,61.77 102.75,61.47 101.67,60.38
  IN1 w0.119: v2(58.15,26.7) 58.73,26.7 59.44,27.4 59.44,31.29 60.19,32.04 60.19,36.73 70.93,47.47 70.93,48.4 81.03,58.5 99.79,58.5 101.67,60.38
  BOTTOM w0.076: UC1.BB65 108.54,65.88 108.54,65 107.77,64.24 104.64,64.24 104.21,63.8 104.21,63.02 103.75,62.57 v2(103.7,62.57)
  BOTTOM w0.112: JDIMM1.46 57.57,26.13 v2(58.15,26.7)
DDR_A_D33: length 78.3
  IN1 w0.076: 101.67,57.64 102.29,58.26 104.36,58.26 105.68,59.57 105.68,60.81 v2(105.22,61.63)
  IN1 w0.119: v2(61.22,28.22) 62.4,29.94 62.4,36.2 75.19,48.99 75.19,49.92 81.83,56.56 100.59,56.56 101.67,57.64
  BOTTOM w0.076: v2(105.22,61.63) 104.86,61.98 104.86,63.24 105.3,63.67 107.99,63.67 109.6,65.28 109.6,65.65 109.54,65.71 109.54,66.13 109.58,66.24 109.58,66.36 109.52,66.58 109.52,66.72 109.57,66.88 109.57,67.06 109.5,67.22 109.5,67.71 109.28,67.94 UC1.AW65
  BOTTOM w0.112: v2(61.22,28.22) 61.61,27.83 61.61,26.07 61.57,26.03 JDIMM1.62
DDR_A_D34: length 78.7
  IN1 w0.119: v2(61.22,31.27) 61.61,31.27 61.73,31.4 61.73,35.63 61.46,35.9 61.46,36.21 61.95,36.7 72.36,47.11 72.36,47.24 72.2,47.41 72.2,47.59 72.34,47.74 72.57,47.74 72.69,47.61 72.87,47.61 73.02,47.76 73.02,47.95 72.77,48.2 72.77,48.45 81.55,57.23 100.31,57.23 101.72,58.64 103.03,58.64 103.24,58.86 103.24,59.6 103.36,59.72 103.6,59.72 103.72,59.6 103.72,58.74 103.85,58.61 104.14,58.61 104.27,58.74 104.27,59.65 104.4,59.78 v2(105.15,59.78)
  BOTTOM w0.076: v2(105.15,59.78) 106.94,61.57 106.94,62.66 107.28,63.01 108.47,63.01 110.4,64.93 110.4,66.64 110.18,66.86 110.18,67.41 109.87,67.72 UC1.AW63
  BOTTOM w0.112: JDIMM1.63 61.82,31.93 62.21,31.55 62.21,30.37 62.08,30.24 61.8,30.24 61.66,30.38 61.66,31.08 61.47,31.27 v2(61.22,31.27)
DDR_A_D35: length 77.7
  IN1 w0.076: 101.67,61.8 102.26,62.39 102.26,62.91 103.58,64.23 104.57,64.23 105.45,63.35 v2(105.45,63.3)
  IN1 w0.119: v2(58.15,31.27) 58.43,31.56 58.43,33.25 58.55,33.37 58.8,33.37 58.93,33.5 58.93,33.73 58.81,33.85 58.55,33.85 58.43,33.97 58.43,34.71 58.55,34.82 59.07,34.82 59.18,34.94 59.18,35.18 59.07,35.3 58.55,35.3 58.43,35.42 58.43,35.68 58.55,35.8 59.07,35.8 59.18,35.92 59.18,36.16 59.07,36.28 58.8,36.28 58.68,36.4 58.68,36.65 58.8,36.77 59.07,36.77 59.18,36.89 59.18,37.15 69.92,47.89 69.92,48.82 80.61,59.51 99.37,59.51 101.67,61.8
  BOTTOM w0.076: v2(105.45,63.3) 105.45,63.31 105.64,63.5 108.27,63.5 109.88,65.11 109.88,65.65 109.7,65.83 109.7,66.09 109.76,66.21 109.76,66.35 109.69,66.58 109.69,66.71 109.77,66.93 109.77,67.19 UC1.AY63
  BOTTOM w0.112: v2(58.15,31.27) 57.32,32.09 JDIMM1.45
DDR_A_D36: length 76.8
  IN1 w0.076: v2(103.66,63.12) 103.66,63.06 101.67,61.07 101.67,60.86
  IN1 w0.119: v2(58.15,28.22) 58.82,28.22 59.11,28.5 59.11,28.84 58.99,28.96 58.86,28.96 58.74,29.07 58.74,29.31 58.86,29.43 58.99,29.43 59.11,29.55 59.11,31.43 59.86,32.18 59.86,36.87 70.59,47.61 70.59,48.54 80.89,58.84 99.65,58.84 101.67,60.86
  BOTTOM w0.076: UC1.BA65 108.64,66.49 108.5,66.35 108.5,66.34 108.49,66.34 108.38,66.09 108.38,65.07 107.7,64.4 104.52,64.4 104.02,63.89 104.02,63.42 103.72,63.12 v2(103.66,63.12)
  BOTTOM w0.112: JDIMM1.50 58.57,25.97 58.87,26.26 58.87,27.5 v2(58.15,28.22)
DDR_A_D37: length 77
  IN1 w0.076: v2(103.66,63.68) 103.51,63.68 102.42,62.59 102.42,62.09 101.67,61.33
  IN1 w0.119: v2(58.15,29.74) 58.64,29.74 58.77,29.87 58.77,32.07 58.89,32.19 59.39,32.19 59.52,32.32 59.52,32.54 59.4,32.66 59.05,32.66 58.94,32.78 58.94,32.98 59.07,33.11 59.4,33.11 59.52,33.23 59.52,33.57 59.24,33.85 59.24,34.25 59.52,34.53 59.52,37.01 70.25,47.75 70.25,48.68 80.75,59.17 99.51,59.17 101.67,61.33
  BOTTOM w0.076: v2(103.66,63.68) 103.66,64 104.23,64.57 107.64,64.57 108.21,65.14 108.21,66.13 108.32,66.36 108.32,66.4 108.38,66.53 108.38,66.82 108.64,67.08 UC1.AY65
  BOTTOM w0.112: v2(58.15,29.74) 58.47,29.74 58.6,29.87 58.6,31.79 58.32,32.07 JDIMM1.49
DDR_A_D38: length 76.9
  IN1 w0.076: 101.67,58.11 101.98,58.42 104.29,58.42 105.51,59.64 105.51,60.57 v2(105.15,60.93)
  IN1 w0.119: 101.67,58.11 100.45,56.9 81.69,56.9 74.55,49.76 74.55,49.58 74.86,49.28 74.86,49.13 74.69,48.96 74.52,48.96 74.22,49.26 74.05,49.26 73.87,49.08 73.87,48.91 74.17,48.61 74.17,48.44 74.02,48.29 73.85,48.29 73.55,48.59 73.39,48.59 73.21,48.41 73.21,48.24 73.5,47.94 73.5,47.77 62.07,36.34 62.07,30.04 61.77,29.74 v2(61.22,29.74)
  BOTTOM w0.076: v2(105.15,60.93) 105.28,61.06 105.35,61.06 106.77,62.48 106.77,62.73 107.22,63.17 108.4,63.17 110.23,65 110.23,66.16 109.97,66.42 UC1.BA63
  BOTTOM w0.112: v2(61.22,29.74) 60.77,30.19 60.77,32.06 60.82,32.11 JDIMM1.59
DDR_A_D39: length 75.8
  IN1 w0.076: v2(105.22,62.2) 105.84,61.58 105.84,59.5 104.41,58.07 102.57,58.07
  IN1 w0.119: v2(61.22,26.87) 61.96,26.87 62.08,27 62.08,27.7 62.74,28.35 62.74,36.06 75.53,48.85 75.53,49.78 81.97,56.23 100.73,56.23 102.57,58.07
  BOTTOM w0.076: UC1.BB63 110.05,65.91 110.05,65.05 108.34,63.34 107.15,63.34 106.14,62.32 105.35,62.32 v2(105.22,62.2)
  BOTTOM w0.112: v2(61.22,26.87) 60.57,26.22 JDIMM1.58
DDR_A_D40: length 77.4
  IN1 w0.076: v2(107.42,61.34) 107.42,61.56 107.49,61.64 107.93,61.64 108,61.56 108,59.03 106.27,57.3 104.51,57.3 103.31,56.09 102.76,56.09
  IN1 w0.119: v2(63.77,28.22) 64,27.99 64.51,27.99 64.64,28.12 64.64,29.15 64.46,29.33 64.3,29.33 64.18,29.45 64.18,29.68 64.31,29.81 64.92,29.81 65.05,29.94 65.05,30.47 64.69,30.83 64.69,33.89 64.58,34 64.33,34 64.27,34.06 64.27,35.43 83.54,54.69 101.37,54.69 102.76,56.09
  BOTTOM w0.076: v2(107.42,61.34) 107.79,61.71 107.79,61.85 110.73,64.8 110.73,66.15 111,66.41 UC1.BA61
  BOTTOM w0.112: JDIMM1.66 62.57,27.2 63.59,28.22 v2(63.77,28.22)
DDR_A_D41: length 78.5
  IN1 w0.076: 107.41,62.64 106.44,61.66 106.44,59.09 105.25,57.91 103.15,57.91 102.05,56.8
  IN1 w0.084: 107.41,62.64 v2(107.42,62.64)
  IN1 w0.119: 102.05,56.8 100.95,55.7 82.19,55.7 76.74,50.25 76.74,50.08 77.03,49.78 77.03,49.61 76.86,49.44 76.69,49.44 76.4,49.74 76.23,49.74 76.05,49.56 76.05,49.39 76.35,49.1 76.35,48.93 63.27,35.85 63.27,27.54 63.18,27.46 62.74,27.46 62.61,27.33 62.61,27.02 62.74,26.89 63.51,26.89 63.57,26.83 v2(63.72,26.83)
  BOTTOM w0.076: UC1.AW61 111.1,67.75 110.77,67.42 110.77,66.88 110.57,66.67 110.57,64.86 108.34,62.64 v2(107.42,62.64)
  BOTTOM w0.112: v2(63.72,26.83) 63.57,26.68 JDIMM1.70
DDR_A_D42: length 76.9
  IN1 w0.076: 103.66,55.19 105.27,56.8 106.8,56.8 108.51,58.51 108.51,59.26 108.92,59.67 v2(109.35,59.67)
  IN1 w0.119: 103.66,55.19 101.89,53.42 84.13,53.42 67.18,36.48 67.18,35.79 67.05,35.65 66.29,35.65 66.17,35.54 66.17,35.3 66.29,35.18 67.05,35.18 67.18,35.05 67.18,34.83 67.06,34.71 66.08,34.71 65.96,34.59 65.96,34.05 66.08,33.93 67.08,33.93 67.18,33.83 67.18,33.59 67.06,33.47 66.08,33.47 65.96,33.35 65.96,33.14 66.08,33.02 67.06,33.02 67.18,32.9 67.18,32.68 67.06,32.56 66.1,32.56 65.98,32.44 65.98,32.22 66.1,32.11 67.06,32.11 67.18,31.99 67.18,31.8 67.06,31.68 66.08,31.68 65.96,31.56 65.96,31.36 66.08,31.24 66.28,31.24 v2(66.31,31.27)
  BOTTOM w0.076: v2(109.35,59.67) 110.14,60.46 110.14,62.51 112.07,64.44 112.07,64.44 112.18,64.56 112.18,64.96 112.42,65.2 112.42,65.88 UC1.BB59
  BOTTOM w0.112: JDIMM1.79 65.82,31.4 65.95,31.27 v2(66.31,31.27)
DDR_A_D43: length 79.6
  IN1 w0.076: 104.39,54.46 106.23,56.31 108.18,56.31 109.73,57.85 109.73,60.5 v2(109.35,60.88)
  IN1 w0.119: 104.39,54.46 102.26,52.33 84.51,52.33 68.19,36.01 68.19,29.16 68.98,28.37 68.98,27.26 69.17,27.07 69.17,26.25 69.05,26.13 68.63,26.13 68.51,26.25 68.51,26.77 68.39,26.89 68.15,26.89 68.03,26.77 68.03,26.19 67.92,26.07 66.94,26.07 v2(66.31,26.7)
  BOTTOM w0.076: UC1.AW59 111.67,67.94 111.47,67.73 111.47,67.22 111.39,67.12 111.39,66.87 111.44,66.74 111.44,66.51 111.43,66.5 111.43,66.5 111.43,66.5 111.39,66.41 111.39,66.21 111.43,66.12 111.43,65.76 111.23,65.56 111.23,64.59 108.96,62.32 108.96,61.27 v2(109.35,60.88)
  BOTTOM w0.112: v2(66.31,26.7) 66.45,26.7 67.07,26.08 JDIMM1.84
DDR_A_D44: length 76.7
  IN1 w0.076: v2(107.42,60.78) 107.66,60.78 107.79,60.65 107.79,59.04 106.2,57.46 103.66,57.46 103.57,57.37
  IN1 w0.119: 103.57,57.37 103.33,57.14 103.33,56.97 103.5,56.8 103.5,56.63 103.33,56.46 103.16,56.46 103,56.63 102.83,56.63 101.23,55.03 83.4,55.03 63.94,35.57 63.94,33.8 64.06,33.68 64.23,33.68 64.35,33.56 64.35,33.32 64.23,33.2 64.06,33.2 63.94,33.08 63.94,32.84 64.06,32.72 64.23,32.72 64.35,32.6 64.35,32.37 64.23,32.25 64.06,32.25 63.94,32.13 63.94,31.92 64.07,31.78 64.23,31.78 64.35,31.65 64.35,30.69 64.45,30.59 64.45,30.28 64.33,30.15 64.17,30.15 v2(63.77,29.74)
  BOTTOM w0.076: UC1.BB61 110.9,65.88 110.9,64.73 108.23,62.06 108.23,61.58 108.16,61.5 107.9,61.5 107.83,61.42 107.83,61.27 107.9,61.2 108.16,61.2 108.23,61.12 108.23,60.39 108.1,60.26 107.89,60.26 107.83,60.33 107.83,60.67 107.72,60.78 v2(107.42,60.78)
  BOTTOM w0.112: JDIMM1.67 62.82,29.92 63,29.74 v2(63.77,29.74)
DDR_A_D45: length 78.1
  IN1 w0.076: v2(107.43,59.64) 107.43,59.45 105.6,57.63 103.35,57.63 102.28,56.56
  IN1 w0.119: v2(63.77,31.27) 63.6,31.44 63.6,35.71 77.51,49.61 77.51,49.78 77.21,50.08 77.21,50.25 77.38,50.42 77.55,50.42 77.84,50.12 78.01,50.12 78.18,50.29 78.18,50.46 77.89,50.75 77.89,50.92 78.05,51.09 78.22,51.09 78.52,50.79 78.69,50.79 78.86,50.96 78.86,51.13 78.56,51.43 78.56,51.6 78.73,51.77 78.9,51.77 79.2,51.47 79.36,51.47 79.53,51.64 79.53,51.81 79.24,52.11 79.24,52.27 79.41,52.44 79.57,52.44 79.87,52.15 80.04,52.15 80.21,52.32 80.21,52.48 79.91,52.78 79.91,52.95 80.08,53.12 80.25,53.12 80.55,52.82 80.72,52.82 80.88,52.99 80.88,53.16 80.59,53.46 80.59,53.62 80.76,53.79 80.93,53.79 81.22,53.5 81.39,53.5 81.56,53.67 81.56,53.84 81.26,54.13 81.26,54.3 81.43,54.47 81.6,54.47 81.9,54.17 82.07,54.17 82.24,54.34 82.24,54.51 81.94,54.81 81.94,54.98 82.11,55.15 82.28,55.15 82.57,54.85 82.74,54.85 83.26,55.37 101.09,55.37 102.28,56.56
  BOTTOM w0.076: v2(107.43,59.64) 107.87,59.64 108.4,60.17 108.4,61.99 111.06,64.66 111.06,65.63 111.26,65.83 111.26,66.09 111.23,66.18 111.23,66.19 111.23,66.44 111.26,66.53 111.26,66.74 111.23,66.82 111.23,66.82 111.2,66.92 111.2,67.19 UC1.AY61
  BOTTOM w0.112: JDIMM1.71 63.82,31.32 v2(63.77,31.27)
DDR_A_D46: length 78.3
  IN1 w0.076: v2(109.35,59.11) 109.19,59.27 108.92,59.27 108.84,59.2 108.84,57.7 107.78,56.64 105.65,56.64 103.95,54.93 103.91,54.93
  IN1 w0.119: 103.91,54.93 102.07,53.09 84.27,53.09 67.52,36.34 67.52,31.44 67.4,31.32 66.9,31.32 66.78,31.2 66.78,30.96 66.9,30.84 67.4,30.84 67.52,30.72 67.52,30.5 67.4,30.38 66.83,30.38 66.69,30.24 66.69,30.02 66.8,29.9 67.4,29.9 67.52,29.78 67.52,28.09 67.4,27.97 67.16,27.97 67.05,28.09 67.05,29.35 66.93,29.47 66.58,29.47 v2(66.31,29.74)
  BOTTOM w0.076: v2(109.35,59.11) 110.33,60.09 110.33,62.45 112.35,64.47 112.35,64.89 112.59,65.13 112.59,66.08 112.53,66.23 UC1.BA59
  BOTTOM w0.112: JDIMM1.83 66.82,30.26 v2(66.31,29.74)
DDR_A_D47: length 79.1
  IN1 w0.076: v2(109.35,57.97) 107.84,56.47 105.92,56.47 104.21,54.75
  IN1 w0.119: 104.21,54.75 102.13,52.68 84.39,52.68 67.85,36.15 67.85,28.8 67.95,28.7 68.18,28.7 68.31,28.57 68.31,28.33 68.19,28.21 67.97,28.21 67.85,28.09 67.85,27.89 67.97,27.77 68.53,27.77 68.65,27.65 68.65,27.44 68.53,27.32 67.98,27.32 67.86,27.2 67.86,27.07 67.49,26.7 66.87,26.7 66.7,26.87 66.7,27.83 v2(66.31,28.22)
  BOTTOM w0.076: v2(109.35,57.97) 109.44,57.97 110.5,59.04 110.5,62.38 112.51,64.39 112.51,64.82 112.75,65.06 112.75,66.12 112.72,66.19 112.59,66.62 112.59,66.82 112.32,67.08 UC1.AY59
  BOTTOM w0.112: JDIMM1.80 66.07,26.01 65.72,26.36 65.72,27.63 v2(66.31,28.22)
DDR_A_D48: length 49.2
  IN3 w0.076: v2(107.65,69.4) 107.1,68.85 106.61,68.85 104.45,66.69 104.08,66.69 103.38,65.99 103.38,65.09 101.51,63.23 101.51,63.02
  IN3 w0.117: v2(102.3,29.74) 101.91,30.14 101.91,36.81 102.05,36.95 102.4,36.95 102.53,37.08 102.53,37.27 102.4,37.4 102.06,37.4 101.93,37.53 101.93,37.73 102.06,37.86 102.45,37.86 102.54,37.95 102.54,38.63 101.67,39.49 101.67,57.38 101.51,57.54 101.51,63.02
  BOTTOM w0.076: UC1.AT66 108,69.75 v2(107.65,69.4)
  BOTTOM w0.112: v2(102.3,29.74) 100.82,31.22 JDIMM1.211
DDR_A_D49: length 48.2
  IN3 w0.076: 101.84,63.23 101.84,63.32 104.78,66.26 104.78,66.56 106.1,67.89 107.03,67.89 107.19,68.05 107.19,68.56 107.4,68.77 v2(107.65,68.77)
  IN3 w0.117: v2(102.3,31.27) 102.3,32 102.43,32.13 102.74,32.13 102.87,32.26 102.87,32.44 102.74,32.57 102.39,32.57 102.26,32.7 102.26,32.89 102.39,33.02 102.74,33.02 102.87,33.15 102.87,33.34 102.74,33.47 102.38,33.47 102.25,33.6 102.25,33.78 102.38,33.92 102.74,33.92 102.87,34.05 102.87,34.23 102.74,34.36 102.38,34.36 102.25,34.49 102.25,34.68 102.38,34.81 102.51,34.81 102.62,34.92 102.62,35.14 102.51,35.26 102.39,35.26 102.26,35.39 102.26,35.6 102.39,35.73 102.74,35.73 102.87,35.86 102.87,36.05 102.74,36.18 102.38,36.18 102.25,36.31 102.25,36.49 102.38,36.62 102.77,36.62 102.87,36.71 102.87,38.76 102,39.63 102,57.51 101.84,57.67 101.84,63.23
  BOTTOM w0.076: UC1.AU66 v2(107.65,68.77)
  BOTTOM w0.112: JDIMM1.215 101.82,31.75 v2(102.3,31.27)
DDR_A_D50: length 51.8
  IN3 w0.076: v2(108.56,71.31) 108.93,70.94 108.93,69.19 109.12,69 109.12,67.97 106.98,65.83 106.76,65.83 104.44,63.51 104.44,63.23
  IN3 w0.117: v2(104.84,31.27) 104.86,31.29 105.33,31.29 105.45,31.4 105.45,31.58 105.32,31.71 104.9,31.71 104.8,31.81 104.8,32 104.93,32.13 105.29,32.13 105.42,32.26 105.42,32.45 105.29,32.58 104.93,32.58 104.81,32.7 104.81,32.88 104.93,33.01 105.42,33.01 105.55,33.14 105.55,33.33 105.42,33.46 104.93,33.46 104.8,33.59 104.8,33.77 104.93,33.9 105.41,33.9 105.53,34.03 105.53,34.22 105.41,34.35 104.93,34.35 104.8,34.48 104.8,35.32 104.93,35.44 105.4,35.44 105.53,35.57 105.53,35.79 105.4,35.92 104.95,35.92 104.82,36.05 104.82,36.23 104.95,36.35 105.4,36.35 105.55,36.5 105.55,38.82 103.95,40.42 103.95,58.34 104.44,58.83 104.44,63.23
  BOTTOM w0.076: v2(108.56,71.31) 108.82,71.05 UC1.AP65
  BOTTOM w0.112: v2(104.84,31.27) 104.84,31.45 104.32,31.97 JDIMM1.225
DDR_A_D51: length 52.8
  IN3 w0.076: 104.77,62.97 104.77,63.24 106.24,64.7 106.97,64.7 107.19,64.92 107.19,65.61 109.29,67.71 109.29,69.06 109.28,69.06 109.28,69.07 109.1,69.26 109.1,71.41 v2(108.56,71.94)
  IN3 w0.117: 104.77,62.97 104.77,58.69 104.28,58.2 104.28,40.56 105.88,38.96 105.88,28.95 105.74,28.81 105.43,28.81 105.25,28.99 105.25,29.63 105.14,29.74 v2(104.84,29.74)
  BOTTOM w0.076: v2(108.56,71.94) 108.81,71.7 UC1.AN65
  BOTTOM w0.112: v2(104.84,29.74) 105.74,30.64 105.74,31.71 105.32,32.12 JDIMM1.229
DDR_A_D52: length 51.6
  IN3 w0.076: v2(107.65,71.31) 107.28,70.94 107.28,70.03 104.92,67.66 103.97,67.66 103.56,67.25 103.56,66.66 103.03,66.14 103.03,65.4 100.85,63.21 100.85,63.12
  IN3 w0.117: v2(102.3,26.7) 101.37,26.7 101.24,26.83 101.24,38.98 101.01,39.21 101.01,57.1 100.85,57.26 100.85,63.12
  BOTTOM w0.076: UC1.AN66 108.04,71.7 v2(107.65,71.31)
  BOTTOM w0.112: JDIMM1.216 102.07,26.47 v2(102.3,26.7)
DDR_A_D53: length 51.4
  IN3 w0.076: v2(107.65,70.67) 107.65,70.16 104.98,67.49 104.04,67.49 103.79,67.25 103.79,66.67 103.2,66.07 103.2,65.2 101.18,63.18 101.18,63.02
  IN3 w0.117: v2(102.3,28.22) 101.57,28.95 101.57,38.06 101.72,38.2 102.03,38.2 102.16,38.33 102.16,38.52 102.03,38.65 101.72,38.65 101.59,38.78 101.59,39.1 101.34,39.35 101.34,57.24 101.18,57.4 101.18,63.02
  BOTTOM w0.076: UC1.AP66 v2(107.65,70.67)
  BOTTOM w0.112: v2(102.3,28.22) 101.07,26.99 JDIMM1.212
DDR_A_D54: length 50.8
  IN3 w0.076: 104.11,63.23 104.11,63.42 106.69,66 106.91,66 108.94,68.02 108.94,68.93 108.56,69.3 v2(108.56,69.4)
  IN3 w0.117: 104.11,63.23 104.11,58.97 103.61,58.47 103.61,40.28 105.22,38.68 105.22,37.78 105.12,37.67 104.6,37.67 104.47,37.54 104.47,37.33 104.6,37.2 105.08,37.2 105.21,37.07 105.21,36.89 105.08,36.76 104.59,36.76 104.47,36.64 104.47,31.47 104.45,31.45 104.45,28.29 104.58,28.16 104.78,28.16 v2(104.84,28.22)
  BOTTOM w0.076: v2(108.56,69.4) 108.91,69.75 UC1.AT65
  BOTTOM w0.112: JDIMM1.224 104.07,25.94 104.07,27.45 v2(104.84,28.22)
DDR_A_D55: length 49.8
  IN3 w0.076: 104.49,64.32 104.78,64.32 106.62,66.16 106.84,66.16 108.56,67.88 v2(108.56,68.77)
  IN3 w0.112: 103.11,63.23 103.11,63.66 103.77,64.32 104.49,64.32
  IN3 w0.117: v2(104.84,26.7) 104.34,26.7 104.11,26.92 104.11,31.56 104.14,31.59 104.14,37.9 104.26,38.02 104.75,38.02 104.88,38.15 104.88,38.34 104.75,38.47 104.26,38.47 104.14,38.59 104.14,39.29 103.28,40.15 103.28,58.26 103.11,58.43 103.11,63.23
  BOTTOM w0.076: UC1.AU65 108.9,69.1 v2(108.56,68.77)
  BOTTOM w0.112: v2(104.84,26.7) 105.07,26.47 105.07,26.21 JDIMM1.228
DDR_A_D56: length 50.7
  IN3 w0.076: v2(110.39,69.4) 110.39,69.3 109.88,68.79 109.88,67.55 108.69,66.36 108.69,64.91 107.98,64.21 107.26,64.21 106.23,63.18 106.23,59.71 105.96,59.45 105.96,59.24
  IN3 w0.117: 105.96,59.24 105.96,58.2 105.47,57.71 105.47,41.05 108.29,38.23 108.29,37.55 108.18,37.44 107.44,37.44 107.32,37.32 107.32,37.12 107.44,36.99 108.2,36.99 108.31,36.88 108.31,36.68 108.2,36.57 107.24,36.57 107.07,36.41 107.07,30.14 v2(107.47,29.74)
  BOTTOM w0.076: v2(110.39,69.4) 110.74,69.75 UC1.AT61
  BOTTOM w0.112: JDIMM1.233 106.32,32.25 106.73,31.84 106.73,30.48 v2(107.47,29.74)
DDR_A_D57: length 50.2
  IN3 w0.076: v2(110.39,68.77) 110.39,68.24 110.07,67.91 110.07,67.4 108.86,66.19 108.86,64.75 108,63.89 107.34,63.89 106.4,62.94 106.4,59.35 106.29,59.25
  IN3 w0.117: v2(107.47,31.27) 107.42,31.32 107.42,32.39 107.54,32.51 107.84,32.51 107.96,32.63 107.96,32.86 107.84,32.98 107.54,32.98 107.42,33.09 107.42,33.49 107.54,33.61 108.27,33.61 108.4,33.74 108.4,33.93 108.27,34.06 107.54,34.06 107.41,34.19 107.41,35 107.61,35.2 108.53,35.2 108.65,35.31 108.65,35.55 108.53,35.67 107.55,35.67 107.42,35.8 107.42,36.09 107.55,36.22 108.54,36.22 108.65,36.33 108.65,38.35 105.8,41.19 105.8,57.57 106.29,58.06 106.29,59.25
  BOTTOM w0.076: UC1.AU61 110.73,69.1 v2(110.39,68.77)
  BOTTOM w0.112: JDIMM1.237 107.32,32.02 107.44,31.91 107.88,31.91 108.03,31.76 108.03,31.4 107.9,31.27 v2(107.47,31.27)
DDR_A_D58: length 53.3
  IN3 w0.076: 108.61,62.32 108.61,62.57 110.82,64.77 110.82,65.35 112.2,66.74 112.2,68.67 111.69,69.18 111.69,70.93 v2(111.31,71.31)
  IN3 w0.117: v2(110.26,28.22) 110.19,28.14 110.19,27.99 110.33,27.84 110.88,27.84 111.01,27.98 111.01,28.71 110.9,28.83 110.77,28.83 110.65,28.95 110.65,29.18 110.77,29.3 110.9,29.3 111.01,29.41 111.01,29.65 110.9,29.76 110.77,29.76 110.65,29.88 110.65,30.12 110.77,30.23 110.9,30.23 111.01,30.35 111.01,39.68 107.75,42.94 107.75,56.79 108.61,57.64 108.61,62.32
  BOTTOM w0.076: UC1.AP60 111.56,71.05 v2(111.31,71.31)
  BOTTOM w0.112: v2(110.26,28.22) 109.39,27.34 109.39,26 109.57,25.82 JDIMM1.246
DDR_A_D59: length 53.2
  IN3 w0.076: v2(111.31,71.96) 111.85,71.41 111.85,69.25 112.38,68.73 112.38,66.67 111.02,65.32 111.02,64.67 108.94,62.59 108.94,62.32
  IN3 w0.117: 108.94,62.32 108.94,57.51 108.09,56.65 108.09,43.08 111.94,39.23 111.94,32.09 111.58,31.73 111.58,26.82 111.15,26.38 110.58,26.38 v2(110.26,26.7)
  BOTTOM w0.076: v2(111.31,71.96) 111.56,71.7 UC1.AN60
  BOTTOM w0.112: JDIMM1.250 110.57,26.38 v2(110.26,26.7)
DDR_A_D60: length 52.8
  IN3 w0.076: 105.3,59.24 105.3,59.35 105.9,59.96 105.9,63.63 106.8,64.54 107.78,64.54 108.29,65.04 108.29,66.43 109.52,67.67 109.52,68.92 109.85,69.25 109.85,70.77 v2(110.39,71.31)
  IN3 w0.117: v2(107.47,26.7) 106.55,26.7 106.43,26.82 106.43,27.31 106.57,27.45 106.98,27.45 107.09,27.56 107.09,27.78 106.98,27.89 106.54,27.89 106.41,28.02 106.41,39.17 104.8,40.78 104.8,57.98 105.3,58.47 105.3,59.24
  BOTTOM w0.076: v2(110.39,71.31) 110.79,71.7 UC1.AN61
  BOTTOM w0.112: v2(107.47,26.7) 107.07,26.3 JDIMM1.236
DDR_A_D61: length 51.9
  IN3 w0.076: 105.63,59.24 105.63,59.37 106.06,59.8 106.06,63.25 107.19,64.37 107.87,64.37 108.47,64.98 108.47,66.38 109.7,67.6 109.7,68.84 110.02,69.17 110.02,70.31 v2(110.39,70.67)
  IN3 w0.117: v2(107.47,28.22) 106.74,28.95 106.74,37.85 106.89,38 107.45,38 107.58,38.13 107.58,38.32 107.45,38.45 106.87,38.45 106.76,38.57 106.76,39.3 105.14,40.91 105.14,57.84 105.63,58.34 105.63,59.24
  BOTTOM w0.076: v2(110.39,70.67) 110.77,71.05 UC1.AP61
  BOTTOM w0.112: JDIMM1.232 106.07,26.83 v2(107.47,28.22)
DDR_A_D62: length 52.4
  IN3 w0.076: v2(111.31,69.4) 111.31,69.33 112.03,68.61 112.03,66.8 110.64,65.41 110.64,64.99 108.27,62.62 108.27,62.32
  IN3 w0.117: 108.27,62.32 108.27,57.77 107.42,56.92 107.42,42.8 107.81,42.42 107.81,42.3 107.51,42.01 107.51,41.82 107.64,41.69 107.83,41.69 108.08,41.95 108.27,41.95 108.42,41.79 108.42,41.58 108.16,41.32 108.16,41.13 108.29,41 108.44,41 108.73,41.29 108.91,41.29 109.04,41.15 109.04,40.97 108.77,40.7 108.77,40.51 108.92,40.36 109.11,40.36 109.39,40.65 109.58,40.65 109.71,40.51 109.71,40.33 109.42,40.04 109.42,39.85 109.57,39.7 109.75,39.7 110.01,39.96 110.19,39.96 110.32,39.82 110.32,39.64 110.07,39.39 110.07,39.2 110.29,38.98 110.29,38.69 110.41,38.57 110.56,38.57 110.68,38.45 110.68,38.22 110.56,38.1 110.42,38.1 110.3,37.99 110.3,37.75 110.42,37.64 110.56,37.64 110.68,37.52 110.68,37.29 110.56,37.17 110.41,37.17 110.29,37.05 110.29,36.82 110.41,36.7 110.56,36.7 110.68,36.59 110.68,36.35 110.56,36.23 110.41,36.23 110.29,36.12 110.29,35.88 110.41,35.77 110.56,35.77 110.68,35.65 110.68,35.42 110.56,35.3 110.43,35.3 110.31,35.18 110.31,34.91 110.43,34.79 110.56,34.79 110.68,34.68 110.68,34.44 110.56,34.32 110.39,34.32 110.28,34.21 110.28,33.97 110.39,33.86 110.56,33.86 110.68,33.74 110.68,33.51 110.56,33.39 110.39,33.39 110.28,33.27 110.28,33.04 110.39,32.92 110.56,32.92 110.68,32.81 110.68,32.57 110.56,32.46 110.4,32.46 110.27,32.33 110.27,32.03 110.68,31.62 110.68,31.25 110.56,31.13 110.4,31.13 v2(110.26,31.27)
  BOTTOM w0.076: v2(111.31,69.4) 111.66,69.75 UC1.AT60
  BOTTOM w0.112: v2(110.26,31.27) 110.32,31.33 JDIMM1.249
DDR_A_D63: length 52
  IN3 w0.076: 108.05,62.75 110.46,65.16 110.46,65.46 111.86,66.86 111.86,68.55 111.63,68.77 v2(111.31,68.77)
  IN3 w0.117: v2(110.26,29.74) 110.22,29.79 109.99,29.79 109.87,29.67 109.87,28.24 109.73,28.11 109.51,28.11 109.39,28.22 109.39,30.47 109.51,30.59 109.61,30.59 109.73,30.71 109.73,30.94 109.61,31.06 109.51,31.06 109.39,31.18 109.39,31.7 109.94,32.24 109.94,38.87 107.09,41.71 107.09,57.06 107.94,57.91 107.94,62.64 108.05,62.75
  BOTTOM w0.076: UC1.AU60 111.64,69.1 v2(111.31,68.77)
  BOTTOM w0.112: v2(110.26,29.74) 109.54,29.74 109.43,29.86 109.43,31.79 109.32,31.9 JDIMM1.245
DDR_A_DQS0: length 88.3
  IN1 w0.124: v2(99.05,71.79) 98.94,71.91 98.94,72.22 98.69,72.47 94.58,72.47 89.7,67.6 82.26,67.6 81.59,66.93 79.43,66.93 49.69,37.19 49.69,34.96 49.57,34.84 49.03,34.84 48.78,34.59 48.78,34.04 49.03,33.79 49.5,33.79 49.67,33.61 49.67,33.11 49.42,32.86 48.72,32.86 48.35,32.49 48.35,29.63 48.62,29.36 v2(49.2,29.36)
  BOTTOM w0.076: v2(99.05,71.79) 98.99,71.73 98.99,71.57 99.16,71.39 101.99,71.39 102.67,72.07 103,72.07 103.57,72.64 104.63,72.64 104.73,72.54 104.99,72.54 105.1,72.6 105.32,72.6 105.43,72.54 105.64,72.54 105.72,72.58 106.01,72.58 106.21,72.48 106.25,72.45 106.45,72.24 UC1.AM69
  BOTTOM w0.112: JDIMM1.13 49.32,31.66 49.92,31.07 49.92,29.76 49.68,29.53 49.37,29.53 v2(49.2,29.36)
DDR_A_DQS1: length 82.3
  IN1 w0.076: v2(101.7,66.25) 101.84,66.25 102.01,66.08 102.01,65.28 101.75,65.02 101.67,65.02
  IN1 w0.124: v2(54.3,28.52) 54.44,28.39 54.71,28.39 55.22,28.89 55.22,36.94 56.76,38.49 57.31,38.49 57.57,38.75 57.57,38.93 57.37,39.13 57.37,39.48 57.82,39.94 58.18,39.94 58.38,39.74 58.55,39.74 58.82,40 58.82,40.18 58.62,40.38 58.62,40.73 79.67,61.78 98.43,61.78 101.67,65.02
  BOTTOM w0.076: v2(101.7,66.25) 101.38,66.57 101.38,67.59 102.17,68.38 102.61,68.38 103.63,69.39 104.37,69.39 104.53,69.56 105.02,69.56 105.16,69.51 105.27,69.51 105.4,69.56 105.67,69.56 105.75,69.52 105.97,69.52 106.1,69.58 106.11,69.6 106.11,69.75 106.07,69.79 UC1.AT70
  BOTTOM w0.112: v2(54.3,28.52) 54.61,28.21 54.78,28.21 54.95,28.04 54.95,26.8 54.43,26.28 54.43,26.04 54.57,25.9 JDIMM1.34
DDR_A_DQS2: length 65.7
  IN3 w0.076: v2(109.08,73.81) 109.08,73.76 108.74,73.42 107.59,73.42 105.55,71.37 105.55,69.84 104.9,69.19 103.25,69.19 102.48,68.42 102.03,68.42
  IN3 w0.124: v2(98.49,28.6) 98.29,28.4 98.07,28.4 97.89,28.58 97.89,30.85 98.04,31 98.15,31 98.38,31.22 98.38,34.99 98.13,35.25 97.75,35.25 97.62,35.38 97.62,35.61 97.76,35.74 98.1,35.74 98.38,36.02 98.38,36.41 98.1,36.69 97.66,36.69 97.5,36.85 97.5,37.04 97.66,37.2 98.1,37.2 98.38,37.48 98.38,37.86 98.1,38.14 97.62,38.14 97.5,38.26 97.5,38.57 97.63,38.7 97.82,38.7 98.07,38.95 98.07,39.38 97.82,39.63 97.62,39.63 97.5,39.75 97.5,40.01 97.62,40.14 97.83,40.14 98.07,40.38 98.07,40.85 97.82,41.1 97.59,41.1 97.5,41.19 97.5,41.44 97.62,41.57 97.81,41.57 98.07,41.83 98.07,60.79 98.25,60.97 98.48,60.97 98.71,61.2 98.71,61.67 98.47,61.91 97.42,61.91 97.29,62.03 97.29,62.35 97.44,62.5 98.49,62.5 98.72,62.73 98.72,63.89 100.7,65.87 100.7,67.66 101.46,68.42 102.03,68.42
  BOTTOM w0.076: v2(109.08,73.81) UC1.AH65
  BOTTOM w0.112: JDIMM1.200 98.07,25.77 97.93,25.92 97.93,26.02 97.93,26.16 98.06,26.3 98.61,26.3 99.11,26.8 99.11,28.07 98.83,28.36 98.74,28.36 v2(98.49,28.6)
DDR_A_DQS3: length 69
  IN3 w0.112: 100.84,74.68 100.86,74.7 100.86,74.71 100.9,74.75 100.9,74.76 101.06,74.91 101.31,74.91 ; 101.43,75.03 101.43,75.05 101.67,75.29 v2(101.8,75.29)
  IN3 w0.124: 100.84,74.68 100.67,74.51 95.51,74.51 90.15,69.15 90.15,63.66 94.27,59.53 94.27,51.15 93.4,50.28 93.4,48.7 93.7,48.39 93.7,47.77 93.4,47.47 93.4,47.02 93.7,46.72 93.7,46.1 93.4,45.8 93.4,45.09 93.7,44.78 93.7,44.16 93.4,43.86 93.4,33.17 93.15,32.92 92.92,32.92 92.75,32.75 92.75,32.53 92.9,32.38 93.45,32.38 93.7,32.12 93.7,31.7 93.45,31.45 93.1,31.45 92.88,31.23 92.88,29.96 93.03,29.81 93.3,29.81 93.43,29.94 93.43,30.11 v2(93.41,30.13) ; 101.31,74.91 101.43,75.03
  BOTTOM w0.076: v2(101.8,75.29) 101.55,75.04 101.55,74.69 101.67,74.57 105.02,74.57 105.16,74.51 105.27,74.51 105.4,74.57 105.67,74.57 105.75,74.53 105.97,74.53 106.1,74.59 106.22,74.71 106.22,74.85 106.17,74.9 105.96,74.9 UC1.AG70
  BOTTOM w0.112: v2(93.41,30.13) 93.41,29.9 93.3,29.79 93.08,29.79 92.97,29.9 92.97,30.09 92.88,30.18 92.88,30.83 92.97,30.93 92.97,31.76 92.71,32.01 92.71,32.17 92.82,32.29 JDIMM1.179
