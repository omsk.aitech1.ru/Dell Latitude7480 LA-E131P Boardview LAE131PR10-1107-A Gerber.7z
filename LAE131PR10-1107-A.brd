# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_RUN_AUDIO: length 20.9
  TOP w0.127: 291.76,25.67 291.99,25.67 v1(292.31,25.35)
  TOP w0.508: LA14.2 293.31,37.37 RA18.2 293.06,37.48 292.46,36.88 292.46,36.36 ; RA61.1 292.46,36.36 ; 292.46,36.36 292.46,35.47 v2(292.59,35.34) ; RA59.1 v2(289.91,28.31) ; v2(292.46,29.12) 292.65,28.92 LA12.2
  IN1 w0.508: v2(292.46,29.12) 292.43,29.12 291.56,28.24 v2(291.56,25.26)
  BOTTOM w0.508: v2(292.59,35.34) 292.8,35.13 292.8,31.05 293.4,30.45 293.4,29.73 292.79,29.12 v2(292.46,29.12) 290.71,29.12 v2(289.91,28.31)
+3.3V_RUN_AUDIO_DVDD: length 1.6
  TOP w0.203: UA1.1 296.67,34.62 v3(296.19,35.1) 295.92,35.36
+3.3V_RUN_AUDIO_IO: length 4.8
  TOP w0.203: UA1.9 296.63,31.42 295.91,30.7 295.91,29.89 295.71,29.69 CA55.1 295.04,29.69 CA56.1 294.78,28.94 LA12.1
+3.3V_RUN_AUDIO_UZ5:
  vias: v1(293.05,19.84)
+3.3V_RUN_CARD: length 18.2
  TOP w0.102: v1(307.91,41.94) 307.81,42.04 v1(306.15,42.04)
  TOP w0.127: v1(307.91,41.94) 308.79,41.07 v2(308.79,41.01) ; v1(307.01,40.35) 307.58,40.93 307.98,40.93
  IN3 w1.016: 308.37,41.76 308.36,41.78 308.36,43.78 307.63,44.51 305.4,44.51 304.74,43.85 298.66,43.85 297.54,44.97
  vias: v2(297.8,48.72) v2(297.8,48.14) v2(309.37,41.01)
+3.3V_RUN_DIMM1: length 6.4
  TOP w0.102: CD28.1 109.58,32.28 CD27.1 110.66,32.28 110.73,32.35 RD10.2 111.38,31.83 111.61,31.6 v2(112.08,31.6) 112.56,32.09 v3(112.56,33.01)
  BOTTOM w0.305: v2(112.08,31.6) 111.83,31.86 JDIMM1.255
+3.3V_RUN_DIMM2: length 6.2
  TOP w0.102: RD26.2 190.45,30.63 190.73,30.91 190.73,31.57 CD59.1 CD60.1 191.19,32.76 v3(191.19,33.23) 191.19,34.05 v2(190.92,34.31)
  BOTTOM w0.305: JDIMM2.255 190.92,36.1 v2(190.92,34.31)
+3.3V_RUN_UZ3:
  vias: v1(199.07,37.62)
+3.3V_SPI: length 99.7
  TOP w0.254: v2(166.23,85.47) 165.52,85.47 164.49,84.44 164.49,79.9 v1(165.05,79.35) 165.05,79.31 168.17,76.19 168.17,76.13 168.27,76.02 v2(168.27,76.02)
  IN1 w0.254: v2(179.01,85.4) 178.98,85.4 177.1,87.28 175.65,87.28 174.45,86.08 172.28,86.08 171.57,85.36 167.9,85.36 167.63,85.63 166.39,85.63 v2(166.23,85.47)
  IN2 w0.127: 140.23,73.49 140.93,74.19 143.39,74.19 143.72,73.86 144.22,73.86 143.74,73.38 140.97,73.38 140.87,73.49 140.23,73.49
  IN2 w0.254: 140.23,73.49 140.11,73.37 139.6,73.37 139.35,73.63 139.35,74.72 138.88,75.19 137.14,75.19 136.55,74.6 136.55,74.06 v2(137.08,73.54) ; 144.22,73.86 149.48,73.86 149.9,73.43 152.64,73.43 153.77,72.31 155.59,72.31 156.47,73.18 156.47,75.73 159.07,78.33 163.07,78.33 164.73,76.66 167.63,76.66 v2(168.27,76.02) ; v2(179.01,85.4) 180.04,86.43 180.04,91.69 179.64,92.09 v2(179.64,92.23)
  BOTTOM w0.254: JSPI1.6 171.89,77.88 ; 171.89,77.88 172.71,78.7 RC31.2 RC30.2 ; 171.89,77.88 171.77,78.01 168.97,78.01 168.27,77.31 v2(168.27,76.02) 168.27,75.5 169.82,73.95 169.82,72.64 169.55,72.37 169.55,71.09 170.24,70.4 RC41.1 ; CC9.1 179.64,92.23 v2(179.64,92.23) 179.55,92.15 179.55,92.11 179.43,91.98 179.43,91.23 179.68,90.98 UC5.8 ; v2(137.08,73.54) 136.74,73.88 UC1.AJ16 ; v2(179.01,85.4) CC10.1 179.07,84.84 UC6.8
+3.3V_TBT: length 59.6
  TOP w0.203: v2(26.66,85.51) UT1.H9
  TOP w0.254: RT49.2 22.18,74.69 v2(21.55,74.69)
  TOP w0.381: v2(33.99,76.09) 34.01,76.12 RT12.2 RT13.2
  TOP w0.508: RT14.2 38.8,80.68 v2(39.2,80.68)
  IN2 w0.381: v2(39.2,80.68) 38.73,80.68 38.29,80.24 38.29,78.58 37.19,77.48 37.19,75.76 36.81,75.38 35.49,75.38 34.77,76.09 v2(33.99,76.09) 33.99,75.58 32.16,73.75 30.71,73.75 28.4,76.07 27.51,76.07 26.7,75.25 23.26,75.25 22.69,74.69 v2(21.55,74.69)
  IN2 w0.508: v2(23.09,81.65) 23.55,81.2 23.55,77.49 21.55,75.49 v2(21.55,74.69)
  BOTTOM w0.254: RT11.2 24.36,79.17 24.11,78.91 24.11,75.76 23.5,75.15 22.01,75.15 v2(21.55,74.69) 21.75,74.49 v3(22.34,74.49) 24.03,74.49 24.56,75.02 28.17,75.02 28.93,75.79 28.93,77.71 30.2,78.98 RT337.2 ; v2(26.66,85.51) 26.66,85.4 26.37,85.11 CT43.1 ; RT14.2 38.58,81.08 RT336.2
  BOTTOM w0.508: v2(39.2,80.68) 39.03,80.5 38.62,80.5 RT14.2
  vias: v2(23.09,82.29)
+3.3V_TBT_FLASH_R: length 19.3
  TOP w0.254: 35.97,75.05 35.69,74.77 34.47,74.77 34.41,74.71 32.98,74.71 32.72,74.97 v2(32.08,74.97) ; 35.97,75.05 RT2.2 RT3.2 RT4.2 RT10.2 ; 35.97,75.05 RT9.1
  BOTTOM w0.254: CT1.1 23.98,74.01 RT1.2 ; CT1.1 24.64,74.11 24.94,74.42 28.86,74.42 v1(29.4,74.96) 30.18,75.74 30.99,75.74 31.75,74.97 v2(32.08,74.97) ; CT1.1 25.05,74.01 25.68,73.37 UT2.8
+3.3V_TBT_LC: length 16.7
  TOP w0.203: UT1.R6 v2(30.57,84.21)
  TOP w0.254: RT9.2 34.47,75.28 34.36,75.16 33.09,75.16 32.72,75.53 v2(32.21,75.53)
  IN3 w0.381: v2(30.57,84.21) 31.31,84.21 31.83,84.73 33.14,84.73 34.14,83.72 v2(34.14,80.89)
  BOTTOM w0.254: v2(30.57,84.21) CT41.1
  BOTTOM w0.381: RT6.2 33.45,80.48 32.24,79.27 v1(32.24,77.63) 32.24,75.95 32.21,75.91 v2(32.21,75.53)
+3.3V_TBT_S0: length 0.5
  TOP w0.203: v2(30.57,87.45) 30.24,87.13 UT1.R13
  vias: v1(18.73,86.39) v2(18.95,85.68) v2(19.43,85.96) v2(19.41,85.35)
+3.3V_TBT_SX: length 28.9
  TOP w0.203: UT1.F8 v2(26.01,84.21)
  TOP w0.508: RT338.2 36.6,76.68 v2(36.6,76.09) ; v2(26.52,76.04) RT20.2 RT17.2 ; RT19.2 v2(31.35,77.34) ; RT18.2 v2(30.14,77.32)
  IN2 w0.508: v2(36.6,76.09) 36.6,76.22 35.99,76.83 31.85,76.83 v2(31.35,77.34) 30.15,77.34 v2(30.14,77.32) 27.8,77.32 v2(26.52,76.04) 25.4,77.16 24.79,77.16 24.21,77.74 24.21,82.7 25.02,83.51 25.5,83.51 26.01,84.02 v2(26.01,84.21)
  BOTTOM w0.254: v2(36.6,76.09) 35.94,76.75 RT371.2
  BOTTOM w0.381: CT42.1 26.01,83.61 v2(26.01,84.21)
  BOTTOM w0.508: v2(26.52,76.04) 26.39,76.17 RT372.2 RT16.2
+3.3V_TBTA_FLASH: length 84.1
  TOP w0.102: v3(28.46,49.26) 27.95,49.76 v2(27.88,49.76)
  TOP w0.203: CT84.1 27.62,65.88 27.62,65.46 27.9,65.18 27.9,64.5 27.76,64.35 UT5.G1
  TOP w0.254: v2(34.83,63.49) 36.04,64.71 37.59,64.71 37.67,64.64 RT67.2 RT66.2 ; RT95.2 23.93,67.35 24.31,66.97 v2(24.31,66.92)
  TOP w0.457: CT84.1 27.26,67.14 27.26,68.19 v2(27.13,68.32)
  TOP w0.508: CT70.1 27.49,49.76 v2(27.88,49.76) ; CT70.1 25.98,49.49 RT51.2 ; CT70.1 27.22,50.42 RT50.2 RT52.2 ; RT10.1 34.62,70.78 v2(34.62,70.58) ; RT53.2 25.94,52.36 25.94,52.64 v2(25.61,52.98) 25.33,53.26 RT98.2
  IN1 w0.457: v2(27.88,49.76) 27.88,51.02 30.98,54.12 30.98,56.5 31.8,57.32 31.8,58.03 32.77,58.99 34.87,58.99 35.75,59.87 35.75,61.25 34.83,62.17 v2(34.83,63.49)
  IN2 w0.508: v2(25.61,52.98) 25.61,51.17 27.01,49.76 v2(27.88,49.76)
  IN3 w0.508: v2(34.83,63.49) 34.83,64.9 34.15,65.58 34.08,65.58 33.53,66.13 30.89,66.13 29.94,67.09 28.51,67.09 27.28,68.32 v2(27.13,68.32)
  BOTTOM w0.254: RT76.2 24.2,62.65 24.56,63.01 24.56,64.34 23.78,65.12 23.78,66.72 23.98,66.92 v2(24.31,66.92) 24.31,68.32 24.79,68.8 26.8,68.8 27.13,68.47 v2(27.13,68.32)
  BOTTOM w0.305: 27.32,46.53 26.15,45.36 JDB1.1
  BOTTOM w0.381: 27.32,46.53 27.78,46.98 27.78,49.66 v2(27.88,49.76)
  BOTTOM w0.508: v2(34.62,70.58) 34.65,70.55 34.65,70.13 35.16,69.61 35.16,66.52 ; 35.16,66.52 33.29,66.52 32.95,66.17 30.84,66.17 29.78,67.23 RT106.2 ; 35.16,66.52 35.16,63.83 v2(34.83,63.49) 34.83,62.96 34.13,62.26 RT107.2 ; UT6.8 28.72,48.93 v2(27.88,49.76)
+3.3V_TP: length 136.8
  TOP w0.508: v2(247.95,30.43) 248.03,30.35 v1(248.03,28.94) 248.03,27.57 CZ90.1 ; RZ117.1 RZ116.1 167.29,77.95 166.47,78.76 v2(166.47,78.93)
  IN1 w0.508: v2(166.47,78.93) 166.94,78.46 166.94,77.37 166.3,76.73 166.3,75.54 166.36,75.48 166.36,74.32 165.99,73.95 160.9,73.95 v2(159.89,72.93)
  IN2 w0.508: v2(159.89,72.93) 160.64,72.18 164.89,72.18 167.59,69.48 169.72,69.48 171.2,68 172.13,68 178.64,61.49 178.81,61.49 184.43,55.87 184.96,55.87 185.35,55.48 185.35,55.1 200.26,40.2 201.55,40.2 204.87,36.88 207.36,36.88 208.84,35.4 219.05,35.4 221.33,33.13 231.89,33.13 232.62,32.4 235.71,32.4 236.91,31.19 238.03,31.19 238.74,30.48 244.99,30.48 245.16,30.65 247.73,30.65 v2(247.95,30.43)
  BOTTOM w0.305: JKBTP1.9 248.85,29.53 v2(247.95,30.43)
  BOTTOM w0.508: RZ21.1 166.94,78.46 v2(166.47,78.93) ; v2(159.89,72.93) 159.89,73.42 163.08,76.61 163.08,77.41 164.04,78.37 RZ20.1
+3.3V_VCCHDA: length 3.6
  TOP w0.254: v2(134.46,73.49) CC313.1 135.07,74.53 135.35,74.25 LC1.2 135.66,74.29 135.66,74.96 CC324.1
  BOTTOM w0.254: UC1.AJ19 134.46,73.53 v2(134.46,73.49)
+3.3V_VDD_DCIN: length 88.8
  TOP w0.381: v2(33.8,110.64) 33.8,111.31 PC9.1 33.6,111.44 33.56,111.4 33.29,111.4 PU1.5
  TOP w0.508: PR17.1 39.12,110.08 38.43,110.76 v2(37.57,110.76) ; v2(40.55,63.86) 40.55,64.24 39.3,65.5 36.7,65.5 36.19,66.01 v2(36.19,66.15) PR1208.1 35.32,66.91 PR1206.1 ; PR27.2 33.02,107.03 v2(32.59,107.03)
  IN2 w0.508: v2(35.91,100.32) 36.59,100.32 36.98,99.92 36.98,95.09 37.72,94.35 37.72,91.48 38.56,90.65 38.56,90.11 39.58,89.1 39.58,86.18 40.03,85.72 40.03,82.36 40.67,81.73 40.67,75.79 39.83,74.95 39.83,70.07 36.19,66.43 v2(36.19,66.15)
  BOTTOM w0.508: PD1801.3 35.8,72.47 35.26,71.93 35.26,70.38 35.77,69.87 35.77,66.58 v2(36.19,66.15) ; v2(35.91,100.32) 35.42,100.32 33,102.74 33,103.81 31.85,104.96 31.85,106.29 v2(32.59,107.03) 33.3,107.74 33.3,109.91 33.8,110.41 v2(33.8,110.64) 34.05,110.64 34.66,110.03 35.06,110.03 35.79,110.76 v2(37.57,110.76) ; v2(40.55,63.86) 42.44,61.97 44.06,61.97 v1(44.36,62.27) 44.36,62.29 44.68,62.6 44.68,65.53 45.69,66.53 PC10.1 44.64,67.86 44.55,67.86 PU2.3
+3.3V_VDD_PIC: length 150.1
  TOP w0.305: v2(46.55,74.56) 46.55,74.68 46.86,74.99 48.08,74.99 48.52,75.42 PC1204.1
  TOP w0.381: PR1214.1 47.24,85.06 48.27,86.1 48.27,89.4 48.66,89.78 50.68,89.78 51.18,89.27 51.18,86.61 49.41,84.83 PR1226.1 ; PU1200.5 49.13,76.28 48.52,75.66 PC1204.1
  TOP w0.508: v2(46.55,74.56) 46.55,74.39 45.95,73.79 45.95,71.95 44.15,70.14 ; PR1214.1 44.04,85.72 v2(44.17,85.85) ; UT7.5 18.16,98.2 17.63,97.67 16.67,97.67 CT91.1 16.66,96.72 CT92.1 16.84,96.54 v2(16.84,95.94) ; v2(43.36,97.86) 43.18,97.86 PR1253.1 ; 44.15,70.14 44.15,69.01 v2(44.07,68.93) ; 44.15,70.14 43.87,70.14 43.23,70.79 41.35,70.79 40.9,71.23 38.03,71.23 37.52,70.72 37.52,70.3 37.24,70.02 36.68,70.02 36.17,70.53 v2(35.97,70.53) 35.9,70.53 35.21,69.83 35.21,69.09 34.86,68.74 33.65,68.74 33.03,69.36 ; v2(41.23,74.56) 41.23,74.95 PR1240.1
  IN1 w0.457: v2(41.23,74.56) 41.39,74.56 42.91,76.08 42.91,78.03 43.36,78.47 43.36,80.1 44.52,81.27 44.52,83.15 44.17,83.5 v2(44.17,85.85)
  IN1 w0.508: v2(43.36,97.86) 43.36,97.62 44.61,96.37 44.61,95.44 46.09,93.96 46.09,91.82 v2(45.57,91.3)
  IN2 w0.381: v2(45.57,91.3) 44.67,91.3 44.2,90.83 44.2,87.36 44.63,86.92 44.63,86.25 44.24,85.85 v2(44.17,85.85)
  IN2 w0.508: 19.36,79.95 19.36,81.23 18.3,82.29 18.3,86.05 19.06,86.82 19.06,89.64 20.89,91.47 v2(20.89,91.98) ; 19.36,79.95 19.36,76.87 18.36,75.88 18.36,74.85 ; 19.36,79.95 18.71,79.3 17.12,79.3 16.64,78.82 16.64,76.57 18.36,74.85 ; v2(41.23,74.56) 41.23,74.52 40.55,73.84 40.55,69.76 37.83,67.04 37.83,64.9 v2(36.92,63.99) ; v2(26.9,72.71) 26.77,72.71 26.11,72.05 22.68,72.05 21.3,70.67 20.53,70.67 18.36,72.84 18.36,74.85
  IN3 w0.508: v2(16.84,95.94) 17.18,95.94 17.97,95.16 17.97,94.23 19.23,92.97 20.39,92.97 20.89,92.46 v2(20.89,91.98)
  BOTTOM w0.102: v1(36.63,63.06) 36.63,63.7 v2(36.92,63.99)
  BOTTOM w0.381: v2(41.23,74.56) 41.23,74.82 39.96,76.08 39.1,76.08 38.72,75.7 38.72,75.35 37.6,74.23 37.6,73.27 37.1,72.77 PD1801.2 ; v2(36.92,63.99) 37.44,64.51 QT1.5 QT1.2
  BOTTOM w0.508: v2(35.97,70.53) 35.97,70.78 36.45,71.27 PR1237.1 36.45,71.97 PD1801.2 ; PR1236.2 44.15,69.61 44.15,69.01 v2(44.07,68.93) ; PR1254.2 46.55,74.74 v2(46.55,74.56)
+3.3V_VDD_PIC_PDA: length 11.7
  TOP w0.203: v2(27.17,64.93) 27.26,64.84 UT5.H1 ; UT5.B1 30.26,64.04 31.65,65.43 v2(31.65,65.54)
  TOP w0.381: v2(31.65,65.54) 32.15,66.05 32.15,67.1 31.68,67.58 CT74.1
  IN3 w0.381: v2(31.65,65.54) 31.45,65.34 30.91,65.34 30.07,66.18 29.2,66.18 28.77,65.75 28.77,65.37 28.32,64.93 v2(27.17,64.93)
+3.3V_WLAN:
  vias: v1(280.99,52.8) v1(280.99,35.78) v1(281.37,37.69) v2(279.28,53.43) v2(279.85,53.43) v2(282.18,37.66) v2(282.18,37.08) v2(282.18,36.46) v2(282.18,35.85) v2(294.52,62.01) v2(294.49,61.36) v2(294.49,60.75) v2(295.05,60.7) v2(295.09,62.01) v2(295.07,61.39)
+3.3V_WLAN_UZ2:
  vias: v1(298.77,62.9)
+3.3V_WWAN:
  vias: v1(259.97,73.63) v1(279.66,74.39) v1(281.94,74.2) v2(261.22,74.72) v2(261.18,74.16) v2(261.74,74.14) v2(261.79,74.69) v2(262.33,74.56) v2(278.19,75.99) v2(278.52,75.53) v2(278.82,76) v2(279.15,75.5) v2(279.38,76.01) v2(284.23,73.25) v2(284.23,72.61) v2(284.23,71.98) v2(284.99,73.25) v2(284.99,72.61) v2(284.99,71.98)
+3.3V_WWAN_UZ4:
  vias: v1(288.61,75.74)
+5V_ALW: length 377.6
  TOP w0.127: CI31.1 294.08,74.39 v1(294.1,74.4)
  TOP w0.203: UZ3.4 202.26,35.09 v2(202.27,35.11) ; v2(285.56,78.67) 285.72,78.51 UZ4.4 ; UZ5.4 295.45,23.46 295.9,23.91 296.5,23.91 v2(296.51,23.9) ; v2(301.55,59.92) 301.44,60.03 UZ2.4
  TOP w0.254: PU610.2 75.9,83.11 76.3,83.51 76.3,84 77.1,84.8 PC661.1 ; v2(182.03,23.88) 182.03,24.41 183.61,25.98 183.61,27.58 182.93,28.26 182.93,35.92 182.15,36.69 182.15,42.16 181.29,43.02 180.47,43.02 180.35,43.14 UZ26.3 ; v2(169.82,63.91) 169.23,64.5 169.23,65.13 168.76,65.59 v2(168.76,66.02) 168.69,65.95 167.8,65.95 UZ8.4
  TOP w0.381: CZ64.1 267.17,25.48 CZ69.1 ; v2(28.13,97.88) 27.87,98.15 27.87,99.66 28.88,100.68 PR7.1
  TOP w0.508: v2(267.18,26.13) CZ69.1 ; RI13.2 291.77,66.88 v2(292.34,66.31) ; v2(77.22,85.46) 77.32,85.36 77.32,85.34 77.4,85.26 PC661.1 ; LED3.2 314.06,110.25 306.39,102.58 289.63,102.58 v1(287.47,100.42) 287.47,92.68 289.35,90.8 289.35,88.5 287.81,86.96 286.49,86.96 285.37,85.85 285.37,82.71 ; v2(201.64,24.97) 201.64,25.99 203.19,27.54 v2(203.19,30.57) ; v2(59.08,68.4) 58.98,68.5 58.26,68.5 PR615.2 ; DT1.2 16.31,93.06 v2(16.77,93.52) ; v2(210.42,37.08) 210.42,44.63 197.64,57.41 v2(197.64,57.67) ; v2(56.8,65.86) 56.52,66.13 PR634.2 ; RA53.2 303.05,24.28 v2(303.28,24.5)
  IN1 w0.508: v2(11.15,77.64) 11.15,80.61 13.06,82.52 v2(13.06,83.08) ; v2(289.48,26.44) 289.48,27.03 291.42,28.97 291.42,29.91 294.11,32.6 294.11,33.74 294.57,34.19 294.57,40.6 297.23,43.26 297.23,46.3 297.83,46.9 300.85,46.9 301.05,46.7 302.23,46.7 302.56,47.03 302.56,48.21 302.26,48.51 302.26,54.93 304.41,57.08 304.41,58.12 304.05,58.47 304.05,59.61 303.43,60.24 301.87,60.24 v2(301.55,59.92) ; v2(70.51,76.27) 69.92,76.87 69.92,84.93 71.97,86.99 v2(72.79,86.99) 72.79,86.75 73.22,86.32 76.89,86.32 77.17,86.03 77.17,85.51 v2(77.22,85.46) ; v2(315.25,6.79) 314.99,6.79 314.97,6.81 314.48,6.81 314.46,6.79 313.54,6.79 308.42,11.91 303.61,11.91 302.08,13.43 301.39,13.43 300.4,14.42 299.66,14.42 298.26,15.82 298.26,19.51 297,20.77 297,23.4 296.51,23.88 v2(296.51,23.9) 296.53,23.9 296.96,24.33 298.44,24.33 299.16,23.61 300.81,23.61 301.7,24.5 v2(303.28,24.5)
  IN2 w0.508: v2(267.18,26.13) 267.84,26.78 273.54,26.78 274.08,26.24 277.15,26.24 277.68,26.78 279.33,26.78 280.2,27.65 282.56,27.65 283.65,28.75 287.03,28.75 287.65,28.12 287.65,28.05 289.26,26.44 v2(289.48,26.44) ; v2(202.27,35.11) 202.86,35.11 203.71,34.26 204.85,34.26 v2(204.94,34.35) 204.94,33.08 204.01,32.15 204.01,32.07 203.19,31.25 v2(203.19,30.57) ; v2(182.03,23.88) 182.16,23.75 183.51,23.75 185.44,25.69 185.65,25.69 185.65,25.68 186.14,25.68 186.14,25.69 192.38,25.69 192.8,25.27 201.34,25.27 v2(201.64,24.97) ; v2(11.15,77.64) 11.56,78.05 15.17,78.05 15.79,77.43 15.79,75.98 16.99,74.77 16.99,62.83 16.2,62.03 ; v2(294.58,63.1) 294.58,65.89 v2(294.91,66.22) ; v2(16.77,93.52) 16.74,93.52 16.11,92.89 16.11,91.53 13.47,88.9 13.47,83.5 v2(13.06,83.08)
  BOTTOM w0.254: PC685.1 72.99,86.79 v2(72.79,86.99) 72.6,87.17 PU614.6 ; v2(49.13,74.13) 49.55,74.56 PR602.2
  BOTTOM w0.305: JUSH1.18 266.65,26.66 v2(267.18,26.13)
  BOTTOM w0.508: v2(294.58,63.1) 295.56,63.1 297.33,61.32 298.34,61.32 298.45,61.44 300.42,61.44 301.55,60.3 v2(301.55,59.92) ; v2(210.42,37.08) 209.07,35.73 206.33,35.73 v2(204.94,34.35) ; v2(315.25,6.79) 314.69,7.35 JLED1.1 ; v2(62.26,69.84) 62.37,69.73 PC669.1 ; v2(296.51,23.9) 296.51,23.89 293.95,23.89 291.41,26.44 v2(289.48,26.44) ; JUART1.1 164.66,68.24 164.97,67.93 166.43,67.93 167.23,67.12 167.23,66.47 167.87,65.84 168.59,65.84 v2(168.76,66.02) ; v2(16.77,93.52) 16.87,93.62 26.85,93.62 27.69,94.46 27.69,97.44 v2(28.13,97.88)
  vias: v1(173.92,109.84) v2(13.6,58.6) v2(13.6,57.96) v2(14.24,58.6) v2(14.24,57.96) v2(14.87,58.6) v2(14.87,57.96) v2(15.52,58.57) v2(15.52,57.93) v2(20.4,48.1) v2(20.96,48.1) v2(21.53,48.1) v2(22.1,33.18) v2(22.16,48.1) v2(22.35,33.75) v2(22.74,33.11) v2(22.99,33.69) v2(26.8,29.62) v2(26.82,28.98) v2(26.79,28.38) v2(27.43,29.69) v2(36.9,61.18) v2(36.96,60.63) v2(36.96,60.04) v2(37.52,61.37) v2(37.85,60.86) v2(38.08,61.38) v2(38.42,60.86) v2(38.7,61.37) v2(38.99,60.86) v2(39.36,61.38) v2(39.63,60.86) v2(39.98,61.37) v2(132.16,105.67) v2(132.56,105.24) v2(151.7,109.99) v2(152.37,109.42) v2(173.63,115.98) v2(174.25,115.98) v2(179.29,110.09) v2(179.28,109.47) v2(188.94,106.85) v2(188.94,106.29) v2(257.92,82.15) v2(257.91,81.46) v2(257.92,80.88) v2(258.57,82.19) v2(258.58,81.5) v2(258.57,80.92) v2(259.31,81.53) v2(259.32,80.94) v2(259.98,81.57) v2(259.97,80.98) v2(283.78,82.2) v2(283.78,81.57) v2(283.78,80.99) v2(283.78,80.39) v2(283.78,79.82) v2(284.48,82.2) v2(284.48,81.57) v2(284.48,80.99) v2(284.48,80.42) v2(284.47,79.83) v2(290.6,72.69) v2(290.66,73.27) v2(291.23,73.26) v2(291.21,72.68) v2(291.84,72.68) v2(291.87,73.26) v2(295.54,66.22)
+5V_ALW2: length 0.7
  TOP w0.254: v1(32.32,47.4) 32.32,46.94 v2(32.13,46.74)
+5V_ALW_PDA: length 5.2
  TOP w0.254: v2(26.78,59.89) 27.26,59.42 UT5.H10
  BOTTOM w0.381: v2(26.78,59.89) 26.78,59.67 26.35,59.24 25.86,59.24 23.79,57.17 CT76.1
  vias: v1(25.34,55.34) v2(29.51,56.57) v2(29.94,57.65) v2(29.89,57.09) v2(30.07,56.55) v2(30.05,55.97) v2(30.53,57.63) v2(30.46,57.06)
+5V_ALWP: length 37.1
  IN2 w0.254: v2(29.97,46.77) 29.97,47.69 29.62,48.05 29.62,53.54 31.12,55.04 31.12,57.23 32.49,58.6 38.7,58.6 v2(39.04,58.26) ; v2(35.82,58.13) 32.65,58.13 31.47,56.96 31.47,48.69 32.73,47.43 v2(32.73,46.73)
  BOTTOM w0.254: v2(29.97,46.77) 30,46.79 PR117.2 ; v2(32.73,46.73) 33.01,46.44 PU102.14
  vias: v1(34.85,58.64) v2(38.11,55.77) v2(38.1,55.06) v2(38.11,54.11) v2(38.11,53.45) v2(38.15,57.65) v2(38.15,56.95)
+5V_PD_VDD: length 106.3
  IN2 w0.508: v2(32.79,17.72) 32.79,17.4 32.28,16.9 28.41,16.9 27.35,17.96 27.35,18.64 25.56,20.42 21.46,20.42 20.77,21.11 20.77,23.78 21.78,24.8 21.78,27.4 21.43,27.75 21.29,27.75 20.53,28.51 20.53,29.44 19.06,30.91 19.06,31.01 18.77,31.3 18.77,35.61 17.59,36.8 17.59,51.82 16.33,53.08 15.18,53.08 12.1,56.16 12.1,58.87 16.39,63.16 16.39,74.52 15.12,75.79 v2(15.12,77.22)
  BOTTOM w0.457: v2(15.12,77.22) 15.73,77.22 16.56,78.05 16.56,80.32 17.46,81.22 18.28,81.22 20.28,83.21 20.28,85.5 22.08,87.29 23.07,87.29 23.88,88.11 23.88,91.41 22.28,93.01 v1(21.4,93.01) 18.32,93.01 17.99,92.68 v2(17.99,92.39)
  BOTTOM w0.508: v2(32.79,17.72) 32.79,17.95 32.8,17.96 32.8,18.44 32.79,18.45 32.79,18.48 33.3,18.99 DT2.1
+5V_RUN: length 66.2
  TOP w0.356: CZ92.1 245.11,27.03 244.81,26.73 244.81,25.94 v2(245.07,25.67)
  TOP w0.508: RV6.2 98.94,111.27 99.2,111.54 v2(99.2,112.44) 98.75,112.9 98.3,112.9 QV8.3
  TOP w1.016: 191.01,76.93 191.01,81.37 v1(188.5,83.88) 181,91.39 179.29,91.39 177.21,93.47 177.21,94.53 176.6,95.14 176.6,99.04 176.62,99.31 176.62,100.34 173.64,103.31 172.73,103.31 171.83,104.22 171.64,104.43 168.69,107.38 167.99,107.38 165.14,110.23 160.31,110.23 157.74,112.81 157.74,113.82
  BOTTOM w0.305: v2(245.07,25.67) 245.07,25.93 245.35,26.2 JKBTP1.16
  BOTTOM w0.508: v2(98.27,116.3) 98.27,113.34 99.17,112.44 v2(99.2,112.44)
  vias: v2(19.48,75.56) v2(20.04,75.54) v2(157.55,115.54) v2(157.55,114.9) v2(189.86,76.77) v2(189.86,76.14) v2(264.35,26.12) v2(286.85,85.6) v2(286.85,85.01) v2(286.85,84.42) v2(286.85,83.84) v2(287.43,85.61) v2(287.43,85.05) v2(287.43,84.48) v2(287.43,83.9) v2(297.61,23.01) v2(297.59,22.37) v2(297.59,21.68) v2(297.62,21.05) v2(298.2,23.03) v2(298.2,22.35) v2(298.22,21.68) v2(298.2,21.05)
+5V_RUN_AUDIO: length 4.6
  TOP w0.508: LA5.2 304.5,23.79 v1(304.23,23.53) 303.41,22.7 301.5,22.7
  vias: v2(296.28,40.18) v2(296.67,39.66) v2(296.87,40.19) v2(298.77,19.91) v2(299.02,19.4) v2(299.13,18.78) v2(299.3,18.23)
+5V_RUN_AUDIO_UZ5: length 1.5
  TOP w0.102: 297.4,18.36 v3(297.4,16.81)
+5V_RUN_PVDD_L: length 7.4
  TOP w0.203: CA46.1 300.73,38.83 300.73,38.25 CA45.1 300.98,37.81 301.29,37.5 301.29,36.39 300.91,36.01 UA1.41 ; UA1.46 298.91,35.87 297.75,37.02 CA47.1
  vias: v2(299.6,40.16)
+5V_RUN_UZ4:
  vias: v1(288.74,81.31)
+5V_TBT_VBUS: length 0.7
  TOP w0.102: v2(34.42,21.04) v1(35.1,21.04)
+5V_TBTA_VBUS_D: length 1.7
  BOTTOM w0.102: UT8.3 v1(42.23,18.56)
+5V_TSP:
  vias: v1(95.63,117.19) v2(96.4,116.3) v2(97.03,116.3) v2(97.67,116.3)
+5V_USB_CHG_PWR:
  vias: v1(298.26,71.09) v2(297.63,70.07) v2(297.63,69.5) v2(298.26,70.07) v2(298.26,69.5) v2(298.83,70.07) v2(298.83,69.5) v2(304.78,59.91) v2(304.78,59.35) v2(304.8,58.77) v2(305.36,59.9) v2(305.39,59.34) v2(305.39,58.77)
+GND_CHASSIS: length 16.6
  TOP w0.102: v2(302.12,94.2) v3(301.49,94.2)
  TOP w0.508: RL18.2 RL17.2 304.1,89.46 RL16.2 RL15.2 304.07,92.26 v2(302.12,94.2)
  BOTTOM w0.508: v2(302.12,94.2) 302.12,95.9 CL22.2
+VBUS_DC_SS: length 23.9
  IN2 w0.508: v2(51.69,100.11) 52.11,100.11 52.76,100.76 56.88,100.76 57.15,101.02 62.02,101.02 62.48,101.49 66.69,101.49 v2(66.72,101.46)
  BOTTOM w0.102: v1(69.47,98.9) 69.09,99.28 68.18,99.28 67.87,99.6 67.87,99.84 66.88,100.83 PD903.2 66.38,100.49 v1(66.38,99.64) 66.59,99.43 66.59,98.82 66.21,98.44 65.06,98.44 v1(65.03,98.47)
  BOTTOM w0.508: v2(66.72,101.46) PD903.2
+VCC1V8A_TBTA_LDO: length 2.2
  TOP w0.203: CT73.1 24.89,65.17 UT5.K1
+VCC1V8D_TBTA_LDO: length 13.9
  TOP w0.203: CT72.1 31.78,63.58 v2(31.64,63.44) 31.63,63.44 31.49,63.31 UT5.A2
  TOP w0.508: v2(29.11,53.63) RT97.1
  IN3 w0.508: v2(29.11,53.63) 29.65,53.63 31.14,55.12 31.14,57.12 32.05,58.02 32.05,63.01 31.64,63.41 v2(31.64,63.44)
+VCC3V3_ANA_PCIE: length 1.5
  TOP w0.203: UT1.L16 v2(27.96,88.76)
  BOTTOM w0.254: CT63.1 27.4,89.32 v2(27.96,88.76)
+VCC3V3_ANA_USB2: length 1.1
  TOP w0.203: v2(27.96,88.11) 27.96,88.12 27.65,88.43 UT1.J16
  BOTTOM w0.254: CT64.1 27.82,88.25 v2(27.96,88.11)
+VCC_1P8: length 8.7
  TOP w0.102: RC313.2 144.67,76.8 142.33,76.8 142.23,76.91 142.23,77.15 141.98,77.4 v3(141.48,77.4) 139.6,77.4 139.36,77.64 CC222.1 139.36,78.9 v2(139.25,79.01)
  BOTTOM w0.076: UC1.U12 UC1.U11 139.53,79.3 v2(139.25,79.01)
+VCC_CORE: length 30.7
  TOP w0.381: PC1001.1 122.93,81.62 v2(122.93,81.15) ; v2(121.57,81.14) 121.57,81.47 PC1076.1 ; v2(121.51,76.31) 121.51,76.07 PC1004.1 ; v2(124.17,81.15) 124.17,81.63 PC1075.1 ; PC1066.1 125.44,81.64 v2(125.44,81.18)
  TOP w0.508: PC1006.1 125.23,75.97 v2(125.23,76.31) ; PC1071.1 122.75,76.03 v2(122.75,76.31) ; v2(125.37,78.8) 125.37,79.24 PC1070.1 ; PC1068.1 122.82,79.11 v2(122.82,78.81) ; v2(123.99,76.31) 123.99,76.01 PC1013.1 ; v2(124.09,78.81) 124.09,79.18 PC1069.1
  IN3 w0.305: v2(123.21,73.62) 123.67,73.15 124.58,73.15 v2(125.07,73.64) 125.58,73.13 126.34,73.13 v2(126.86,73.66)
  BOTTOM w0.127: 124.87,73.29 UC1.AK37 124.57,72.99 ; 122.59,84.13 UC1.J40 122.28,84.43 ; 126.86,72.35 126.87,72.35 UC1.AM32 127.31,72.66 ; UC1.K40 122.43,83.66 ; 125.33,72.83 UC1.AL37 125.02,73.13 ; 122.13,83.66 UC1.K42 121.82,83.97 ; 122.74,73.6 UC1.AK40 123.05,73.29 ; UC1.AK33 126.7,73.29 ; 124.11,84.43 UC1.J37 123.8,84.13 ; 127.77,84.43 UC1.J30 ; UC1.J30 127.77,83.82 ; UC1.J30 127.46,84.13 ; UC1.AL33 127.16,72.83 ; UC1.AL40 123.5,72.83 ; UC1.K38 123.96,83.66 ; UC1.AK38 123.35,73.29 ; 126.24,84.13 UC1.J33 125.94,84.43 ; UC1.K35 125.79,83.66 ; UC1.AK35 125.18,73.29 ; UC1.K33 126.09,83.66 ; UC1.K37 124.26,83.66
  BOTTOM w0.203: UC1.A44 v2(120.36,89.12) ; v2(122.97,89.23) 122.97,88.42 UC1.A39 ; UC1.A30 v2(127.8,88.83) ; UC1.A34 125.32,88.77 v2(125.44,88.9)
  BOTTOM w0.254: UC1.G37 124.31,84.84 v2(124.11,84.84) 123.9,84.84 UC1.G38 ; UC1.G33 126.14,84.84 v2(125.94,84.84) 125.73,84.84 UC1.G35 ; UC1.G42 122.06,84.83 v2(122.28,84.83) 122.5,84.83 UC1.G40
  BOTTOM w0.508: RC140.2 128.05,89.07 v2(127.8,88.83)
  vias: v1(105.98,97.76) v2(82.36,83.53) v2(82.87,84.04) v2(83.44,84.42) v2(83.44,83.72) v2(84.13,84.08) v2(84.14,83.47) v2(84.14,82.86) v2(84.2,82.07) v2(84.32,81.3) v2(84.25,80.24) v2(85.12,83.6) v2(85.17,80.49) v2(86.16,80.51) v2(86.29,83.62) v2(87.05,80.52) v2(87.53,83.62) v2(88.01,80.52) v2(88.7,83.62) v2(89.54,81.88) v2(89.82,83.53) v2(89.92,85.17) v2(89.92,84.3) v2(90.13,88.36) v2(90.15,87.23) v2(90.18,89.13) v2(90.43,83.85) v2(90.49,84.65) v2(90.62,83.09) v2(90.58,81.6) v2(90.9,87.64) v2(90.91,86.77) v2(91.06,83.8) v2(91.3,88.36) v2(91.54,86.26) v2(91.92,82.98) v2(91.89,81.59) v2(92.33,85.78) v2(92.97,84.88) v2(93.16,81.63) v2(93.56,84.02) v2(94.43,81.63) v2(94.48,83.91) v2(120.34,81.11) v2(120.39,78.77) v2(120.37,76.31) v2(121.07,82.96) v2(121.48,82.45) v2(121.59,78.79) v2(121.67,74.96) v2(121.8,82.93) v2(122.28,83.44) v2(122.3,82.45) v2(122.43,74.96) v2(122.62,74.33) v2(122.68,82.96) v2(123.19,82.52) v2(123.7,82.96) v2(124.11,83.44) v2(124.14,82.52) v2(124.11,71.96) v2(124.53,82.96) v2(124.57,74.24) v2(124.91,82.54) v2(125.02,71.96) v2(125.41,82.9) v2(125.94,83.44) v2(125.86,82.54) v2(125.95,71.99) v2(126.37,82.99) v2(126.43,82.41) v2(126.42,80.22) v2(126.39,79.47) v2(126.35,77.77) v2(126.39,77.07) v2(126.42,76.09) v2(126.39,74.24) v2(127.79,83.45)
+VCC_CORE_G0: length 1.4
  TOP w0.254: T122.1 127.21,82.94 v2(127.16,82.89)
  BOTTOM w0.254: UC1.K32 127.31,83.04 v2(127.16,82.89)
+VCC_CORE_G1: length 1.4
  TOP w0.254: v2(127.23,74.13) 127.07,74.29 T123.1
  BOTTOM w0.203: v2(127.23,74.13) 127.31,74.05 UC1.AK32
+VCC_EDRAM: length 3
  TOP w0.102: CC292.1 110.37,76.73 v1(110.37,75.52)
  BOTTOM w0.254: v2(111,79.01) 110.75,79.27 UC1.V62 ; UC1.P62 110.82,81.1 v2(111.05,80.87) ; UC1.AB62 v2(111.08,77.44)
  vias: v2(59.49,61.73) v2(59.82,61.24) v2(60.1,61.75) v2(60.45,61.26) v2(111.06,79.66) v2(111.38,78.35)
+VCC_EDRAM_P: length 12.3
  IN2 w0.508: v2(51.98,57.32) 51.98,57.07 52.85,56.2 58.85,56.2 59.57,56.91 59.57,59.4 v2(59.17,59.8)
  BOTTOM w0.102: v3(59.73,60.23) 59.6,60.23 v2(59.17,59.8)
+VCC_EOPIO: length 2
  TOP w0.102: v1(110.59,73.79) 110.59,74.07 v2(110.98,74.46)
  BOTTOM w0.254: UC1.AE62 110.56,75.42 v2(110.91,75.06) 110.56,74.71 UC1.AG62
  vias: v2(55.59,54.11) v2(56.21,54.11) v2(56.83,54.11) v2(57.41,54.12) v2(111.04,75.83) v2(111.55,74.3)
+VCC_EOPIO_P: length 13.1
  TOP w0.102: v2(50.7,45.52) v3(50.7,44.7)
  IN2 w0.254: v2(57.71,51.57) 52.01,51.57 50.7,50.26 v2(50.7,45.52)
+VCC_GT: length 71.1
  TOP w0.508: PC1132.1 101.73,78.73 101.78,78.78 ; v2(116.86,78.05) 116.86,77.6 PC1024.1 ; 101.8,79.62 PC1135.1 ; PC1129.1 104.86,77.79 v2(105.21,77.44) ; v2(103.31,79.62) PC1138.1 ; v2(103.17,82.7) 104.03,82.7 ; v2(103.36,78.85) PC1131.1 ; PC1021.1 116.27,80.74 v2(116.27,80.42) ; v2(118.1,78.04) 118.1,77.64 PC1134.1 ; PC1022.1 104.88,79.6 v2(105.21,79.27) ; PC1020.1 117.52,80.78 v2(117.52,80.41) ; PC1025.1 v2(89.22,77.1)
  BOTTOM w0.127: UC1.W64 109.74,78.81 ; 119.53,83.8 119.54,83.8 UC1.J45 119.84,84.13 ; UC1.AL60 112.53,72.83 ; UC1.AL60 112.22,73.13 ; UC1.AL60 111.92,72.83 ; UC1.AL60 112.22,72.52 ; 120.45,83.81 UC1.J43 120.15,84.13 ; 116.79,83.83 UC1.J50 117.1,84.13 ; UC1.R67 107.79,80.64 ; 110.39,82.47 UC1.L63 110.09,82.71 ; 105.19,79.72 UC1.U71 104.89,80.03 ; 109.44,80.33 UC1.R64 109.74,80.64 ; 105.84,80.64 UC1.R70 105.54,80.33 ; 104.89,80.33 UC1.R71 105.19,80.64 ; UC1.AK50 117.56,73.29 ; UC1.AK50 117.25,72.99 ; UC1.AK50 117.25,73.6 ; 118.62,83.82 UC1.J46 118.93,84.13 ; 119.08,72.99 UC1.AK46 ; UC1.AK46 119.08,73.6 ; UC1.AK46 119.39,73.29 ; UC1.AL56 114.36,72.83 ; UC1.AL56 113.75,72.83 ; UC1.AL56 114.05,73.13 ; UC1.K50 117.25,83.97 ; 107.14,80.64 UC1.R68 106.84,80.33 ; UC1.K55 114.51,83.97 ; UC1.AK45 119.69,73.29 ; UC1.AK45 119.99,73.6 ; UC1.AK45 119.99,72.99 ; 110.09,78.23 UC1.AA63 ; UC1.AA63 110.09,77.58 ; UC1.AA63 110.39,77.9 ; 105.84,76.98 UC1.AC70 105.54,77.29 ; 105.19,77.9 UC1.AA71 104.89,78.2 ; 118.17,73.6 UC1.AK48 ; UC1.AK48 117.86,73.29 ; UC1.AK48 118.17,72.99 ; 114.36,84.13 UC1.J55 114.05,83.82 ; 108.64,77.27 108.79,77.13 UC1.AC65 UC1.AC66 ; 110.39,78.81 UC1.W63 110.09,78.55 ; 114.96,83.82 UC1.J53 115.27,84.13 ; 105.19,81.55 UC1.N71 104.89,81.86 ; 120.91,72.99 UC1.AK43 ; UC1.AK43 120.91,73.6 ; UC1.AK43 121.21,73.29 ; 115.42,73.6 UC1.AK53 ; UC1.AK53 115.42,72.99 ; UC1.AK53 115.73,73.29 ; UC1.W67 107.79,78.81 ; UC1.AA69 106.49,77.9 ; UC1.AK58 112.37,73.29 ; UC1.AK58 112.68,72.99 ; UC1.AK58 112.68,73.6 ; UC1.U68 107.14,79.72 ; UC1.AK60 112.07,73.29 ; UC1.AK60 111.76,72.99 ; UC1.AK60 111.76,73.6 ; UC1.AC69 106.49,76.98 ; 110.09,80.96 UC1.R63 ; 110.09,81.86 UC1.N63 ; UC1.N63 110.09,81.23 ; UC1.N63 110.39,81.55 ; 119.23,72.83 UC1.AL46 ; UC1.AL46 119.84,72.83 ; UC1.AL46 119.54,73.13 ; UC1.AA66 108.44,77.9 ; 110.56,78.03 UC1.Y62 ; UC1.Y62 110.86,78.35 ; UC1.Y62 110.56,78.69 ; UC1.W66 108.44,78.81 ; UC1.K52 116.34,83.97 ; UC1.AK52 116.34,73.6 ; UC1.AK52 116.34,72.99 ; UC1.AK52 116.03,73.29 ; 114.51,72.99 UC1.AK55 ; UC1.AK55 114.2,73.29 ; UC1.AK55 114.51,73.6 ; 105.19,78.81 UC1.W71 ; UC1.AL43 121.67,72.83 ; UC1.AL43 121.37,73.13 ; UC1.AL43 121.06,72.83 ; 110.56,81.67 UC1.M62 ; UC1.M62 110.86,82.01 ; UC1.M62 110.56,82.29 ; 111.61,84.13 UC1.J60 111.31,83.82 ; 106.84,76.68 UC1.AC68 107.14,76.98 ; 109.09,80.64 UC1.R65 108.79,80.33 ; UC1.L64 109.74,82.47 ; 115.88,83.82 UC1.J52 116.18,84.13 ; UC1.W69 106.49,78.81 ; 110.25,82.92 UC1.L62 ; UC1.L62 110.86,82.92 ; UC1.L62 110.56,82.6 ; 115.88,72.52 UC1.AL53 ; UC1.AL53 115.57,72.83 ; UC1.AL53 116.18,72.83 ; UC1.AL53 115.88,73.13 ; UC1.N64 109.74,81.55 ; 121.82,72.99 UC1.AK42 ; UC1.AK42 121.82,73.6 ; UC1.AK42 121.52,73.29 ; UC1.K53 115.42,83.97 ; 105.19,82.47 UC1.L71 104.89,82.16 ; UC1.R69 106.49,80.64 ; UC1.J58 112.53,84.13 ; 110.9,80.18 UC1.T62 ; UC1.T62 110.56,79.82 ; UC1.T62 110.56,80.53 ; UC1.N69 106.49,81.55 ; 113.59,72.99 UC1.AK56 ; UC1.AK56 113.9,73.29 ; UC1.AK56 113.59,73.6 ; UC1.R66 108.44,80.64 ; UC1.W68 107.14,78.81 ; UC1.K60 111.76,83.97 ; UC1.W65 109.09,78.81 ; UC1.W70 105.84,78.81 ; UC1.J56 113.44,84.13 ; UC1.N70 105.84,81.55 ; UC1.L70 105.84,82.47 ; UC1.K48 118.17,83.97 ; UC1.AA67 107.79,77.9 ; 118.01,84.13 UC1.J48 117.71,83.83 ; UC1.AC67 107.79,76.98 ; UC1.L69 106.49,82.47 ; 118.01,72.83 UC1.AL50 ; UC1.AL50 117.71,73.13 ; UC1.AL50 117.71,72.52 ; UC1.AL50 117.4,72.83 ; UC1.K58 112.68,83.97 ; UC1.U65 109.09,79.72 ; UC1.AA70 105.84,77.9 ; UC1.K56 113.59,83.97 ; 109.59,77.31 109.44,77.16 UC1.AC64 109.62,76.98 109.77,77.13 ; UC1.AA64 109.74,77.9
  BOTTOM w0.152: UC1.BB57 v2(112.96,64.69)
  BOTTOM w0.178: v2(104.19,73.51) 104.23,73.47 UC1.AK70
  BOTTOM w0.203: v2(117.94,89.23) 117.89,89.18 UC1.A48 ; UC1.A58 v2(112.93,89.3) ; UC1.A62 v2(110.45,89.3) ; UC1.BB66 107.98,65.41 v2(107.74,65.17) ; UC1.A53 115.41,88.67 115.04,89.04 115.04,89.48 115.38,89.82 v2(115.38,89.88) ; UC1.A66 107.97,89.27 v2(107.87,89.38)
  BOTTOM w0.254: v2(109.48,69.41) 109.79,69.1 UC1.AU63 ; UC1.AU58 112.56,69.1 v2(112.25,69.41) ; UC1.AC71 104.89,77.11 v2(105.21,77.44)
  vias: v1(88.19,67.94) v2(80.14,75.98) v2(80.14,70.83) v2(80.39,71.47) v2(80.52,76.61) v2(80.84,75.98) v2(80.84,70.83) v2(81.16,71.47) v2(81.28,76.61) v2(81.6,70.83) v2(81.66,75.98) v2(82.04,76.61) v2(81.98,74.52) v2(81.98,73.69) v2(81.98,72.61) v2(81.98,71.47) v2(82.25,75.13) v2(82.36,75.72) v2(82.36,73.18) v2(82.43,72.04) v2(82.36,70.83) v2(82.49,74.07) v2(82.68,76.36) v2(83.11,75.71) v2(83.12,74.07) v2(83.36,71.38) v2(83.5,76.36) v2(84.42,77.11) v2(84.39,74.02) v2(84.58,71.37) v2(85.63,77.11) v2(85.6,74.02) v2(85.8,71.38) v2(86.84,77.11) v2(86.81,74.02) v2(87.02,71.38) v2(87.97,77.1) v2(88.01,74.06) v2(88.05,78.43) v2(88.29,71.32) v2(89.22,74.02) v2(89.32,78.75) v2(90.17,78.77) v2(90.87,74.9) v2(91.63,75.47) v2(91.89,79.6) v2(92.27,78.83) v2(92.52,79.6) v2(93.6,78.83) v2(96.27,78.45) v2(96.59,81.69) v2(96.84,78.45) v2(97.22,81.69) v2(97.47,78.45) v2(97.86,81.69) v2(98.17,78.45) v2(98.55,81.69) v2(98.81,78.45) v2(99.25,81.69) v2(99.57,78.45) v2(100.27,78.45) v2(100.9,81.76) v2(100.9,78.45) v2(105.86,82.01) v2(105.92,80.18) v2(105.86,78.35) v2(106.51,81.1) v2(106.51,77.44) v2(107.16,82.01) v2(107.23,80.18) v2(107.16,79.27) v2(107.16,78.35) v2(107.81,81.1) v2(107.81,77.44) v2(108.4,80.17) v2(108.46,82.01) v2(108.46,78.35) v2(109.11,79.27) v2(109.2,78.37) v2(109.77,82.02) v2(109.83,80.18) v2(110.93,82.44) v2(111.32,83.41) v2(111.32,82) v2(111.78,82.79) v2(112.22,83.44) v2(112.19,71.95) v2(112.69,82.79) v2(112.85,74.1) v2(113.14,83.44) v2(113.14,71.97) v2(113.62,82.79) v2(113.59,73.99) v2(114.07,83.41) v2(114.05,73.52) v2(114.39,80.37) v2(114.44,75.63) v2(114.51,73.96) v2(114.58,82.81) v2(114.99,83.42) v2(115.01,80.36) v2(115.42,73.97) v2(115.46,82.81) v2(115.63,78.03) v2(115.68,75.63) v2(115.92,83.42) v2(115.87,73.56) v2(115.87,71.98) v2(116.32,73.96) v2(116.41,82.81) v2(116.81,83.45) v2(116.78,71.96) v2(117.24,73.97) v2(117.29,82.86) v2(117.72,83.4) v2(117.71,73.53) v2(118.08,73.97) v2(118.18,82.86) v2(118.62,83.37) v2(119.07,73.97) v2(119.18,83.15) v2(119.55,73.54) v2(119.99,74) v2(120.89,74) v2(121.39,73.52)
+VCC_SA: length 0.8
  TOP w0.254: RC168.1 131.47,84.89 v2(131.46,84.91)
  BOTTOM w0.508: 131.64,82.83 131.62,82.82
  vias: v1(85.21,87.47) v2(83.99,89.63) v2(84.33,86.14) v2(84.84,89.62) v2(84.95,85.87) v2(85.63,89.66) v2(85.66,86.14) v2(86.39,85.92) v2(86.73,89.24) v2(86.72,88.45) v2(86.72,87.61) v2(86.72,86.79) v2(87.31,89.19) v2(87.44,86.8) v2(88.31,86.76) v2(129.5,83.1) v2(130.18,82.84) v2(131,82.96) v2(130.99,74.28) v2(131.06,80.91) v2(131.1,79.98) v2(131.6,74.28)
+VCC_SFR_OC: length 78.1
  TOP w0.254: v2(132.96,63.48) 132.59,63.11 132.59,58.59 132.15,58.14 132.15,55.61 CC322.1
  TOP w0.381: UZ26.6 178.44,46.23 RZ119.2 177.8,46.11 CZ103.1 177.57,46.61 177.1,47.09 176.24,47.09 175.66,46.5 v1(174.64,46.5) 164.61,46.5 163.07,48.04 137.16,48.04 133.07,52.13 133.07,54.69 CC322.1
  TOP w0.508: v2(132.34,73.52) 132.31,73.54 CC288.1
  IN1 w0.254: v2(132.34,73.52) 131.03,73.52 130.05,72.54 130.05,68.4 129.66,68 129.66,65.61 131.79,63.48 v2(132.96,63.48)
  BOTTOM w0.254: UC1.AL23 v2(132.34,73.52)
+VDDA_AVDD1: length 7.5
  TOP w0.127: LA5.1 305.03,25.79 v3(305.42,25.4)
  TOP w0.203: UA1.26 303.74,30.62 304.73,29.63
  TOP w0.508: 305.41,27.74 CA9.1 LA5.1 ; 305.41,27.74 305.23,27.74 304.73,28.25 304.73,29.63 ; 305.41,27.74 CA8.1
GND: length 3574.6
  TOP w0.076: UT1.T1 UT1.T2 30.77,82.05 v2(30.55,82.27)
  TOP w0.127: UT1.AB6 33.34,83.72 33.15,83.53 ; v1(122.34,35.19) 122.23,35.07 CD21.2 ; v2(281.25,55.81) 281.25,56.39 v1(281.48,56.62) ; CC205.2 134.54,75.29 134.94,75.69 135.85,75.69 CC324.2 ; UT1.A22 UT1.B22
  TOP w0.152: UT1.U22 UT1.U23 ; UT1.AB16 33.53,88.32 UT1.AC16 ; UT1.G23 UT1.G22 ; UT1.N22 UT1.N23 ; UT1.A6 UT1.B6 ; UT1.M1 UT1.M2 ; UT1.Y13 32.83,87.05 33.4,86.48 UT1.AB12 UT1.AC12 ; UT1.A18 UT1.B18 ; UT1.AC10 UT1.AB10 33.21,85.56 UT1.Y9 ; UT1.A8 UT1.B8 ; UT1.P1 UT1.P2 ; UT1.B14 UT1.A14 ; UT1.L22 UT1.L23 ; 33.07,84.78 33.21,84.64 UT1.AB8 33.53,84.64 33.99,84.64 UT1.AC8 ; UT1.W23 UT1.W22 ; UT1.AC18 UT1.AB18 ; UT1.K2 UT1.K1 ; UT1.H1 UT1.H2 ; UT1.C23 UT1.C22 UT1.B22 ; UT1.E23 UT1.E22 25.71,90.97 ; UT1.AC1 UT1.AB1 UT1.AB2 UT1.AC2 ; UT1.R23 UT1.R22 ; 33.12,87.39 33.13,87.4 UT1.AB14 UT1.AC14 ; UT1.B16 UT1.A16 ; UT1.A20 UT1.B20 ; UT1.AC6 UT1.AB6 ; UT1.J23 UT1.J22 ; UT1.AA22 UT1.AA23 ; UT1.A12 UT1.B12 ; UT1.AC22 UT1.AB22 ; UT1.AB20 UT1.AC20
  TOP w0.203: v2(28.84,59.85) 28.76,59.93 UT5.E8 ; v2(26.79,62.24) 26.83,62.24 UT5.H5 ; UT5.G8 UT5.H8 27.08,60.48 v2(26.79,60.48) ; UT5.G8 UT5.F8 ; UT5.G8 UT5.G7 ; UT5.G8 27.76,59.93 v2(27.68,59.85) ; UT5.G6 UT5.G7 ; UT5.G6 UT5.F6 ; UT5.G6 UT5.G5 ; UT5.G7 UT5.F7 ; UT5.F7 UT5.F8 ; UT5.F7 UT5.F6 ; UT5.F7 UT5.E7 ; UT5.F8 UT5.E8 ; UT5.F8 v2(28.26,59.85) ; UT5.E6 UT5.F6 ; UT5.E6 UT5.E7 ; UT5.E6 UT5.E5 ; UT5.F6 UT5.F5 ; UT5.L1 25.61,63.81 25.16,64.26 v2(25.14,64.26) ; v2(31.24,61.44) 31.12,61.31 UT5.A6 ; v2(198.58,35.15) 198.64,35.09 UZ3.11 ; v2(301.21,38.52) 301.56,38.17 CA45.2 ; UZ5.11 v2(295.45,21.85) ; UT5.E5 29.22,62.27 29.22,62.59 v2(29.43,62.79) ; UT5.E5 UT5.F5 ; UT5.E7 UT5.E8 ; v2(27.09,62.79) 27.26,62.63 UT5.H4 UT5.G5 ; UT5.B8 30.09,60.48 v2(29.73,60.48) 29.43,60.48 UT5.D8 UT5.E8 ; v2(31.26,63.89) 31.18,63.81 UT5.A1 ; 20.65,95.42 20.65,96.57 20.64,96.58 ; UT5.G5 UT5.F5 ; UZ4.11 v2(289.36,78.51) ; UT5.B7 UT5.A7 31.06,60.81 v2(31.27,60.6) 30.98,60.31 UT5.A8 ; UT1.B10 UT1.A10
  TOP w0.254: UE1.A6 262.02,40.39 ; JUSBC1.A12 8.02,87.1 8.27,86.85 v2(8.27,86.14) ; CC30.2 66.36,99.13 v2(66.18,98.95) ; v2(136.91,72.58) 136.97,72.58 137.38,72.17 CC214.2 ; PD2.1 v2(213.49,25.99) ; v2(59.5,93.95) 59.72,94.18 61.29,94.18 PR948.2 ; DT5.2 11.19,93.04 v2(11.08,93.14) ; DT5.2 v2(11.71,93.57) ; DT5.2 12.16,93.04 12.38,93.25 v2(12.38,93.5) ; v2(25.02,94.65) 24.9,94.76 24.9,96.88 v2(25.15,97.12) 25.15,97.5 24.97,97.68 20.79,97.68 20.64,97.54 20.64,96.58 ; UC8.7 63.37,101.16 v2(63.62,100.91) ; CL3.2 276.63,88.64 276.81,88.47 276.81,87.97 276.81,87.97 v2(276.81,87.53) ; RPE10.8 278.19,49.85 v2(278.42,49.62) 278.16,49.35 RPE10.7 ; v2(45.36,92.49) 45.5,92.64 46.53,92.64 46.61,92.55 46.62,92.55 47.06,92.1 PQ1207.1 47.06,91.81 45.76,90.51 PQ1207.4 ; v2(77.4,79.98) 77.57,79.8 PC645.2 ; v2(45.26,62.29) 45.35,62.38 PR1310.2 ; v2(107.14,81.15) 107.14,80.99 106.65,80.5 PC1044.2 ; v2(262.19,46.86) 262.19,46.62 UE1.A13 ; v2(131.42,71.31) 131.88,71.77 131.88,72.45 RC167.2 ; DT10.2 12.13,85.56 12.26,85.43 v2(12.26,85.06) ; DT10.2 v2(11.64,85.03) ; DT10.2 11.19,85.56 10.99,85.36 v2(10.99,85.06) ; v2(307.95,39.03) 308.21,39.29 CR17.1 ; DT6.2 11.25,91.46 v2(11.12,91.33) ; DT6.2 12.23,91.46 v2(12.33,91.36) ; DT6.2 v2(11.71,90.93) 11.83,90.81 DT7.2 ; v2(109.12,81.15) 108.73,80.75 PC1048.2 108.14,80.75 107.94,80.55 PC1055.2 ; UE1.E6 v2(265.22,40.39) ; v2(258.74,37.99) 258.6,38.13 RE93.2 ; CI19.2 294.92,72.33 v2(295.02,72.43) ; v2(26.49,68.24) 26.62,68.12 RT96.2 26.62,66.63 CT83.2 ; PQ1201.1 37.18,97.38 38.48,96.08 PQ1201.4 39.38,96.08 PR1222.2 ; PU610.3 75.5,83.28 75.64,83.42 v2(75.64,83.88) ; DT9.2 12.1,87.13 v2(12.23,87.26) ; DT9.2 11.12,87.13 v2(11.02,87.23) ; DT9.2 v2(11.64,87.66) ; RA37.2 297.89,23.64 v2(297.66,23.64) ; CV16.2 69.74,116.22 69.55,116.41 CV12.2 ; v2(40.62,105.2) 40.44,105.38 PQ1.1 39.7,105.38 38.4,106.68 PQ1.4 ; CC24.2 139.6,57.89 139.6,57.33 v2(139.45,57.18) 140.45,57.18 CC270.2 140.67,56.97 140.67,56.78 CC266.2 142.12,56.1 142.65,56.64 v2(142.65,57.4) 142.6,57.45 142.6,57.96 CC25.2 ; 20.65,95.42 20.66,95.41 20.66,94.25 20.47,94.07 CT21.2 20.47,93.54 ; PU1302.6 48.98,49.84 v2(49.19,50.04) ; RI14.1 294.89,71.52 v2(294.89,70.95) UI3.14 ; v2(268.42,38.79) UE1.H4 ; PR662.2 v2(78.54,77.73) ; v2(45.86,63.48) 45.92,63.48 46.13,63.69 47.6,63.69 PC619.1 PC618.1 ; v2(41.73,91.53) 41.53,91.33 41.53,90.09 41.21,89.77 PQ1208.4 ; CA55.2 295.53,30.32 295.23,30.62 294.33,30.62 294.07,30.36 294.07,30.3 ; CL17.2 v2(291.52,83.79) ; v2(56.99,111.72) 56.99,110.31 CA7.2 ; v2(68,116.35) 67.83,116.52 RV2.2 ; PQ1208.1 43.05,88.28 v2(42.65,87.88) ; PC605.1 51.82,66.24 51.36,65.78 51.36,64.84 v2(51.2,64.67) ; v2(13.93,90.72) 13.87,90.66 DT11.2 ; CL14.2 280.08,87.43 279.37,88.14 279.37,88.42 279.12,88.67 279.12,88.68 278.96,88.84 278.96,89.58 278.72,89.81 278.14,89.81 v2(277.69,90.26) ; v2(291.39,90.14) 291.4,90.13 CL20.2 ; v2(50.01,75.15) 49.63,75.53 PC1204.2 ; v2(14.63,88.31) DT8.2 ; v2(18.87,94.26) 18.35,94.26 CT88.2 ; PC621.1 46.45,64.23 v2(45.85,64.83) ; CL21.2 v2(291.53,91.41) ; v2(303.17,64.8) 303.02,64.8 CZ111.2 ; CL16.2 v2(291.51,82.52) ; CC290.2 110.27,80.53 v2(109.7,81.1) ; CL13.2 277.38,86.91 277.18,86.71 276.8,86.71 276.62,86.53 276.62,85.45 v2(276.42,85.25) 276.42,83.15 276.74,82.84 279.72,82.84 v2(279.78,82.9) 280.52,82.9 280.86,83.24 280.86,86.92 v2(280.67,87.12) ; UZ2.11 v2(301.44,61.74) ; v2(14.12,88.08) 13.87,88.33 DT12.2 ; v2(273.57,55.34) 273.57,55.43 273.83,55.69 UE2.17 ; PC1150.2 PC1149.2 ; CZ121.2 168.81,69.21 168.51,68.9 168.09,68.9 167.61,68.43 UZ8.5 ; RPE10.6 278.17,48.85 v2(278.42,48.61) 278.17,48.35 RPE10.5 ; CD60.2 190.15,32.38 189.89,32.12 CD59.2 189.38,31.64 v2(189.1,31.93) ; PC601.2 54,78.3 v2(52.68,78.3) ; PD1.1 v2(209.76,25.99) ; UE1.C4 v2(263.62,38.79)
  TOP w0.305: CE31.2 270.16,33.07 v2(270.12,33.04) 270.29,32.88 RE342.2 ; RE95.2 277.62,42.93 CE60.2 ; v2(111.51,34.46) 110.93,34.46 110.33,33.86 CD27.2 109.98,32.85 CD28.2 ; v2(25.27,92.83) 24.94,93.15 24.94,93.57 CT20.2 ; v2(115.23,81.86) 115.22,81.86 PC1056.2 ; PC1040.2 107.7,78.02 v2(107.14,77.46) 107.19,77.41 PC1041.2 ; CA61.2 294.01,36.29 294.69,35.6 CA10.2 ; CL3.2 v2(276.63,89.35) ; CC325.2 146.5,95.52 CC314.2 ; 105.86,76.61 PC1043.2 ; v2(105.86,79.27) 106.02,79.11 PC1047.2 ; RD21.2 189.49,27.14 v2(189.91,26.72) ; CA47.2 298.35,38.13 298.71,38.49 298.71,38.9 299.04,39.24 v2(299.26,39.24) ; JUSBC1.A1 8.09,92.88 v2(8.09,93.1) ; CL15.2 v2(296.97,86.18) ; CE8.2 282.65,45.19 282.65,44.79 v2(282.83,44.61)
  TOP w0.356: v2(135.12,81.92) 135.12,82.02 134.41,82.74 134.41,83.27 RC166.2 ; CZ120.2 165.33,67.79 165.58,67.54 v2(165.58,67.29) ; CC209.2 135.27,78.23 135.27,78.41 v2(135.11,78.57) ; PC1051.2 124.86,84.18 PC1084.2 124.85,84.64 v2(125.07,84.85) ; v2(126.85,83.44) 127.23,83.81 PC1033.2 ; v2(141,75.89) 141.25,75.63 141.25,75.42 CC223.2 ; v2(124.23,73.64) 123.95,73.64 123.32,73.01 CC297.2 ; PC1083.2 123.06,84.71 v2(123.19,84.84) ; v2(132.28,83.27) 132.28,82.96 131.65,82.33 CC202.2 131.75,82.19 PC1147.2 ; PC1149.2 v2(130.98,82.3) ; v2(109.74,82.95) 109.8,82.89 PC1046.2 ; PC1036.2 128.43,84.65 v2(128.68,84.91) ; PC1042.2 114.62,84.34 114.11,84.84 v2(114.05,84.84) ; PC1049.2 112.18,84.14 RC114.2 112.12,84.74 v2(112.22,84.84) ; CZ91.2 245.86,25.75 v2(245.8,25.69) ; CR6.2 296.04,47.61 v2(296.43,47.21) 296.64,47.42 CR3.2 ; v2(146.87,74.93) 146.42,74.48 CC204.2 ; v2(272.11,29.03) 271.91,29.23 CZ68.2 271.78,29.47 CZ73.2 ; PC1087.2 v2(123.76,74.19)
  TOP w0.381: PC1001.2 123.55,80.84 v2(123.55,81.12) ; v2(276.81,87.53) 277.22,87.12 CL13.2 ; PU1201.4 40.69,67.95 PR1219.2 40.53,66.95 PC1206.2 ; CC297.2 123.27,73.02 PC1054.2 122.43,73.02 PC1053.2 ; v2(179.88,50.2) 178.81,49.14 v1(178.81,48.49) 178.81,47.25 179.17,46.89 180.53,46.89 181,46.42 UZ26.5 ; 117.06,72.76 117.06,73.3 v2(116.79,73.57) ; v2(189.59,47.72) 189.06,48.25 UZ34.3 ; CL14.2 v2(280.67,87.12) ; v2(272.84,51.97) 272.52,51.64 CE25.2 ; v2(144.05,72.33) 143.51,71.79 RC338.2 ; CE52.2 259.63,50.79 v2(259.06,51.36) 259.94,51.36 260.37,51.79 UE3.3 ; 39.69,93.05 40.01,92.73 PQ1210.1 ; 39.69,93.05 39.69,93.65 v2(39.5,93.84) 39.32,94.03 PQ1210.4 ; 39.69,93.05 39.34,92.69 39.34,92.13 38.96,91.75 PC1217.2 ; CZ66.2 264.68,24.54 CZ72.2 ; CC215.2 138.08,74.24 138.08,73.89 v2(137.74,73.55) ; RE537.1 238.24,41.59 238.9,40.93 239.69,40.93 239.86,41.1 v2(240.35,41.1) ; CC325.2 146.67,95.31 146.13,94.77 v2(146.13,94.61) ; CE40.2 269.22,50.62 v2(269.3,50.7) ; v2(94.46,115.99) 94.4,116.06 CV83.2 ; v2(283.52,38.51) 283.28,38.27 CZ30.2 283.69,37.59 CZ36.2 ; CL30.2 281.08,94.74 v2(281.31,94.96) ; CC176.2 128.62,58.85 129.21,58.25 v2(129.51,58.25) ; UE6.3 278.75,31.45 v2(278.75,31.63) ; v2(154.64,114.74) 154.34,115.04 CZ94.2 ; v2(43.86,82.51) 43.89,82.54 44.37,82.54 44.76,82.92 PQ1204.4 ; CC265.2 137.02,75.19 136.35,75.19 CC324.2 ; v2(190.23,52.08) 190.18,52.04 CZ104.2 ; CZ109.2 300.42,64.92 CZ122.2 ; v2(100.35,115.98) 99.98,115.6 CZ2.2 ; PQ1204.1 42.74,81.37 41.95,80.57 v2(41.51,80.57) ; v2(299.48,45.68) 299.48,46.17 299.15,46.5 CR7.2 ; UZ1.1 156.53,115.22 156.78,115.47 v2(156.78,115.73) ; CZ91.2 245.84,26.45 CZ92.2 ; v2(290.71,80.49) 290.71,80.26 CZ116.2 ; PC1076.2 122.18,80.68 v2(122.18,81.12) ; v2(40.01,96.46) 40.01,96.45 40.01,96.42 39.55,95.97 PR1222.2 ; v2(55.3,90.7) 55.3,90.75 56.35,91.8 PC933.2 ; PQ1214.1 v2(42.75,100.78) ; v2(276.61,37) CE22.2 ; DI6.3 v2(23.87,40.31) ; PQ1214.4 43.71,99.48 v2(43.32,99.09) ; CR20.1 v2(319.11,47.69) ; CZ119.2 v2(291.15,77.55) ; UL2.3 v2(292.48,84.11) ; CR19.1 v2(317.32,49.27) ; v2(284.36,31.97) 284.05,31.67 QE2.4 ; PC1045.2 114.5,72.43 v2(114.08,72.02) ; v2(265.82,23.48) 265.8,23.5 CZ67.2 266.44,24.87 CZ64.2 ; CZ128.2 294.73,18.81 CZ127.2 CZ126.2 296,18.64 CZ125.2 296.66,16.73 297.29,16.1 299.26,16.1 300.15,16.99 v2(300.15,17.16) ; v2(280.34,88.41) 280.08,88.41 CL11.2 ; v2(47.83,77.69) 47.83,77.7 PU1200.3 ; CL9.2 v2(281,97.25) ; v2(124.81,81.14) 124.81,80.86 PC1075.2 ; CE11.2 259.36,35.52 v2(259.26,35.62) ; PU1.3 30.47,109.73 v2(30.23,109.49) ; CZ93.2 v2(251.28,34.91) ; v2(261.13,57.83) 260.5,57.2 UE4.3 ; RD25.2 169.2,24.91 168.53,25.58 v2(168.53,26.59) ; CZ33.2 283.76,52.79 CZ31.2 284.29,51.75 v2(285,51.75) ; CR2.2 298.45,57.79 v2(298.52,57.73) ; v2(282.24,28.29) 282.75,28.8 QE2.1 ; v2(59.5,93.95) 59.18,93.64 PR960.1 ; v2(247.39,28.42) 247.39,28.33 246.98,27.92 CZ90.2 246.64,26.76 CZ83.2 ; CL10.2 v2(268.61,97.63) ; v2(261.43,40.15) 261.79,40.15 262.02,40.39 ; PU903.3 v2(31.45,71.36) ; CL8.2 v2(281,92.22) CL7.2 ; 127.51,77.14 PC1091.2 127.79,77.14 v2(128.15,76.77) 127.95,76.57 PC1126.2 127.51,76.57 ; v2(274.64,37.13) CE21.2 ; CZ102.2 176.99,45.66 CZ103.2 ; PC1002.2 120.95,76.81 v2(120.95,76.35)
  TOP w0.406: CC294.2 108.74,58.2 109.07,58.53 v2(109.35,58.53) ; UZ10.3 250.85,32.07 v2(250.7,31.92)
  TOP w0.432: QE13.2 v2(257.65,83.88)
  TOP w0.457: CC225.2 143.48,97.1 142.77,97.82 v2(142.77,98.41) ; CT72.2 31.87,64.5 v2(31.26,63.89) ; RC324.2 132.39,81.52 PC1147.2 ; CE54.2 264.8,33.44 v2(264.42,33.06) ; CT73.2 v2(24.26,66.34) ; v2(174.04,26.63) 174.31,26.36 RD18.2
  TOP w0.508: CC322.2 132.65,56.48 v2(133.1,56.93) ; v2(133.86,99.64) 135.33,99.64 RC3.2 ; v2(131.11,58.84) 130.87,58.84 130.34,59.37 CC179.2 ; v2(158.69,34.25) 159.01,34.57 CD33.2 ; PC1024.2 116.25,78.38 v2(116.25,78.07) ; v2(258.74,37.99) 258.74,37.34 CE61.2 ; RT125.2 v2(35.79,76.12) ; CC224.2 140.66,71.98 141.41,71.98 v2(141.48,71.91) ; v2(105.2,81.05) 104.88,81.37 PC1022.2 ; QE12.3 253.54,37.27 v2(253.54,37.51) ; v2(103.86,84.77) 104.02,84.61 PC1029.2 104.03,84.12 PC1027.2 ; v2(263.62,53.22) RE77.2 262.98,53.19 CE38.2 ; PC929.2 70.56,94.23 v2(70.56,94.19) ; v2(28.34,106.64) PR8.1 28.34,105.03 28.66,104.72 PQ3.3 ; CE53.2 258.06,55.59 v2(258.06,56.62) 257.9,56.78 257.08,56.78 CE47.2 ; v2(306.9,39.78) 306.2,39.08 CA69.2 ; RC1.2 139.35,81.31 139.87,81.83 v2(139.87,82.18) ; CC222.2 140.81,78.09 141.11,78.39 RC96.2 140.86,79.01 v2(140.5,79.01) ; v2(37.05,66.14) PR1217.2 PC1205.2 ; CC177.2 128.76,57.05 v2(129.51,57.05) 129.71,56.85 CC296.2 ; v2(137.1,53.18) 137.33,53.41 CC27.2 ; PC1176.2 84.38,72.76 84.36,72.74 v2(84.36,72.73) ; PR207.1 v2(31.28,37.53) ; v2(69.59,31.27) 69.31,31.27 69,30.96 69,29.28 CD29.2 ; CA31.2 294.03,39.85 v2(292.5,41.37) ; RV1.2 67.19,114.29 v2(66.78,113.89) ; PR1309.2 50.18,62.53 PC1310.2 51.06,62.71 51.63,63.29 v2(51.64,63.29) ; v2(290.83,48.74) 290.83,49.94 291.28,50.39 RR4.2 ; v2(278.61,54.96) 278.62,54.97 ; 278.62,54.97 CZ28.2 ; 278.62,54.97 278.74,55.09 RE14.2 ; v2(42.55,34.82) PR212.2 40.95,34.83 PC222.2 ; YL1.2 277.14,85.25 v2(276.42,85.25) ; PC1134.2 117.49,78.42 v2(117.49,78.06) ; CE62.2 263.59,32.07 v2(263.59,32.99) RE20.2 ; CA53.2 291.39,31.27 v2(291,31.67) ; RA52.1 293.99,34.58 293.6,34.97 v2(293.5,34.97) 293.16,34.97 292.42,34.22 CA54.2 ; v2(265.03,23.53) CZ72.2 ; v2(292.74,29.94) CA56.2 293.71,29.94 294.07,30.3 ; v2(289.63,70.4) CI34.2 290.3,70.38 CI33.2 ; v2(136.43,76.05) 136.43,75.37 CC324.2 ; SW3.1 v2(314.79,105.72) ; v2(101.73,77.36) PC1132.2 101.82,76.59 103.27,76.59 PC1131.2 104.84,76.67 PC1129.2 104.94,76.61 105.86,76.61 v2(105.89,76.57) ; v2(280.11,57.75) 280.11,58.31 279.61,58.82 RE16.2 ; CV21.2 73.28,117.24 CV20.2 73.28,115.61 v2(73.44,115.45) ; v2(85.29,31.27) 85.29,31.29 84.88,31.7 CD7.2 ; v2(89.03,72.69) 89.24,72.9 PC1102.2 ; CC23.2 152.96,72.43 152.7,72.17 152.64,72.17 v2(152.64,72.13) ; PC1015.2 119.66,72.09 v2(119.51,71.94) ; CC199.2 127.01,96.64 PC1067.2 ; v2(126.02,78.78) 126.02,78.42 125.65,78.06 PC1070.2 ; CLIP4.1 18.45,31.6 v2(18.05,31.2) ; CT92.2 15.58,96.6 v2(15.27,96.28) ; v2(106.4,82.94) 106.33,83.02 RC90.2 ; CE6.2 CE5.2 244.22,40.82 v2(243.94,41.1) ; CD37.2 149.44,29.22 v2(149.38,29.17) ; CV19.2 99.76,116.41 CV18.2 99.93,116.4 v2(100.35,115.98) ; CN63.2 20.5,18.26 v2(20.39,18.14) ; CC323.2 148.45,98.25 v2(148.79,97.91) ; v2(137.08,77.73) 137.08,77.95 137.41,78.28 CC208.2 ; v2(54.72,31.5) 54.35,31.87 CD9.2 ; CD2.2 78.5,31.86 v2(77.91,31.27) 77.41,31.77 CD10.2 ; v2(13.53,61.25) 13.33,61.05 JHDMI1.22 ; v2(163.34,34.22) 163.4,34.28 CD48.2 163.58,35.2 CD40.2 ; PQ1212.3 44.11,74.2 v2(45,74.2) ; RV88.2 113.39,105.48 v2(113.73,105.82) ; PC949.1 31.8,73.91 31.42,74.29 v2(31.42,74.39) ; v2(257.31,34.14) 257.31,34.08 257.23,34 CE29.2 ; CT85.2 20.93,57.84 CT86.2 21.15,59.06 v2(21.15,59.66) ; RD5.2 110.31,29.03 v2(110.26,28.98) ; CC295.2 113.12,55.75 v2(114.15,56.78) ; v2(298.68,8.6) 298.87,8.79 CA23.2 298.83,9.7 CA19.2 ; RD29.2 167.1,29.71 167.29,29.89 v2(167.41,29.89) ; CLIP6.1 v2(310.36,52.55) ; CV14.2 60.23,102.67 v2(60.2,102.65) ; v2(170.9,26.6) 171.15,26.85 RD16.2 ; RT65.2 RT64.2 34.58,59.54 v2(34.77,59.73) ; 310.43,19.66 310.49,19.6 CA13.1 310.49,18.6 310.85,18.24 310.85,17.05 310.64,16.84 310.64,15.72 310.34,15.41 DA1.1 ; 310.43,19.66 310.52,19.75 CA12.2 ; 310.43,19.66 310.05,20.03 DA3.1 ; PC1138.2 v2(103.31,81.08) ; v2(264.03,23.53) 263.81,23.74 CZ61.2 263.51,23.86 CZ71.2 ; CE10.2 249.03,32.99 v2(248.6,32.56) ; RT126.2 37.7,80.76 v2(37.22,81.24) 36.9,80.92 RT37.2 ; v2(181.37,98.2) 181.37,97.52 PC302.2 ; CT89.2 RT393.2 16.12,94.21 v2(15.69,93.78) ; CZ27.2 v2(283.57,36.18) ; CA24.2 v2(292.81,9.68) ; v2(308.23,74.9) 307.72,75.41 DI5.1 ; v2(77.92,26.62) 78.07,26.47 CD4.2 ; v2(118.14,80.39) 118.14,80 PC1020.2 ; CE57.2 252.29,39.12 v2(252.29,38.63) ; v2(273.48,28.75) 273.48,29.15 273.9,29.57 CE3.2 ; v2(252.46,23.82) 251.87,24.41 CZ81.2 251.37,24.43 CZ80.2 ; CC320.2 147.14,83.66 v2(146.8,83.32) ; v2(265.5,29.12) 264.75,28.37 CE59.2 ; RA45.2 CA62.2 295.73,24.83 v2(295.53,24.63) ; RZ40.1 v2(283.78,77.95) ; CC217.2 133.18,77.7 v2(133.16,77.73) 132.47,77.73 PC1153.2 ; v2(30.72,67.81) 30.26,67.35 CT71.2 ; CC216.2 141.32,96.31 v2(141.18,96.17) ; JSD1.20 325.77,36.99 v2(326.34,37.56) ; RC136.2 62.97,96.97 v2(62.38,97.55) ; RL12.2 v2(275.08,101.06) ; JUSB2.7 v2(15.4,25.65) ; CE28.2 257.88,30.56 v2(258.01,30.43) ; CA65.2 v2(303.43,42.97) ; PR419.2 168.7,113.17 v2(169,113.47) ; PC1175.2 83.16,72.89 v2(83.31,72.74) ; CZ197.2 v2(168.68,64.99) ; PC116.2 v2(39.76,45.33) ; CT91.2 16.67,99.05 16.7,99.05 17.07,98.68 17.53,98.68 v2(17.53,98.68) ; DI1.3 v2(22.96,31.37) ; v2(132.67,26.57) 133.94,27.83 CD61.2 ; PC1007.2 87.58,82.58 87.58,82.3 v2(87.47,82.19) ; v2(88.65,82.23) 88.8,82.38 88.8,82.58 PC1065.2 ; v2(267.18,23.56) CZ69.2 ; PC1068.2 123.17,78.13 123.47,78.43 v2(123.47,78.78) ; PC202.2 36.58,40.56 ; CR18.1 v2(309.12,38.02) ; QV2.3 56.71,103.81 v2(57,103.52) ; RE18.2 279.6,60.6 v2(280.01,60.19) ; v2(85.08,82.19) 85.14,82.25 85.14,82.56 PC1008.2 ; CA61.2 293.36,36.29 v2(293.11,36.04) ; PR1304.2 PC1302.2 44.59,57.8 45.1,58.31 v2(45.18,58.31) ; v2(107.8,34.46) 107.8,34.24 CD12.2 ; v2(282.51,39.66) 282.37,39.8 RE513.2 ; RE56.2 v2(268.1,33.05) ; v2(194.78,21.27) 194.36,21.68 PR516.2 ; CD42.2 157.91,34.53 157.62,34.23 156.89,34.23 v2(156.86,34.27) 157.04,34.45 CD45.2 ; CLIP2.1 v2(319.41,70.65) ; CZ29.2 CZ34.2 281.5,55.56 v2(281.25,55.81) ; PC1060.2 130.6,83.44 v2(130.51,83.36) ; RT30.2 RT24.2 38.46,76.32 v2(38.18,76.04) 37.72,75.58 PC1201.1 ; v2(263.23,50.74) 263.78,50.74 CE30.2 264.21,50.31 264.21,49.57 JTAG1.2 ; JSD1.14 v2(325.2,43.74) ; PC1067.2 126.07,96.63 PC1009.2 ; PC1067.2 126.08,96.72 126.67,97.32 v2(126.98,97.32) ; CC319.2 168.21,79.5 CC318.2 168.21,81.18 167.75,81.65 167.34,81.65 v2(167.09,81.4) ; v2(64.82,107.5) 64.82,106.65 CC306.2 64.45,106.28 CV11.2 62.04,106.28 CV15.2 ; PC1079.2 86.37,82.56 86.37,82.33 v2(86.24,82.19) ; CD39.2 160.13,28.38 160.13,29.03 v2(160.41,29.32) 160.77,29.32 161.06,29.03 CD44.2 ; CC250.2 128.82,75.32 v2(128.36,75.78) 127.93,75.35 CC253.2 ; PC1184.2 87.01,70.63 PC1103.2 v2(87,69.75) ; CC203.2 137.01,82.69 v2(137.08,82.76) ; v2(289.19,24.74) CA67.2 CA68.2 ; UE5.3 256.29,53.14 v2(255.36,53.14) ; CR28.2 CR1.2 298.52,57.32 v2(298.52,57.73) ; RT36.2 v2(24.74,75.96) ; PC1179.2 83.29,69.83 v2(83.31,69.81) ; PC1009.2 124.86,97.25 v2(124.78,97.33) ; PC1009.2 123.65,96.63 PC1064.2 ; CA66.2 305.96,40.48 v2(306.15,40.67) ; DA6.1 v2(297.74,2.08) ; PR1324.1 47.64,51.4 PR1320.2 PC1320.2 v2(49.2,51.38) ; JSD1.23 v2(324.18,34.26) ; CT74.2 33.28,67.72 v2(33.37,67.81) 33.37,67.38 33.88,66.87 34.42,66.87 PC1207.2 ; v2(161.45,34.27) 161.53,34.34 CD41.2 ; CZ118.2 291.34,78.28 291.85,77.77 v2(291.85,77.56) ; v2(91.42,26.71) 91.42,26.49 91.06,26.13 RD9.2 ; CR26.2 298.64,45.84 v2(298.83,45.65) ; CR26.2 CR25.2 ; CR26.2 CR4.2 ; JUSB3.7 v2(15.53,45.15) ; CR5.2 293.03,48.42 v2(292.84,48.23) ; v2(261.05,35.27) 260.94,35.16 RE58.2 ; PR1321.2 45,51.8 v2(45.23,52.03) ; v2(29.1,54.52) 29.09,54.51 RT99.2 28.4,54.95 28.64,55.19 RT86.2 ; CZ121.2 v2(168.81,70.26) ; v2(51.06,78.73) 50.94,78.85 PC902.2 ; PC1188.2 v2(85.6,72.73) ; v2(29.42,68.27) 29.15,68.01 RT63.2 ; PC651.1 PC654.1 59.23,74.67 v2(59.41,74.49) ; CD58.2 164.14,29.34 164.5,29.7 v2(165.25,29.7) ; v2(296.42,29) 296.42,28.91 CA72.2 RA51.2 ; v2(300.1,57.82) 300.61,57.31 CR27.2 ; v2(50.34,82.47) 49.61,82.47 PR1210.2 ; CC291.2 109.82,78.15 v2(109.11,77.44) 109.53,77.02 CC292.2 ; CL4.2 v2(274.68,85.25) ; RE85.2 265.65,50.55 v2(265.65,50.76) ; v2(30.74,49.84) 30.74,49.26 30.06,48.58 CT70.2 ; v2(61.44,76.09) 61.72,76.36 PC680.2 62.16,76.37 PC686.2 63.04,76.37 PC660.2 PC659.2 ; v2(14.58,72.83) 15.37,72.83 QV4.3 ; CZ63.2 269.67,27.73 CZ62.2 270.92,27.73 271.25,27.4 271.25,26.36 v2(271.01,26.12) ; v2(138.74,83.57) 139.25,83.07 CC264.2 ; PR209.2 PC221.2 39.99,40 v2(39.73,40.26) ; JSD1.6 311.2,37.57 v2(311.03,37.75) ; RV21.2 14.12,75.57 13.62,75.06 v2(13.62,74.92) ; v2(165,67.26) 165.54,67.26 v2(165.58,67.29) 166.02,66.86 UZ8.9 ; v2(46.57,73.38) 46.71,73.53 PR608.2 PR611.2 ; v2(147.71,56.29) 145.8,58.2 CC316.2 ; CA6.2 59.76,115.24 59.76,115.68 v2(59.55,115.89) ; v2(71.68,34.57) 71.68,34.52 72.34,33.86 72.34,32.59 72.88,32.05 CD11.2 ; UE7.2 240.59,40.86 v2(240.35,41.1) ; v2(304.34,62.19) 304.34,61.47 CI44.2 ; v2(160.41,33.89) 160.2,34.1 CD47.2 ; CR21.2 v2(302.91,45.94) ; PC1101.2 v2(84.52,69.81) ; PC201.2 37.76,39.25 v2(37.77,39.26) ; v2(300.74,65.63) CZ109.2 ; RD7.2 112.99,31.3 112.65,30.96 v2(112.65,30.84) ; v2(252.8,30.66) 252.29,30.16 CE12.2 ; v2(18.8,96.81) 18.8,96.78 19.11,96.46 UT7.2 ; RC6.2 134.66,58.72 134.94,58.44 CC333.2 135.6,58.34 v2(135.67,58.27) ; RZ25.2 v2(309.98,8.4) ; v2(263.29,51.39) RE65.2 ; v2(291.47,79.6) 291.28,79.6 CZ117.2 ; CD38.2 153.51,29.59 v2(153.31,29.78) ; v2(124.6,76.35) 124.6,76.79 PC1013.2 ; CC280.2 174.52,51.71 CC279.2 175.64,51.71 v1(176.68,52.74) 178.83,54.9 v2(178.83,54.93) ; CC211.2 137.34,79.98 137.08,79.72 v2(137.08,79.4) ; CZ3.2 v2(102.45,115.42) ; UV24.2 v2(70.3,110.89) 70.4,110.78 71.89,110.78 72.53,110.14 CV17.2 ; v2(123.37,76.36) 123.37,76.81 PC1071.2 ; CV25.2 CV24.2 62.65,109.87 v2(62.65,111.58) ; PC1193.2 v2(85.6,75.71) ; PR647.1 61.19,69.31 61.55,69.67 v2(61.62,69.67) ; v2(133.1,57.75) 133.29,57.75 133.87,58.34 CC331.2 133.77,58.62 RC5.2 ; PC1194.2 v2(88.01,72.73) ; v2(303.75,57.78) RZ38.1 ; YT1.2 24.81,94.84 25,94.65 v2(25.02,94.65) 25.02,93.72 CT20.2 ; v2(28.78,46.37) 28.77,46.36 28.77,46.13 29.72,45.18 UI2.2 ; v2(301.44,65.5) 301.44,65.5 301.53,65.5 301.96,65.07 CZ110.2 ; CT84.2 28.07,68.55 v2(28.25,68.73) ; v2(324.4,40.15) 324.84,39.72 JSD1.17 ; v2(73.53,26.4) 74.03,25.9 CD8.2 ; 272.1,88.49 v2(272.84,88.49) ; v2(302.9,54.48) 302.87,54.45 CR15.2 ; v2(88.33,26.13) CD25.2 86.9,25.43 CD16.2 ; YT1.4 v2(22.79,96.64) ; RC91.2 109.85,83.05 v2(109.74,82.95) ; v2(307.96,35.51) 307.85,35.4 CA49.2 ; v2(282.49,33.18) CZ32.2 281.03,33.18 CZ35.2 ; v2(295.02,72.43) 295,72.46 CI31.2 ; PC1318.2 PC1317.2 44.59,48.35 v2(44.17,47.93) ; RC44.2 143.6,77.5 v2(143.06,78.04) ; PC1069.2 124.74,78.43 v2(124.74,78.78) ; v2(79.73,31.27) 79.61,31.39 CD15.2 79.8,32.26 CD1.2 ; JUSB2.11 v2(7,34.56) ; PH603.1 v2(74.12,76.94) ; RD23.2 196.34,28.42 195.98,28.06 195.1,28.06 194.58,28.58 ; RC7.2 136.96,58.74 RC48.2 137.92,58.02 v2(137.66,57.76) ; RD31.2 162.37,29.04 CD57.2 163.25,29.54 v2(163.41,29.7) ; PC125.2 38.61,47.54 39.17,48.1 v2(39.17,50.17) ; CC218.2 133.81,79.83 v2(133.81,79.4) 133.84,79.38 CC206.2 ; CV16.2 69.27,115.64 v2(69.06,115.84) ; RL3.2 v2(273.56,84.68) ; v2(186.56,33.45) 186.9,33.45 187.33,33.88 187.33,34.96 186.88,35.4 CD35.2 ; CC288.2 130.65,73.64 v2(130.05,74.24) 129.76,74.53 PC1143.2 ; CC225.2 144.7,97.1 v2(145.12,96.67) ; CD13.2 76.97,26.27 v2(76.67,26.56) 76,25.89 CD3.2 ; v2(265.18,32.35) 264.73,31.9 CE16.2 ; PC1010.2 120.99,78.31 v2(120.99,78.75) ; PC1183.2 v2(86.81,72.73) ; JUSB3.13 v2(7,36.05) ; CE60.2 278.49,44.26 v2(278.73,44.51) ; v2(302.91,49.3) 302.61,49.59 CR22.2 ; CL12.2 v2(268.1,90.9) ; PR514.2 v2(201.59,21.9) ; CZ102.2 176.74,45.57 v2(175.83,44.67) ; PC1004.2 122.13,76.85 v2(122.13,76.35) ; v2(125.84,76.35) 125.84,76.75 PC1006.2 ; v2(34.55,69.35) 34.55,69.59 33.75,70.39 PR953.2 ; v2(127.77,73.52) 127.77,72.89 CC252.2 126.8,72.86 126.81,72.87 126.85,72.87 ; v2(308.9,62.19) 308.31,61.6 CLIP1.1 ; PC1025.2 v2(89.22,75.71) ; v2(105.72,113.57) 104.8,112.64 RV74.2 ; v2(187.26,97.19) 186.5,97.19 186.37,97.06 PC313.2 ; CD5.2 82.39,31.73 82.89,31.23 v2(82.91,31.23) 82.91,31.44 83.63,32.16 CD6.2 ; v2(60.66,97.66) 60.66,97.5 61.45,96.71 PC947.2 ; v2(283.47,88.77) 283.47,88.84 282.96,89.35 RL13.2 ; PC647.1 59.73,73.06 v2(59.82,73.15) ; CD14.2 64.78,31.23 64.06,30.51 v2(63.77,30.51) ; CA64.2 300.15,17.62 v2(300.15,17.16) ; PC1135.2 v2(101.8,81.05) ; CC212.2 146.56,75.58 v2(146.12,75.14) 145.53,74.55 RC337.2 ; PC940.2 53.91,89.48 54.19,89.2 v2(54.19,89.01) ; v2(104.11,74.98) 104.27,75.14 PC1130.2 ; v2(182.95,26.31) CD36.2 ; CC332.2 135.57,59.78 v2(135.64,59.72) ; v2(231.19,27.7) 230.91,27.43 PC112.2 ; CD34.2 166.85,34.66 167.19,34.32 v2(167.52,34.32) ; v2(41.62,66.63) 41.24,66.63 40.93,66.94 PC1206.2 ; v2(277.36,63.1) 278.08,62.38 CE500.2 ; v2(305.26,62.24) 305.26,61.48 CI43.2 ; RT28.2 RT124.2 33.12,76.37 33.38,76.12 v2(33.38,76.09) ; v2(97.34,112.26) 97.34,111.36 QV7.3 ; JLOM1.16 v2(317.35,100.91) ; JLOM1.17 v2(323.2,100.82) ; YL1.4 v2(279.78,82.9) ; RC89.2 144.69,56.32 144.71,56.31 v2(144.71,56.28) 144.68,56.25 RC88.2 ; CC207.2 135.77,77.73 CC209.2 ; v2(261.81,32.96) RE55.2 ; v2(127.93,97.2) 128.31,97.2 128.88,97.77 CC220.2 ; v2(38.97,32.52) 38.8,32.35 PC218.2 ; PC3.2 v2(308.94,6.98) ; RT33.2 v2(28.08,76.69) ; v2(122.18,78.78) 122.18,78.31 121.96,78.09 PC1072.2 ; CC178.2 111.68,58.22 v2(111.62,58.28) ; PC9.2 v2(34.85,110.69) ; CC266.2 141.34,55.28 RC220.2 141.4,54.79 140.68,54.07 139.96,54.07 139.6,54.43 RC75.2 ; PC513.2 v2(201.61,22.8) ; CZ198.2 v2(264.25,72) ; CL29.2 v2(275.97,101.06) ; DV4.1 93.23,113.62 92.31,114.55 92.31,115.92 v2(92.38,115.99) ; PC1192.2 v2(86.81,75.71) ; v2(116.88,80.4) 116.88,79.95 PC1021.2 ; CE503.2 v2(258.5,87.79) ; CA33.2 v2(291.76,32.61) ; PC1190.2 v2(85.73,69.81) ; v2(108.89,113.31) 108.29,113.91 RV73.2 ; PC1136.2 v2(88.01,75.71) ; CD43.2 156.11,34.51 155.6,34 v2(155.07,34) 155.07,34.64 155.18,34.75 CD46.2 ; 301.82,14.92 302.05,14.69 v2(302.05,14.11) ; QR1.3 v2(313.47,49.87) ; v2(88.98,26.7) 89.27,26.41 CD26.2 ; RE313.2 273.99,32.06 CE4.2 273.13,31.67 272.95,31.49 v2(272.95,31.48) ; SW3.3 v2(313.76,108.61) ; CZ124.2 v2(291.63,76.82) ; JLOM1.14 v2(317.35,72.21) ; RC401.2 163.92,84.65 164.02,84.55 v2(164.02,84.55) ; v2(74.42,105.84) 74.42,106.57 73.41,107.59 RV3.1 ; JLOM1.15 v2(323.2,72.18) ; CA22.2 302.06,9.87 v2(302.96,9.87) ; v2(113.14,73.55) 113.57,73.12 PC1016.2 ; PC1195.2 v2(90.97,78.86) ; DA7.1 v2(293.12,2.1) ; PC2.1 v2(309.98,9.51)
  GND1 w0.203: JUSBC1.B1 6.6,87.51 ; JUSBC1.B1 6.23,86.68 ; JUSBC1.B1 6.97,87.42 ; JUSBC1.B1 6.14,87.05 ; JUSB3.11 8.35,53.65 ; JUSB3.11 7,53.65 ; JUSB3.11 5.65,52.85 ; JUSB3.11 5.65,53.65 ; JUSB3.11 8.35,52.85 ; 310.16,67.2 JUSB1.12 ; JUSB1.12 311.47,68 ; JUSB1.12 311.47,68.8 ; JUSB1.12 311.47,67.2 ; JUSB1.12 308.86,68.8 ; JUSB1.12 308.86,67.2 ; JUSB1.12 310.16,68.8 ; JUSB1.12 308.86,68 ; 191.05,104.2 H31.1 ; H31.1 192.7,100.29 ; H31.1 194.35,104.2 ; H31.1 191.05,100.9 ; H31.1 192.7,104.81 ; H31.1 190.44,102.55 ; H31.1 194.96,102.55 ; H31.1 194.35,100.9 ; H19.1 292.6,16.16 ; H19.1 291.44,13.44 ; H19.1 293.76,13.44 ; H19.1 294.16,14.6 ; H19.1 291.04,14.6 ; H19.1 293.76,15.76 ; H19.1 292.6,13.04 ; H19.1 291.44,15.76 ; 5.14,84.35 JUSBC1.2 ; JUSBC1.2 7.41,84.35 ; JUSBC1.2 6.28,84.35 ; JUSBC1.2 6.28,85.75 ; 4.39,80.24 H10.1 ; H10.1 6.71,80.24 ; H10.1 3.99,81.4 ; H10.1 7.11,81.4 ; H10.1 5.55,82.96 ; H10.1 5.55,79.84 ; H10.1 6.71,82.56 ; H10.1 4.39,82.56 ; JUSB1.10 311.47,55.2 ; JUSB1.10 308.86,54.4 ; JUSB1.10 308.86,55.2 ; JUSB1.10 310.16,54.4 ; JUSB1.10 311.47,56 ; JUSB1.10 310.16,56 ; JUSB1.10 311.47,54.4 ; JUSB1.10 308.86,56 ; JUSB2.7 14.45,26.4 ; JUSB2.7 15.2,25.65 ; JUSB2.7 13.87,26.23 ; JUSB2.7 14.45,24.9 ; JUSB2.7 13.87,25.07 ; JUSB2.7 15.03,26.23 ; JUSB2.7 15.03,25.07 ; H2.1 157.06,68.06 ; H2.1 155.55,68.61 ; H2.1 154.04,68.06 ; H2.1 154.04,65.04 ; H2.1 153.49,66.55 ; H2.1 157.06,65.04 ; H2.1 155.55,64.49 ; H2.1 157.61,66.55 ; 15.2,22.15 JUSB2.4 ; JUSB2.4 15.95,22.9 ; JUSB2.4 15.37,22.73 ; JUSB2.4 15.95,21.4 ; JUSB2.4 15.37,21.57 ; JUSB2.4 16.7,22.15 ; JUSB2.4 16.53,21.57 ; JUSB2.4 16.53,22.73 ; JHDMI1.20 13.01,74.7 ; JHDMI1.20 13.01,76.4 ; JHDMI1.20 11.75,74.7 ; JHDMI1.20 10.49,76.4 ; JHDMI1.20 10.49,74.7 ; JHDMI1.20 13.01,75.55 ; JHDMI1.20 11.75,76.4 ; 0.86,95.65 JUSBC1.3 ; JUSBC1.3 0.86,96.35 ; JUSBC1.3 3.24,94.95 ; JUSBC1.3 2.05,94.95 ; JUSBC1.3 3.24,95.65 ; JUSBC1.3 0.86,94.95 ; JUSBC1.3 3.24,96.35 ; JUSBC1.3 2.05,96.35 ; 243.03,55.11 SW1.5 ; SW1.5 242.05,56.09 ; SW1.5 243.03,57.07 ; SW1.5 242.28,55.34 ; SW1.5 243.77,55.34 ; SW1.5 242.28,56.83 ; SW1.5 244,56.09 ; SW1.5 243.77,56.83 ; 258.64,116.7 H22.1 ; H22.1 260.2,118.26 ; H22.1 260.2,115.14 ; H22.1 261.76,116.7 ; H22.1 261.36,117.86 ; H22.1 261.36,115.54 ; H22.1 259.04,115.54 ; H22.1 259.04,117.86 ; JHDMI1.17 12,71.35 ; JHDMI1.17 11.1,71.35 ; JHDMI1.17 11.1,72.25 ; JHDMI1.17 10.99,71.8 ; JHDMI1.17 12,72.25 ; JHDMI1.17 12.11,71.8 ; 11.75,60.2 JHDMI1.22 ; JHDMI1.22 13.01,60.2 ; JHDMI1.22 11.75,61.9 ; JHDMI1.22 13.01,61.05 ; JHDMI1.22 10.49,61.9 ; JHDMI1.22 10.49,60.2 ; JHDMI1.22 13.01,61.9 ; JHDMI1.2 13.66,64.3 ; JHDMI1.2 12.65,64.75 ; JHDMI1.2 12.65,63.85 ; JHDMI1.2 13.1,63.74 ; JHDMI1.2 13.55,63.85 ; JHDMI1.2 13.55,64.75 ; JHDMI1.2 12.54,64.3 ; 159.79,112.8 H28.1 ; H28.1 165.61,112.8 ; H28.1 159.79,115.2 ; H28.1 159.79,117.6 ; H28.1 165.61,117.6 ; H28.1 165.61,115.2 ; H28.1 162.7,117.6 ; H28.1 162.7,112.8 ; 51.7,115.14 H15.1 ; H15.1 53.26,116.7 ; H15.1 52.86,115.54 ; H15.1 51.7,118.26 ; H15.1 50.54,115.54 ; H15.1 52.86,117.86 ; H15.1 50.54,117.86 ; H15.1 50.14,116.7 ; 14.2,18.45 JUSB2.12 ; JUSB2.12 15.55,18.45 ; JUSB2.12 15.55,20.05 ; JUSB2.12 16.9,18.45 ; JUSB2.12 16.9,19.25 ; JUSB2.12 14.2,19.25 ; JUSB2.12 16.9,20.05 ; JUSB2.12 14.2,20.05 ; 321.55,99.65 JLOM1.17 ; JLOM1.17 324.85,100.45 ; JLOM1.17 323.2,100.45 ; JLOM1.17 321.55,100.45 ; JLOM1.17 324.85,99.65 ; 311.35,60.98 JUSB1.7 ; JUSB1.7 312.58,62.22 ; JUSB1.7 311.97,62.4 ; JUSB1.7 312.58,60.98 ; JUSB1.7 311.97,60.8 ; JUSB1.7 311.16,61.6 ; JUSB1.7 311.35,62.22 ; 251.14,69.25 H30.1 ; H30.1 253.4,66.99 ; H30.1 255.05,70.9 ; H30.1 255.66,69.25 ; H30.1 251.75,70.9 ; H30.1 253.4,71.51 ; H30.1 251.75,67.6 ; H30.1 255.05,67.6 ; H4.1 157.06,87.54 ; H4.1 157.61,89.05 ; H4.1 155.55,91.11 ; H4.1 154.04,87.54 ; H4.1 153.49,89.05 ; H4.1 155.55,86.99 ; H4.1 157.06,90.56 ; H4.1 154.04,90.56 ; JUSBC1.1 7.41,95.35 ; JUSBC1.1 6.28,95.35 ; JUSBC1.1 6.28,93.95 ; JUSBC1.1 5.14,95.35 ; JHDMI1.8 13.55,67.75 ; JHDMI1.8 12.65,67.75 ; JHDMI1.8 12.65,66.85 ; JHDMI1.8 13.66,67.3 ; JHDMI1.8 12.54,67.3 ; JHDMI1.8 13.55,66.85 ; 2.05,83.35 JUSBC1.4 ; JUSBC1.4 0.86,84.75 ; JUSBC1.4 0.86,83.35 ; JUSBC1.4 3.24,84.75 ; JUSBC1.4 3.24,83.35 ; JUSBC1.4 0.86,84.05 ; JUSBC1.4 3.24,84.05 ; JUSBC1.4 2.05,84.75 ; 303.04,107.04 H21.1 ; H21.1 305.76,108.2 ; H21.1 305.36,107.04 ; H21.1 303.04,109.36 ; H21.1 304.2,106.64 ; H21.1 304.2,109.76 ; H21.1 302.64,108.2 ; H21.1 305.36,109.36 ; 44.8,9.64 H14.1 ; H14.1 45.96,12.36 ; H14.1 43.64,10.04 ; H14.1 46.36,11.2 ; H14.1 44.8,12.76 ; H14.1 43.64,12.36 ; H14.1 43.24,11.2 ; H14.1 45.96,10.04 ; 9.79,11.45 H34.1 ; H34.1 11.95,13.1 ; H34.1 9.79,13.1 ; H34.1 14.11,11.45 ; H34.1 14.11,13.1 ; H34.1 9.79,9.8 ; H34.1 14.11,9.8 ; H34.1 11.95,9.8 ; 14.2,50.75 JUSB3.10 ; JUSB3.10 14.2,52.35 ; JUSB3.10 14.2,51.55 ; JUSB3.10 16.9,51.55 ; JUSB3.10 16.9,52.35 ; JUSB3.10 16.9,50.75 ; JUSB3.10 15.55,52.35 ; JUSB3.10 15.55,50.75 ; 14.2,32.05 JUSB2.10 ; JUSB2.10 16.9,32.85 ; JUSB2.10 16.9,31.25 ; JUSB2.10 15.55,32.85 ; JUSB2.10 14.2,31.25 ; JUSB2.10 15.55,31.25 ; JUSB2.10 14.2,32.85 ; JUSB2.10 16.9,32.05 ; SW1.4 238.31,52.19 ; SW1.4 236.59,52.94 ; SW1.4 237.57,53.92 ; SW1.4 237.57,51.96 ; SW1.4 236.83,53.68 ; SW1.4 238.31,53.68 ; SW1.4 236.83,52.19 ; SW1.4 238.55,52.94 ; 315.7,99.65 JLOM1.16 ; JLOM1.16 317.35,100.45 ; JLOM1.16 319,99.65 ; JLOM1.16 315.7,100.45 ; JLOM1.16 319,100.45 ; JUSB1.4 311.27,65.1 ; JUSB1.4 311.08,64.48 ; JUSB1.4 309.85,65.72 ; JUSB1.4 310.46,65.9 ; JUSB1.4 311.08,65.72 ; JUSB1.4 310.46,64.3 ; JUSB1.4 309.66,65.1 ; JUSB1.4 309.85,64.48 ; 318.26,69.3 JUSB1.13 ; JUSB1.13 319.41,70.1 ; JUSB1.13 320.57,70.1 ; JUSB1.13 318.26,70.1 ; JUSB1.13 320.57,69.3 ; 4.1,6.9 H23.1 ; H23.1 2.88,7.33 ; H23.1 2.88,9.77 ; H23.1 2.45,8.55 ; H23.1 5.32,9.77 ; H23.1 4.1,10.2 ; H23.1 5.75,8.55 ; H23.1 5.32,7.33 ; JSD1.13 323.41,31.98 ; JSD1.13 323.41,33.37 ; JSD1.13 321.19,31.98 ; JSD1.13 323.41,32.68 ; JSD1.13 321.19,33.37 ; JSD1.13 322.3,33.37 ; JSD1.13 321.19,32.68 ; JSD1.13 322.3,31.98 ; 4.39,99.46 H9.1 ; H9.1 3.99,98.3 ; H9.1 6.71,99.46 ; H9.1 7.11,98.3 ; H9.1 4.39,97.14 ; H9.1 5.55,96.74 ; H9.1 6.71,97.14 ; H9.1 5.55,99.86 ; 252.99,44.55 H7.1 ; H7.1 257.01,44.55 ; H7.1 253.53,46.02 ; H7.1 255,46.56 ; H7.1 256.47,43.08 ; H7.1 256.47,46.02 ; H7.1 253.53,43.08 ; H7.1 255,42.54 ; 6.6,92.19 JUSBC1.B12 ; JUSBC1.B12 6.14,92.65 ; JUSBC1.B12 6.23,93.02 ; JUSBC1.B12 6.97,92.28 ; JUSBC1.B12 7.06,92.65 ; 15.37,42.23 JUSB3.4 ; JUSB3.4 15.95,42.4 ; JUSB3.4 15.95,40.9 ; JUSB3.4 16.7,41.65 ; JUSB3.4 15.2,41.65 ; JUSB3.4 16.53,42.23 ; JUSB3.4 16.53,41.07 ; JUSB3.4 15.37,41.07 ; 96.45,64.49 H3.1 ; H3.1 97.96,65.04 ; H3.1 94.94,65.04 ; H3.1 96.45,68.61 ; H3.1 97.96,68.06 ; H3.1 94.39,66.55 ; H3.1 98.51,66.55 ; H3.1 94.94,68.06 ; 271.2,109.34 H8.1 ; H8.1 269.19,111.35 ; H8.1 269.73,109.88 ; H8.1 272.67,109.88 ; H8.1 269.73,112.82 ; H8.1 271.2,113.36 ; H8.1 273.21,111.35 ; H8.1 272.67,112.82 ; 311.59,46.27 JSD1.11 ; JSD1.11 312.7,45.58 ; JSD1.11 312.7,46.97 ; JSD1.11 313.81,46.97 ; JSD1.11 311.59,46.97 ; JSD1.11 313.81,46.27 ; JSD1.11 311.59,45.58 ; JSD1.11 313.81,45.58 ; JHDMI1.11 12,69.25 ; JHDMI1.11 10.99,68.8 ; JHDMI1.11 12,68.35 ; JHDMI1.11 12.11,68.8 ; JHDMI1.11 11.1,68.35 ; JHDMI1.11 11.1,69.25 ; JUSB3.12 16.9,38.75 ; JUSB3.12 16.9,39.55 ; JUSB3.12 14.2,38.75 ; JUSB3.12 16.9,37.95 ; JUSB3.12 14.2,37.95 ; JUSB3.12 15.55,39.55 ; JUSB3.12 14.2,39.55 ; JUSB3.12 15.55,37.95 ; JLOM1.15 324.85,73.25 ; JLOM1.15 324.85,72.45 ; JLOM1.15 323.2,72.45 ; JLOM1.15 321.55,73.25 ; JLOM1.15 321.55,72.45 ; JUSB3.13 8.35,37.45 ; JUSB3.13 8.35,36.65 ; JUSB3.13 5.65,37.45 ; JUSB3.13 7,36.65 ; JUSB3.13 5.65,36.65 ; H26.1 322.3,10.2 ; H26.1 320.65,8.55 ; H26.1 322.3,6.9 ; H26.1 321.08,7.33 ; H26.1 323.95,8.55 ; H26.1 323.52,9.77 ; H26.1 321.08,9.77 ; H26.1 323.52,7.33 ; JUSB2.13 8.35,17.15 ; JUSB2.13 5.65,17.95 ; JUSB2.13 8.35,17.95 ; JUSB2.13 5.65,17.15 ; JUSB2.13 7,17.15 ; JLOM1.14 319,72.45 ; JLOM1.14 319,73.25 ; JLOM1.14 315.7,73.25 ; JLOM1.14 315.7,72.45 ; JLOM1.14 317.35,72.45 ; JUSB2.11 8.35,33.35 ; JUSB2.11 7,34.15 ; JUSB2.11 5.65,34.15 ; JUSB2.11 8.35,34.15 ; JUSB2.11 5.65,33.35 ; 1.75,78.05 JHDMI1.21 ; JHDMI1.21 1.75,77.05 ; JHDMI1.21 5.05,78.05 ; JHDMI1.21 5.05,77.05 ; 12.05,96.74 H12.1 ; H12.1 10.89,99.46 ; H12.1 13.21,99.46 ; H12.1 12.05,99.86 ; H12.1 10.49,98.3 ; H12.1 10.89,97.14 ; H12.1 13.61,98.3 ; H12.1 13.21,97.14 ; H1.1 98.51,89.05 ; H1.1 96.45,91.11 ; H1.1 97.96,90.56 ; H1.1 96.45,86.99 ; H1.1 94.94,87.54 ; H1.1 94.94,90.56 ; H1.1 94.39,89.05 ; H1.1 97.96,87.54 ; JSD1.10 312.7,33.37 ; JSD1.10 311.59,31.98 ; JSD1.10 313.81,33.37 ; JSD1.10 311.59,32.68 ; JSD1.10 311.59,33.37 ; JSD1.10 313.81,31.98 ; JSD1.10 313.81,32.68 ; 325.5,45.58 JSD1.12 ; JSD1.12 325.5,46.97 ; JSD1.12 324.39,46.97 ; JSD1.12 324.39,46.27 ; JHDMI1.5 12.11,65.8 ; JHDMI1.5 11.1,66.25 ; JHDMI1.5 12,65.35 ; JHDMI1.5 10.99,65.8 ; JHDMI1.5 11.1,65.35 ; JHDMI1.5 12,66.25 ; 13.87,45.73 JUSB3.7 ; JUSB3.7 15.03,45.73 ; JUSB3.7 14.45,44.4 ; JUSB3.7 15.03,44.57 ; JUSB3.7 15.2,45.15 ; JUSB3.7 14.45,45.9 ; JUSB3.7 13.87,44.57 ; 3.4,58.55 JHDMI1.23 ; JHDMI1.23 5.19,59.55 ; JHDMI1.23 5.05,58.55 ; JHDMI1.23 1.75,59.55 ; JHDMI1.23 1.75,58.55 ; 319.41,53.1 JUSB1.11 ; JUSB1.11 320.57,53.1 ; JUSB1.11 320.57,53.9 ; JUSB1.11 318.26,53.1
  GND1 w0.508: JUSB2.13 6.6,17.55 6.6,16.75 ; 3.37,78.34 3.4,78.31 JHDMI1.21 ; 7.44,94.65 JUSBC1.1 ; 318.57,53.17 319.3,53.9 JUSB1.11 ; 7.45,85.05 JUSBC1.2
  IN1 w0.508: v2(168.28,67.2) 169.95,67.2 172.09,65.06 172.09,61.62 v2(175.17,58.55)
  VCC w0.203: 308.86,67.2 JUSB1.12 ; JUSB1.12 308.86,68.8 ; JUSB1.12 308.86,68 ; JUSB1.12 311.47,68 ; JUSB1.12 311.47,67.2 ; JUSB1.12 310.16,67.2 ; JUSB1.12 311.47,68.8 ; JUSB1.12 310.16,68.8 ; H34.1 14.11,9.8 ; H34.1 9.79,11.45 ; H34.1 14.11,11.45 ; H34.1 9.79,9.8 ; H34.1 9.79,13.1 ; H34.1 14.11,13.1 ; H34.1 11.95,13.1 ; H34.1 11.95,9.8 ; JUSB3.10 15.55,52.35 ; JUSB3.10 16.9,50.75 ; JUSB3.10 16.9,52.35 ; JUSB3.10 16.9,51.55 ; JUSB3.10 15.55,50.75 ; 311.35,60.98 JUSB1.7 ; JUSB1.7 311.16,61.6 ; JUSB1.7 311.35,62.22 ; 322.3,31.98 JSD1.13 ; JSD1.13 321.19,32.68 ; JSD1.13 323.41,31.98 ; JSD1.13 321.19,31.98 ; JSD1.13 323.41,33.37 ; JSD1.13 323.41,32.68 ; JSD1.13 321.19,33.37 ; JSD1.13 322.3,33.37 ; JHDMI1.2 13.66,64.3 ; JHDMI1.2 13.55,63.85 ; JHDMI1.2 12.65,64.75 ; JHDMI1.2 13.1,63.74 ; JHDMI1.2 12.54,64.3 ; JHDMI1.2 13.55,64.75 ; JHDMI1.2 12.65,63.85 ; 4.39,82.56 H10.1 ; H10.1 6.71,82.56 ; H10.1 5.55,82.96 ; H10.1 4.39,80.24 ; H10.1 5.55,79.84 ; H10.1 3.99,81.4 ; H10.1 7.11,81.4 ; H10.1 6.71,80.24 ; 10.89,99.46 H12.1 ; H12.1 10.89,97.14 ; H12.1 10.49,98.3 ; H12.1 12.05,96.74 ; H12.1 13.61,98.3 ; JLOM1.15 324.85,72.45 ; JLOM1.15 323.2,72.45 ; JLOM1.15 321.55,72.45 ; 324.39,46.97 JSD1.12 ; JSD1.12 324.39,46.27 ; JSD1.12 325.5,46.97 ; JSD1.12 325.5,45.58 ; JUSB2.10 16.9,32.05 ; JUSB2.10 16.9,32.85 ; JUSB2.10 15.55,31.25 ; JUSB2.10 16.9,31.25 ; JUSB2.10 15.55,32.85 ; 43.64,10.04 H14.1 ; H14.1 44.8,9.64 ; H14.1 45.96,12.36 ; H14.1 45.96,10.04 ; H14.1 46.36,11.2 ; H14.1 43.64,12.36 ; H14.1 44.8,12.76 ; H14.1 43.24,11.2 ; JHDMI1.22 13.01,61.05 ; JHDMI1.22 11.75,61.9 ; JHDMI1.22 13.01,61.9 ; JHDMI1.22 13.01,60.2 ; JHDMI1.22 11.75,60.2 ; JUSB3.12 16.9,37.95 ; JUSB3.12 16.9,39.55 ; JUSB3.12 15.55,37.95 ; JUSB3.12 16.9,38.75 ; JUSB3.12 15.55,39.55 ; H8.1 272.67,109.88 ; H8.1 269.73,112.82 ; H8.1 272.67,112.82 ; H8.1 271.2,113.36 ; H8.1 269.19,111.35 ; H8.1 273.21,111.35 ; H8.1 271.2,109.34 ; H8.1 269.73,109.88 ; JUSB3.4 16.53,42.23 ; JUSB3.4 15.37,42.23 ; JUSB3.4 15.2,41.65 ; JUSB3.4 15.95,40.9 ; JUSB3.4 15.95,42.4 ; JUSB3.4 15.37,41.07 ; JUSB3.4 16.7,41.65 ; JUSB3.4 16.53,41.07 ; JSD1.10 313.81,31.98 ; JSD1.10 311.59,32.68 ; JSD1.10 313.81,33.37 ; JSD1.10 311.59,33.37 ; JSD1.10 312.7,33.37 ; JSD1.10 313.81,32.68 ; JSD1.10 311.59,31.98 ; 311.59,46.97 JSD1.11 ; JSD1.11 313.81,46.27 ; JSD1.11 313.81,45.58 ; JSD1.11 311.59,46.27 ; JSD1.11 312.7,46.97 ; JSD1.11 313.81,46.97 ; JSD1.11 311.59,45.58 ; JSD1.11 312.7,45.58 ; 5.65,36.65 JUSB3.13 ; JUSB3.13 8.35,36.65 ; JUSB3.13 7,36.65 ; 15.95,21.4 JUSB2.4 ; JUSB2.4 15.37,22.73 ; JUSB2.4 16.53,22.73 ; JUSB2.4 15.95,22.9 ; JUSB2.4 15.2,22.15 ; JUSB2.4 16.53,21.57 ; JUSB2.4 15.37,21.57 ; JUSB2.4 16.7,22.15 ; JUSBC1.3 3.24,96.35 ; JUSBC1.3 2.05,96.35 ; JUSBC1.3 3.24,95.65 ; H22.1 261.76,116.7 ; H22.1 260.2,115.14 ; H22.1 261.36,115.54 ; H22.1 259.04,117.86 ; H22.1 259.04,115.54 ; H22.1 261.36,117.86 ; H22.1 258.64,116.7 ; JHDMI1.17 12.11,71.8 ; JHDMI1.17 12,72.25 ; JHDMI1.17 12,71.35 ; JUSB1.13 320.57,70.1 ; JUSB1.13 318.26,70.1 ; JUSB1.13 319.41,70.1 ; JLOM1.14 319,72.45 ; JLOM1.14 315.7,72.45 ; JLOM1.14 317.35,72.45 ; JUSB2.7 15.2,25.65 ; JUSB2.7 15.03,25.07 ; JUSB2.7 15.03,26.23 ; JLOM1.16 319,100.45 ; JLOM1.16 315.7,100.45 ; JLOM1.16 317.35,100.45 ; JUSB2.13 8.35,17.15 ; JUSB2.13 7,17.15 ; JUSB2.13 5.65,17.15 ; 321.08,9.77 H26.1 ; H26.1 322.3,6.9 ; H26.1 320.65,8.55 ; H26.1 321.08,7.33 ; H26.1 323.52,7.33 ; H26.1 322.3,10.2 ; H26.1 323.95,8.55 ; H26.1 323.52,9.77 ; 2.88,9.77 H23.1 ; H23.1 2.88,7.33 ; H23.1 5.75,8.55 ; H23.1 2.45,8.55 ; H23.1 5.32,9.77 ; H23.1 4.1,10.2 ; H23.1 4.1,6.9 ; H23.1 5.32,7.33 ; JHDMI1.5 12,66.25 ; JHDMI1.5 12,65.35 ; JHDMI1.5 12.11,65.8 ; H19.1 293.76,13.44 ; H19.1 293.76,15.76 ; H19.1 294.16,14.6 ; H19.1 292.6,13.04 ; H19.1 291.44,13.44 ; H19.1 291.04,14.6 ; H19.1 291.44,15.76 ; H19.1 292.6,16.16 ; H9.1 6.71,97.14 ; H9.1 7.11,98.3 ; H9.1 5.55,96.74 ; H9.1 6.71,99.46 ; H9.1 4.39,99.46 ; H9.1 3.99,98.3 ; H9.1 4.39,97.14 ; 304.2,106.64 H21.1 ; H21.1 303.04,107.04 ; H21.1 304.2,109.76 ; H21.1 303.04,109.36 ; H21.1 305.36,109.36 ; H21.1 305.76,108.2 ; H21.1 305.36,107.04 ; H21.1 302.64,108.2 ; 12.65,66.85 JHDMI1.8 ; JHDMI1.8 13.55,66.85 ; JHDMI1.8 13.66,67.3 ; JHDMI1.8 12.65,67.75 ; JHDMI1.8 13.55,67.75 ; JHDMI1.8 12.54,67.3 ; JHDMI1.20 11.75,76.4 ; JHDMI1.20 13.01,76.4 ; JHDMI1.20 13.01,75.55 ; JHDMI1.20 11.75,74.7 ; JHDMI1.20 13.01,74.7 ; JUSB3.7 15.2,45.15 ; JUSB3.7 15.03,44.57 ; JUSB3.7 15.03,45.73 ; JUSB1.10 311.47,56 ; JUSB1.10 308.86,54.4 ; JUSB1.10 311.47,54.4 ; JUSB1.10 310.16,56 ; JUSB1.10 308.86,55.2 ; JUSB1.10 310.16,54.4 ; JUSB1.10 308.86,56 ; JUSB1.10 311.47,55.2 ; JHDMI1.11 12,69.25 ; JHDMI1.11 12.11,68.8 ; JHDMI1.11 12,68.35 ; JLOM1.17 323.2,100.45 ; JLOM1.17 321.55,100.45 ; JLOM1.17 324.85,100.45 ; JUSB1.4 311.08,64.48 ; JUSB1.4 310.46,65.9 ; JUSB1.4 311.27,65.1 ; JUSB1.4 311.08,65.72 ; JUSB1.4 309.66,65.1 ; JUSB1.4 310.46,64.3 ; JUSB1.4 309.85,64.48 ; JUSB1.4 309.85,65.72 ; JUSB2.12 16.9,20.05 ; JUSB2.12 16.9,19.25 ; JUSB2.12 15.55,20.05 ; JUSB2.12 15.55,18.45 ; JUSB2.12 16.9,18.45 ; JUSB3.11 8.35,53.65 ; JUSB3.11 7,53.65 ; JUSB3.11 7.67,53.65 ; JUSBC1.4 3.24,83.35 ; JUSBC1.4 2.05,83.35 ; JUSBC1.4 3.24,84.05 ; 1.75,78.05 JHDMI1.21 ; JHDMI1.21 5.05,78.05 ; JHDMI1.21 3.4,78.05 ; JUSB2.11 7,34.15 ; JUSB2.11 5.65,34.15 ; JUSB2.11 8.35,34.15
  GND2 w0.203: JSD1.13 323.41,33.37 ; JSD1.13 321.19,32.68 ; JSD1.13 321.19,33.37 ; JSD1.13 323.41,32.68 ; JSD1.13 321.19,31.98 ; JSD1.13 322.3,31.98 ; JSD1.13 322.3,33.37 ; JSD1.13 323.41,31.98 ; 14.2,37.95 JUSB3.12 ; JUSB3.12 15.55,37.95 ; JUSB3.12 16.9,37.95 ; JUSB3.12 14.2,39.55 ; JUSB3.12 15.55,39.55 ; JUSB3.12 16.9,39.55 ; JUSB3.12 14.2,38.75 ; JUSB3.12 16.9,38.75 ; 251.75,70.9 H30.1 ; H30.1 251.14,69.25 ; H30.1 255.66,69.25 ; H30.1 251.75,67.6 ; H30.1 253.4,66.99 ; H30.1 253.4,71.51 ; H30.1 255.05,67.6 ; H30.1 255.05,70.9 ; 9.79,13.1 H34.1 ; H34.1 14.11,9.8 ; H34.1 9.79,9.8 ; H34.1 11.95,9.8 ; H34.1 14.11,13.1 ; H34.1 9.79,11.45 ; H34.1 14.11,11.45 ; H34.1 11.95,13.1 ; SW1.4 238.31,53.68 ; SW1.4 236.83,52.19 ; SW1.4 237.57,53.92 ; SW1.4 237.57,51.96 ; SW1.4 238.31,52.19 ; SW1.4 236.59,52.94 ; SW1.4 236.83,53.68 ; SW1.4 238.55,52.94 ; 12.05,96.74 H12.1 ; H12.1 13.21,97.14 ; H12.1 10.49,98.3 ; H12.1 10.89,99.46 ; H12.1 10.89,97.14 ; H12.1 13.21,99.46 ; H12.1 13.61,98.3 ; H12.1 12.05,99.86 ; JUSB1.13 319.41,70.1 ; JUSB1.13 320.57,69.3 ; JUSB1.13 318.26,69.3 ; JUSB1.13 320.57,70.1 ; JUSB1.13 318.26,70.1 ; JHDMI1.20 13.01,75.55 ; JHDMI1.20 10.49,76.4 ; JHDMI1.20 13.01,76.4 ; JHDMI1.20 13.01,74.7 ; JHDMI1.20 10.49,74.7 ; JHDMI1.20 11.75,76.4 ; JHDMI1.20 11.75,74.7 ; 308.86,56 JUSB1.10 ; JUSB1.10 308.86,54.4 ; JUSB1.10 310.16,56 ; JUSB1.10 311.47,54.4 ; JUSB1.10 310.16,54.4 ; JUSB1.10 308.86,55.2 ; JUSB1.10 311.47,55.2 ; JUSB1.10 311.47,56 ; 311.59,33.37 JSD1.10 ; JSD1.10 311.59,32.68 ; JSD1.10 313.81,31.98 ; JSD1.10 311.59,31.98 ; JSD1.10 313.81,33.37 ; JSD1.10 313.81,32.68 ; JSD1.10 312.7,33.37 ; JHDMI1.5 12.11,65.8 ; JHDMI1.5 11.1,66.25 ; JHDMI1.5 12,65.35 ; JHDMI1.5 10.99,65.8 ; JHDMI1.5 12,66.25 ; JHDMI1.5 11.1,65.35 ; 15.55,31.25 JUSB2.10 ; JUSB2.10 14.2,31.25 ; JUSB2.10 16.9,32.85 ; JUSB2.10 15.55,32.85 ; JUSB2.10 14.2,32.85 ; JUSB2.10 14.2,32.05 ; JUSB2.10 16.9,32.05 ; JUSB2.10 16.9,31.25 ; 10.99,71.8 JHDMI1.17 ; JHDMI1.17 11.1,72.25 ; JHDMI1.17 11.1,71.35 ; JHDMI1.17 12.11,71.8 ; JHDMI1.17 12,72.25 ; JHDMI1.17 12,71.35 ; 14.45,24.9 JUSB2.7 ; JUSB2.7 15.2,25.65 ; JUSB2.7 15.03,26.23 ; JUSB2.7 13.87,26.23 ; JUSB2.7 14.45,26.4 ; JUSB2.7 13.87,25.07 ; JUSB2.7 15.03,25.07 ; H7.1 255,46.56 ; H7.1 253.53,46.02 ; H7.1 252.99,44.55 ; H7.1 256.47,46.02 ; H7.1 253.53,43.08 ; H7.1 257.01,44.55 ; H7.1 255,42.54 ; H7.1 256.47,43.08 ; H28.1 162.7,117.6 ; H28.1 165.61,112.8 ; H28.1 159.79,115.2 ; H28.1 159.79,112.8 ; H28.1 159.79,117.6 ; H28.1 165.61,115.2 ; H28.1 165.61,117.6 ; H28.1 162.7,112.8 ; JUSB2.4 16.53,22.73 ; JUSB2.4 15.2,22.15 ; JUSB2.4 15.37,21.57 ; JUSB2.4 15.95,22.9 ; JUSB2.4 16.53,21.57 ; JUSB2.4 16.7,22.15 ; JUSB2.4 15.37,22.73 ; JUSB2.4 15.95,21.4 ; JUSB2.12 16.9,20.05 ; JUSB2.12 14.2,19.25 ; JUSB2.12 16.9,18.45 ; JUSB2.12 15.55,20.05 ; JUSB2.12 16.9,19.25 ; JUSB2.12 15.55,18.45 ; JUSB2.12 14.2,20.05 ; JUSB2.12 14.2,18.45 ; JHDMI1.2 13.55,64.75 ; JHDMI1.2 12.54,64.3 ; JHDMI1.2 12.65,64.75 ; JHDMI1.2 13.1,63.74 ; JHDMI1.2 13.55,63.85 ; JHDMI1.2 12.65,63.85 ; JHDMI1.2 13.66,64.3 ; JUSBC1.4 3.24,83.35 ; JUSBC1.4 2.05,84.75 ; JUSBC1.4 0.86,84.75 ; JUSBC1.4 0.86,83.35 ; JUSBC1.4 0.86,84.05 ; JUSBC1.4 3.24,84.75 ; JUSBC1.4 2.05,83.35 ; JUSBC1.4 3.24,84.05 ; 15.37,42.23 JUSB3.4 ; JUSB3.4 16.7,41.65 ; JUSB3.4 15.37,41.07 ; JUSB3.4 15.95,40.9 ; JUSB3.4 16.53,41.07 ; JUSB3.4 15.95,42.4 ; JUSB3.4 15.2,41.65 ; JUSB3.4 16.53,42.23 ; SW1.5 244,56.09 ; SW1.5 242.28,56.83 ; SW1.5 243.77,55.34 ; SW1.5 243.03,55.11 ; SW1.5 243.77,56.83 ; SW1.5 242.05,56.09 ; SW1.5 242.28,55.34 ; SW1.5 243.03,57.07 ; JHDMI1.21 3.4,78.05 ; JHDMI1.21 1.75,77.05 ; JHDMI1.21 5.05,77.05 ; JHDMI1.21 5.05,78.05 ; JHDMI1.21 1.75,78.05 ; 321.55,100.45 JLOM1.17 ; JLOM1.17 323.2,100.45 ; JLOM1.17 324.85,99.65 ; JLOM1.17 321.55,99.65 ; JLOM1.17 324.85,100.45 ; 5.14,84.35 JUSBC1.2 ; JUSBC1.2 7.41,84.35 ; JUSBC1.2 7.41,85.05 ; JUSBC1.2 6.28,84.35 ; JUSB3.13 8.35,37.45 ; JUSB3.13 5.65,37.45 ; JUSB3.13 8.35,36.65 ; JUSB3.13 5.65,36.65 ; JUSB3.13 7,36.65 ; H10.1 7.11,81.4 ; H10.1 6.71,80.24 ; H10.1 4.39,80.24 ; H10.1 3.99,81.4 ; H10.1 5.55,82.96 ; H10.1 6.71,82.56 ; H10.1 5.55,79.84 ; H10.1 4.39,82.56 ; 15.55,50.75 JUSB3.10 ; JUSB3.10 14.2,50.75 ; JUSB3.10 16.9,52.35 ; JUSB3.10 14.2,51.55 ; JUSB3.10 16.9,51.55 ; JUSB3.10 16.9,50.75 ; JUSB3.10 14.2,52.35 ; JUSB3.10 15.55,52.35 ; 269.73,112.82 H8.1 ; H8.1 273.21,111.35 ; H8.1 271.2,113.36 ; H8.1 272.67,109.88 ; H8.1 271.2,109.34 ; H8.1 269.19,111.35 ; H8.1 269.73,109.88 ; H8.1 272.67,112.82 ; 94.94,90.56 H1.1 ; H1.1 97.96,87.54 ; H1.1 98.51,89.05 ; H1.1 96.45,91.11 ; H1.1 96.45,86.99 ; H1.1 94.39,89.05 ; H1.1 94.94,87.54 ; H1.1 97.96,90.56 ; 311.59,45.58 JSD1.11 ; JSD1.11 312.7,46.97 ; JSD1.11 312.7,45.58 ; JSD1.11 313.81,45.58 ; JSD1.11 313.81,46.27 ; JSD1.11 311.59,46.97 ; JSD1.11 313.81,46.97 ; JSD1.11 311.59,46.27 ; JLOM1.15 324.85,73.25 ; JLOM1.15 321.55,73.25 ; JLOM1.15 324.85,72.45 ; JLOM1.15 323.2,72.45 ; JLOM1.15 321.55,72.45 ; 325.5,45.58 JSD1.12 ; JSD1.12 324.39,46.27 ; JSD1.12 324.39,46.97 ; JSD1.12 325.5,46.97 ; JHDMI1.22 11.75,61.9 ; JHDMI1.22 13.01,61.9 ; JHDMI1.22 13.01,61.05 ; JHDMI1.22 10.49,60.2 ; JHDMI1.22 11.75,60.2 ; JHDMI1.22 10.49,61.9 ; JHDMI1.22 13.01,60.2 ; 153.49,66.55 H2.1 ; H2.1 154.04,65.04 ; H2.1 157.06,68.06 ; H2.1 157.61,66.55 ; H2.1 157.06,65.04 ; H2.1 154.04,68.06 ; H2.1 155.55,68.61 ; H2.1 155.55,64.49 ; 308.86,67.2 JUSB1.12 ; JUSB1.12 308.86,68 ; JUSB1.12 308.86,68.8 ; JUSB1.12 311.47,68.8 ; JUSB1.12 310.16,68.8 ; JUSB1.12 311.47,67.2 ; JUSB1.12 310.16,67.2 ; JUSB1.12 311.47,68 ; 320.65,8.55 H26.1 ; H26.1 323.52,7.33 ; H26.1 322.3,10.2 ; H26.1 321.08,7.33 ; H26.1 322.3,6.9 ; H26.1 323.52,9.77 ; H26.1 323.95,8.55 ; H26.1 321.08,9.77 ; 315.7,73.25 JLOM1.14 ; JLOM1.14 319,73.25 ; JLOM1.14 319,72.45 ; JLOM1.14 315.7,72.45 ; JLOM1.14 317.35,72.45 ; 43.64,12.36 H14.1 ; H14.1 43.24,11.2 ; H14.1 46.36,11.2 ; H14.1 44.8,9.64 ; H14.1 45.96,10.04 ; H14.1 43.64,10.04 ; H14.1 44.8,12.76 ; H14.1 45.96,12.36 ; H31.1 194.35,100.9 ; H31.1 191.05,100.9 ; H31.1 192.7,100.29 ; H31.1 192.7,104.81 ; H31.1 194.96,102.55 ; H31.1 194.35,104.2 ; H31.1 190.44,102.55 ; H31.1 191.05,104.2 ; 292.6,13.04 H19.1 ; H19.1 291.04,14.6 ; H19.1 294.16,14.6 ; H19.1 291.44,15.76 ; H19.1 291.44,13.44 ; H19.1 293.76,13.44 ; H19.1 292.6,16.16 ; H19.1 293.76,15.76 ; H15.1 53.26,116.7 ; H15.1 51.7,118.26 ; H15.1 51.7,115.14 ; H15.1 50.54,117.86 ; H15.1 50.54,115.54 ; H15.1 52.86,115.54 ; H15.1 52.86,117.86 ; H15.1 50.14,116.7 ; 2.88,9.77 H23.1 ; H23.1 5.32,9.77 ; H23.1 5.75,8.55 ; H23.1 2.88,7.33 ; H23.1 4.1,6.9 ; H23.1 2.45,8.55 ; H23.1 4.1,10.2 ; H23.1 5.32,7.33 ; H9.1 6.71,97.14 ; H9.1 4.39,99.46 ; H9.1 5.55,99.86 ; H9.1 4.39,97.14 ; H9.1 7.11,98.3 ; H9.1 5.55,96.74 ; H9.1 3.99,98.3 ; H9.1 6.71,99.46 ; H3.1 98.51,66.55 ; H3.1 96.45,64.49 ; H3.1 97.96,68.06 ; H3.1 94.94,65.04 ; H3.1 94.94,68.06 ; H3.1 97.96,65.04 ; H3.1 94.39,66.55 ; H3.1 96.45,68.61 ; JHDMI1.11 12,69.25 ; JHDMI1.11 10.99,68.8 ; JHDMI1.11 12,68.35 ; JHDMI1.11 11.1,69.25 ; JHDMI1.11 12.11,68.8 ; JHDMI1.11 11.1,68.35 ; JUSBC1.1 7.41,94.65 ; JUSBC1.1 6.28,93.95 ; JUSBC1.1 7.41,95.35 ; JUSBC1.1 6.28,95.35 ; JUSBC1.1 5.14,95.35 ; 315.7,100.45 JLOM1.16 ; JLOM1.16 319,99.65 ; JLOM1.16 319,100.45 ; JLOM1.16 317.35,100.45 ; JLOM1.16 315.7,99.65 ; JHDMI1.23 5.05,58.55 ; JHDMI1.23 3.4,58.55 ; JHDMI1.23 5.05,59.55 ; JHDMI1.23 1.75,58.55 ; JHDMI1.23 1.75,59.55 ; JUSB3.7 15.03,44.57 ; JUSB3.7 14.45,45.9 ; JUSB3.7 13.87,45.73 ; JUSB3.7 15.03,45.73 ; JUSB3.7 14.45,44.4 ; JUSB3.7 15.2,45.15 ; JUSB3.7 13.87,44.57 ; JUSB1.7 312.58,62.22 ; JUSB1.7 311.35,62.22 ; JUSB1.7 311.97,60.8 ; JUSB1.7 312.58,60.98 ; JUSB1.7 311.97,62.4 ; JUSB1.7 311.16,61.6 ; JUSB1.7 311.35,60.98 ; 310.46,64.3 JUSB1.4 ; JUSB1.4 310.46,65.9 ; JUSB1.4 311.08,64.48 ; JUSB1.4 309.66,65.1 ; JUSB1.4 309.85,64.48 ; JUSB1.4 311.27,65.1 ; JUSB1.4 311.08,65.72 ; JUSB1.4 309.85,65.72 ; JUSB2.13 8.35,17.15 ; JUSB2.13 5.65,17.95 ; JUSB2.13 8.35,17.95 ; JUSB2.13 5.65,17.15 ; JUSB2.13 7,17.15 ; 303.04,109.36 H21.1 ; H21.1 303.04,107.04 ; H21.1 305.76,108.2 ; H21.1 304.2,106.64 ; H21.1 304.2,109.76 ; H21.1 305.36,107.04 ; H21.1 302.64,108.2 ; H21.1 305.36,109.36 ; 153.49,89.05 H4.1 ; H4.1 157.06,90.56 ; H4.1 157.61,89.05 ; H4.1 154.04,90.56 ; H4.1 154.04,87.54 ; H4.1 155.55,91.11 ; H4.1 157.06,87.54 ; H4.1 155.55,86.99 ; 318.26,53.1 JUSB1.11 ; JUSB1.11 318.26,53.9 ; JUSB1.11 319.41,53.1 ; JUSB1.11 320.57,53.1 ; JUSB1.11 320.57,53.9 ; 12.65,66.85 JHDMI1.8 ; JHDMI1.8 13.55,66.85 ; JHDMI1.8 13.55,67.75 ; JHDMI1.8 13.66,67.3 ; JHDMI1.8 12.65,67.75 ; JHDMI1.8 12.54,67.3 ; H22.1 261.36,117.86 ; H22.1 261.76,116.7 ; H22.1 260.2,118.26 ; H22.1 260.2,115.14 ; H22.1 259.04,117.86 ; H22.1 261.36,115.54 ; H22.1 259.04,115.54 ; H22.1 258.64,116.7 ; JUSB3.11 8.35,53.65 ; JUSB3.11 5.65,53.65 ; JUSB3.11 8.35,52.85 ; JUSB3.11 7,53.65 ; JUSB3.11 5.65,52.85 ; 0.86,94.95 JUSBC1.3 ; JUSBC1.3 3.24,94.95 ; JUSBC1.3 0.86,96.35 ; JUSBC1.3 3.24,95.65 ; JUSBC1.3 3.24,96.35 ; JUSBC1.3 0.86,95.65 ; JUSBC1.3 2.05,94.95 ; JUSBC1.3 2.05,96.35 ; JUSB2.11 7,34.15 ; JUSB2.11 8.35,33.35 ; JUSB2.11 8.35,34.15 ; JUSB2.11 5.65,33.35 ; JUSB2.11 5.65,34.15
  BOTTOM w0.102: 124.19,86.07 124.19,86.45 123.63,87.01 123.39,87.01 123.37,87.03 123.37,87.03 123.21,87.19 123.21,87.44 123.23,87.46 123.23,88.13 123.39,88.29 123.72,88.29 124.01,88.58 v2(124.01,89.66) ; v2(209.09,41.96) 209.6,41.96 v1(210.14,42.5) ; PC903.2 50.48,79.57 v1(49.28,79.57) ; PC424.2 175.55,109.44 v1(175.17,109.82) ; v2(28.78,46.37) 28.78,45.61 v1(28.42,45.26)
  BOTTOM w0.127: 54.03,62.74 52.88,62.74 v1(52.73,62.9) ; v2(138.66,75.92) 138.66,75.93 138.72,75.87 138.86,75.87 139.21,75.52 139.21,75.15 139.39,74.97 139.85,74.97 UC1.AF10 ; PC504.2 158.45,104.73 v1(158.68,104.96) ; 88.74,89.9 PC1141.2 89.87,89.9 v1(90.24,90.26) ; v2(11.08,93.14) v1(10.37,93.14)
  BOTTOM w0.178: v2(109.24,65.42) 109.31,65.49 109.31,65.78 UC1.BB64 ; v2(104.11,69.79) 104.29,69.79 UC1.AT71 ; UC1.H71 104.29,84.4 104.23,84.4 v2(103.86,84.77) ; v2(135.14,65.39) 135.11,65.42 UC1.BB18 ; UC1.BB38 124.04,66.3 124.04,65.35 v2(124.07,65.33) ; v2(129.14,65.14) 129.01,65.27 129.01,65.66 UC1.BB30 ; v2(114.3,65.4) 114.26,65.44 114.26,65.92 UC1.BB55 ; UC1.AM71 104.93,72.14 104.18,72.14 v2(104.12,72.09)
  BOTTOM w0.203: v2(146.12,75.14) 146.06,75.21 145.24,75.21 UC1.AF1 ; UC1.D34 125.33,86.62 125.86,86.09 125.86,85.62 UC1.F35 ; UC1.AL48 v2(118.62,73.54) ; UC1.AF63 110.19,75.05 110.19,74.34 UC1.AH63 ; v2(119.48,112.07) 119.5,112.04 119.5,111.25 119.07,110.82 UV7.52 ; UC1.AD21 133.6,76.58 134.03,76.58 UC1.AD20 ; UC1.AH67 107.49,74.17 107.24,73.93 v2(107.24,73.81) 106.9,73.47 UC1.AK68 106.84,73.4 107.25,72.99 107.25,72.72 107.16,72.63 UC1.AM68 ; UC1.F40 v2(123.19,84.84) UC1.F38 ; v2(104.09,86.61) 104.39,86.61 104.79,86.2 UC1.E71 ; v2(146.03,87.2) 145.96,87.2 UC1.C1 ; UC1.AL45 v2(120.45,73.5) ; UC1.AM68 107.35,72.24 v2(107.65,71.94) ; UC1.AM68 107.16,71.76 107.19,71.73 107.19,71.43 107.16,71.4 UC1.AP68 107.16,70.53 107.19,70.5 107.19,70.21 107.16,70.18 UC1.AT68 107.16,69.37 107.21,69.2 107.21,69.02 107.16,68.97 107.16,68.6 UC1.AV68 ; PU613.3 v2(62.23,66.8) ; v2(273.4,67.98) 272.95,67.53 JNGFF2.37 ; v2(106.82,65.22) 106.84,65.24 106.84,65.28 107.3,65.74 UC1.BB67 ; UC1.BA66 UC1.AY66 v2(107.65,68.13) 107.2,68.59 UC1.AV68 ; UC1.AV68 106.88,68.59 v2(106.69,68.4) ; v2(146.37,68.79) 146.18,68.79 145.86,68.47 UC1.AV1 ; UC1.F1 145.64,85.77 v2(145.72,85.85) ; UC1.AW66 108.19,68.31 109.16,68.31 UC1.AW64 109.69,68.26 109.72,68.29 110.02,68.29 110.05,68.26 UC1.AW62 110.92,68.26 110.95,68.29 111.24,68.29 111.27,68.26 UC1.AW60 112.15,68.26 112.18,68.29 112.47,68.29 112.5,68.26 UC1.AW57 113.42,68.26 113.45,68.29 113.75,68.29 113.78,68.26 UC1.AW55 114.65,68.26 114.68,68.29 114.97,68.29 115,68.26 UC1.AW53 115.87,68.26 115.9,68.29 116.2,68.29 116.23,68.26 UC1.AW51 117.04,68.26 117.07,68.29 117.36,68.29 117.39,68.26 UC1.AW49 118.3,68.26 118.33,68.3 118.62,68.3 118.65,68.26 UC1.AW47 119.46,68.26 119.49,68.29 119.79,68.29 119.82,68.26 UC1.AW45 120.69,68.26 120.72,68.29 120.98,68.29 121.01,68.29 121.05,68.25 121.52,68.25 UC1.AW43 ; v2(124.99,90.1) 124.99,88.47 124.99,88.47 124.99,87.96 125.31,87.64 UC1.B34 ; 124.19,86.07 124.19,85.73 124.57,85.35 UC1.F37 ; UC1.BA1 UC1.BA2 ; UC1.AK27 v2(130.05,74.24) ; v2(123.25,68.77) 123.75,68.26 UC1.AW38 124.42,68.26 124.45,68.29 124.74,68.29 124.77,68.26 UC1.AW36 125.64,68.26 125.67,68.29 125.97,68.29 126,68.26 UC1.AW34 126.48,68.41 v2(126.83,68.75) 127.32,68.26 UC1.AW32 128.17,68.26 128.2,68.29 128.5,68.29 128.53,68.26 UC1.AW30 129.4,68.26 129.43,68.29 129.72,68.29 129.75,68.26 UC1.AW28 130.62,68.26 130.65,68.29 130.95,68.29 130.98,68.26 UC1.AW26 131.85,68.26 131.88,68.29 132.18,68.29 132.21,68.26 UC1.AW23 133.18,68.26 133.21,68.29 133.5,68.29 133.53,68.26 UC1.AW21 134.32,68.26 134.35,68.29 134.65,68.29 134.68,68.26 UC1.AW18 135.6,68.26 135.63,68.29 135.92,68.29 135.95,68.26 UC1.AW16 136.43,68.26 v2(136.92,68.76) 137.42,68.26 UC1.AW14 138.02,68.26 138.05,68.29 138.74,68.29 UC1.AW12 139.15,68.26 v2(139.65,68.77) 139.95,68.47 UC1.AW10 140.44,68.26 140.47,68.29 140.76,68.29 140.79,68.26 UC1.AW8 ; UC1.J35 v2(125.02,83.44) ; UV7.11 v2(113.73,105.82) ; v2(130.51,83.36) UC1.J25 ; UC1.J38 v2(123.19,83.44) ; UC1.D48 UC1.D47 118.57,86.66 118.96,86.66 118.98,86.63 119.27,86.63 119.3,86.66 119.68,86.66 UC1.D45 UC1.D44 ; UC1.AL52 v2(116.79,73.57) ; UC1.AL58 v2(113.14,73.55) ; UC1.J28 v2(128.68,84.91) ; UC1.AL66 108.23,72.46 108.28,72.41 108.66,72.41 108.7,72.46 UC1.AL65 108.87,72.46 108.91,72.41 109.29,72.41 109.34,72.46 UC1.AL64 ; UV7.19 v2(110.53,105.82) ; UC1.G10 v2(139.65,84.84) ; UC1.AL55 v2(114.96,73.52) ; UC1.J32 v2(126.85,83.44)
  BOTTOM w0.254: v2(43.33,68.9) 43.11,68.9 42.69,69.32 PC1216.2 ; v2(126.98,97.32) 127.82,97.32 v2(127.93,97.2) 128.01,97.2 128.3,97.49 128.3,100.8 128.07,101.02 124.36,101.02 124.02,100.68 124.02,97.59 124.27,97.33 124.54,97.33 ; UC1.J13 v2(138.74,83.57) UC1.J11 ; v2(136.92,68.76) 137.37,69.08 UC1.AU15 ; v2(132.33,84.84) 132.59,84.59 UC1.G22 ; v2(132.33,84.84) 132.28,84.84 UC1.F23 ; v2(132.33,84.84) 132.4,84.84 UC1.F22 ; v2(68,116.35) 68.2,116.55 JEDP1.20 ; UC1.AU32 127.28,69.1 v2(126.83,68.75) ; UC1.AW10 v2(139.95,67.75) UC1.BA10 ; UC1.AB16 v2(137.08,77.73) UC1.AB15 ; v2(141.77,82.18) UC1.L8 ; v2(116.81,86.12) 116.79,86.12 UC1.E50 ; v2(140.59,70.12) 140.75,70.12 UC1.AR8 ; JDIMM2.36 134.17,26.52 ; UC1.AM45 v2(119.51,71.94) ; UC1.K61 110.37,83.66 UC1.K63 v2(109.74,82.95) 109.42,83.28 UC1.K64 ; JEDP1.39 77.7,116.82 78.11,116.41 v2(78.11,115.79) ; UC1.AR58 v2(112.22,70.04) UC1.AT58 ; UC1.AW62 v2(110.48,67.75) UC1.BA62 ; UC1.BA28 v2(130.19,67.75) UC1.AW28 ; UC1.G63 v2(109.38,84.84) ; UC1.BA14 v2(137.53,67.6) UC1.AW14 ; UC1.AP23 v2(131.42,70.67) ; v2(109.74,73.78) UC1.AH63 ; v2(109.74,73.78) UC1.AK63 110.09,73.28 110.83,72.34 UC1.AM61 110.93,72.44 111.68,72.44 UC1.AM60 ; v2(109.74,73.78) UC1.AH64 ; UC1.K65 108.77,83.28 v2(108.44,82.95) ; UC1.F35 125.09,84.85 v2(125.07,84.85) 124.68,85.24 UC1.F37 ; UC1.L2 144.23,83.11 v2(144.05,82.94) 143.87,83.11 UC1.L4 ; v2(173.33,82.61) 172.89,83.05 UZ12.23 ; UC1.W13 138.23,78.5 138.18,78.45 v2(138.18,77.99) ; DT11.2 13.87,90.66 v2(13.93,90.72) ; v2(139.65,68.77) UC1.AU10 ; UC1.AD21 UC1.AB21 133.49,77.4 v2(133.16,77.73) 133.16,77.82 UC1.Y21 UC1.Y20 ; UC1.AN30 v2(128.68,71.31) UC1.AN28 ; CE36.2 242.4,37.95 v2(241.89,37.43) ; JNGFF2.63 279.45,67.01 v2(279.69,67.24) 279.7,67.24 279.95,66.99 JNGFF2.65 ; JDEG1.10 298.51,74.14 v2(298.33,74.32) ; UC1.K22 132.67,83.66 v2(132.28,83.27) ; UC1.R13 138.12,80.63 v2(137.66,81.1) 138.23,81.68 UC1.N13 ; UC1.AK16 v2(136.91,72.58) ; UC1.AD62 111.03,76.52 v2(111.08,76.53) ; v2(11.08,93.14) 11.19,93.04 DT5.2 ; UC1.BA41 v2(122.73,67.75) UC1.AW41 ; UC1.BA23 v2(132.67,67.79) UC1.AW23 ; DT9.2 11.12,87.13 v2(11.02,87.23) ; DT9.2 v2(11.64,87.66) ; DT9.2 12.1,87.13 v2(12.23,87.26) ; UC1.AK69 106.17,73.47 106.35,73.65 106.66,73.65 UC1.AK68 ; v2(141.11,73.8) 141.49,73.42 UC1.AK8 141.49,72.81 UC1.AM8 ; JEDP1.22 69.2,116.66 68.99,116.45 v2(68.99,116.43) 69.01,116.4 69.55,116.4 69.7,116.55 JEDP1.23 ; UC1.AW53 v2(115.44,67.75) UC1.BA53 ; UC1.AN38 v2(124.11,71.31) UC1.AN37 ; v2(133.29,86.15) 133.32,86.18 133.34,86.18 133.63,85.89 UC1.E21 ; UC1.AR52 v2(116.79,70.04) UC1.AR50 ; UC1.F28 129.44,85.54 v2(129.52,85.54) 129.75,85.54 UC1.F27 ; UC1.AT35 v2(125.02,70.04) UC1.AR35 ; UC1.F42 121.71,85.24 v2(121.34,84.87) 121.16,84.87 120.91,84.62 UC1.G43 ; CC21.2 123.46,96.07 123.46,95.19 124.5,94.15 124.5,90.78 124.19,90.47 124.19,90.44 124.18,90.43 124.18,89.83 v2(124.01,89.66) ; v2(274.52,67.35) 274.45,67.29 JNGFF2.43 ; JEDP1.10 63.2,116.63 v2(63.45,116.38) ; UC1.AK18 135.25,73.3 135.25,73.38 v2(135.13,73.5) 135.13,73.65 UC1.AJ18 135.44,74.14 UC1.AG17 136.09,74.84 ; v2(72.06,115.46) 72.2,115.6 JEDP1.28 ; PR427.2 186.01,113.29 PU401.6 ; JNGFF2.31 271.45,67.32 271.54,67.41 v2(271.54,67.63) ; v2(115.89,84.92) 116.13,84.8 UC1.G52 ; UC1.AR11 139.27,70.4 139.66,70.79 v2(139.67,70.79) 140,71.06 UC1.AP10 ; UC1.AP38 v2(123.19,70.67) ; UC1.B34 125.44,87.52 v2(125.44,87.13) 125.45,87.12 125.45,86.76 UC1.D34 ; UC1.C5 142.92,87.31 v2(142.77,87.17) 142.64,87.04 UC1.D6 ; v2(11.64,85.03) DT10.2 ; DT10.2 11.24,85.56 10.99,85.3 v2(10.99,85.06) ; DT10.2 12.13,85.56 12.26,85.43 v2(12.26,85.06) ; DV7.2 53.86,110.83 v2(54.64,111.61) ; UC1.J8 140.5,83.62 v2(140.49,83.62) ; UC1.AK11 139.04,72.8 v2(138.89,72.8) 138.73,72.8 UC1.AM13 ; UC1.AM27 v2(129.6,71.96) ; UC1.AD13 138.31,76.36 v2(138.66,75.92) ; PR428.2 169.75,111.12 PU402.6 ; UC1.AR23 v2(131.42,70.04) UC1.AT23 ; UC1.AN40 v2(122.28,71.31) 121.89,71.7 UC1.AN42 ; UC1.B30 v2(127.8,87.14) UC1.D30 ; v2(71.19,75.85) 71.12,75.79 71.12,75.66 70.26,74.8 PU612.3 ; UC1.AY71 v2(104.16,67.1) ; UC1.AN58 v2(112.22,71.31) ; UC1.B22 v2(132.75,87.11) UC1.D22 ; UC1.T15 137.08,79.51 v2(137.08,79.4) UC1.V16 UC1.Y17 ; UC1.L11 v2(139.87,82.18) 139.87,82.02 UC1.N10 ; UC1.AP68 v2(106.55,70.97) UC1.AP70 ; UD1.3 84.55,62.61 84.2,62.96 ; UC1.G58 v2(112.22,84.84) 111.97,84.59 UC1.G60 ; v2(120.16,113.35) 120.51,113 122.39,113 122.66,112.73 CV82.2 122.7,112.44 CV81.2 ; UC1.AF1 UC1.AF2 144.25,75.45 143.85,75.45 UC1.AF4 ; UC1.AP35 v2(125.02,70.67) ; v2(142.37,67.75) 142.62,68 143.13,68 143.38,67.75 v2(143.39,67.75) 143.51,67.64 143.7,67.64 144.07,67.27 UC1.AY3 UC1.BA2 ; v2(142.37,67.75) UC1.BA6 UC1.BB6 ; v2(142.37,67.75) 142.33,67.8 UC1.AW6 ; UC1.G48 v2(117.71,84.84) ; UC1.K71 UC1.K70 106.3,83.04 v2(106.4,82.94) 106.64,82.94 UC1.K68 107.26,83.15 UC1.K67 107.47,83.27 v2(107.85,82.89) 107.85,83.08 UC1.K66 ; UC1.AM55 114.47,72.35 v2(114.08,72.02) ; UC1.J42 v2(121.37,83.5) ; CC10.2 179.53,84.19 179.53,84.2 v2(179.57,84.2) ; UC1.AM25 v2(130.51,71.96) ; UC1.AH13 138.23,74.05 v2(137.74,73.55) 137.39,73.9 UC1.AJ15 137.09,74.26 137.09,74.39 136.74,74.74 UC1.AG16 UC1.AF15 ; DT15.2 11.83,90.81 v2(11.71,90.93) DT6.2 ; UC1.BA57 v2(112.96,67.75) UC1.AW57 ; UC1.AP58 v2(112.22,70.67) ; UC1.P20 134.17,80.66 v2(134.5,81.1) 134.79,81.46 UC1.N19 v2(135.12,81.92) UC1.L18 ; UC1.N68 106.84,81.45 v2(107.14,81.15) ; UC1.T17 135.94,79.68 135.59,79.68 UC1.T18 v2(135.13,80.24) UC1.P19 ; UC1.AP18 135.52,71.03 v2(135.08,70.67) 135,70.67 UC1.AP20 ; JNGFF2.49 275.95,66.63 v2(276.25,66.92) ; UC1.E53 115.37,85.94 115.37,86.58 UC1.D53 v2(115.41,87.14) UC1.B53 ; PC604.2 49.09,74.86 49.38,75.15 v2(50.01,75.15) ; UZ12.16 171.36,87.32 171.58,87.53 172.21,87.53 172.53,87.85 CZ55.2 ; UC1.A70 UC1.B71 104.57,88.46 v2(104.37,88.46) ; UC1.AP32 v2(126.85,70.67) ; UC1.AD8 141.01,75.89 v2(141,75.89) ; UC1.AP42 v2(121.37,70.67) UC1.AR43 ; DT5.2 12.16,93.04 12.38,93.25 v2(12.38,93.5) ; DT5.2 v2(11.71,93.57) ; v2(268.45,67.56) JNGFF2.19 ; v2(287.11,35.62) 287.44,35.3 JNGFF1.1 ; UC1.AL4 143.87,72.51 v2(144.05,72.33) 144.23,72.51 UC1.AL2 ; v2(120.44,71.95) 120.5,71.95 120.9,72.35 UC1.AM43 ; RV97.2 108.71,104.86 CV84.2 ; UC1.AL28 v2(129.6,73.52) ; 134.65,68.29 134.62,68.32 UC1.AU20 v2(134.17,69.4) UC1.AT20 ; UC1.AU38 123.65,69.07 v2(123.25,68.77) ; v2(107.14,77.46) 106.84,77.77 UC1.AA68 ; UC1.B14 v2(137.71,87.15) UC1.D14 ; UC1.AR46 v2(119.54,70.04) UC1.AR45 ; UC1.AL32 v2(127.77,73.52) ; UC1.AB18 135.77,76.89 136.32,76.89 UC1.AD16 v2(136.43,76.05) 136.09,75.71 UC1.AF17 UC1.AG18 135.34,74.7 134.89,74.7 UC1.AG19 UC1.AG20 134.14,74.64 v2(133.81,74.32) ; UC1.AM21 133.97,72.35 UC1.AN20 134.61,71.7 v2(134.18,71.27) ; UC1.E18 135.54,86.32 UC1.D18 v2(135.23,87.11) UC1.B18 ; UC1.D26 130.32,86.66 UC1.D25 UC1.C25 130.59,87.31 v2(130.47,87.19) ; UC1.D48 UC1.B48 ; v2(106.11,86.27) 106.11,86.27 UC1.D69 UC1.F68 ; v2(136.91,84.19) 136.95,84.19 137.2,83.94 UC1.H15 ; UC1.BA18 v2(135.11,67.54) UC1.AW18 ; UC1.U69 106.19,79.59 v2(105.86,79.27) 105.54,79.59 UC1.U70 ; v2(104.16,68.22) 104.34,68.4 UC1.AV71 UC1.AV70 UC1.AV69 v2(106.69,68.4) ; UC1.D39 122.84,87.09 v2(122.83,87.11) 122.84,87.12 UC1.B39 ; v2(109.12,81.15) 108.79,81.48 UC1.N65 ; UC1.AN63 109.82,71.61 109.68,71.46 109.66,71.46 v2(109.48,71.31) ; JNGFF2.25 269.95,66.77 269.75,66.97 v2(269.75,67.53) ; UC1.B66 v2(107.97,87.14) UC1.D66 ; UC1.U66 108.14,79.59 v2(107.81,79.27) 107.49,79.59 UC1.U67 ; v2(107.65,71.94) 108.14,72.43 UC1.AL66 ; UC1.AN23 v2(131.42,71.31) ; v2(26.49,68.24) 26.93,67.81 RT100.2 ; v2(89.04,100.8) 89.04,100.8 89.04,100.41 CC29.2 ; UC1.BA71 104.38,66.45 v2(104.11,66.18) 104.31,65.99 UC1.BB70 ; v2(46.57,73.38) 46.57,73.32 45.63,72.38 PQ1209.1 ; UC1.BA36 v2(125.21,67.75) UC1.AW36 ; v2(118.63,86.12) 119.08,85.89 UC1.E46 ; v2(59.95,86.84) 60.07,86.84 60.51,87.27 PC927.2 ; UC1.AD20 134.34,76.26 134.58,76.26 UC1.AD19 ; 70.81,101.46 70.81,101.37 70.84,101.34 70.84,100.91 v2(70.94,100.81) 71.15,100.81 71.41,101.06 JXDP1.59 ; v2(26.79,62.24) 26.43,62.59 RT377.2 ; UC1.AN32 v2(126.85,71.31) ; UC1.AA65 108.79,77.76 v2(109.11,77.44) ; UC1.V17 135.87,79.2 135.65,79.2 UC1.V18 v2(135.11,78.57) UC1.Y19 ; v2(106.99,89.18) 107.04,89.14 107.04,89 107.3,88.74 UC1.A67 ; UC1.AT56 113.8,69.96 v2(114.05,69.96) 114.51,70.33 UC1.AR55 ; v2(11.12,91.33) 11.25,91.46 DT6.2 ; v2(12.33,91.36) 12.23,91.46 DT6.2 ; UC1.AP28 v2(128.68,70.67) ; v2(167.52,80.99) 167.86,81.34 UZ12.32 ; UC1.N6 142.79,81.61 v2(142.41,81.23) 142.79,80.85 UC1.R6 ; v2(66.52,88.51) 66.3,88.29 PC932.1 ; UC1.AR53 v2(114.96,70.04) ; UC1.AW32 v2(127.68,67.75) UC1.BA32 ; UC1.AL38 124.11,73.52 v2(124.23,73.64) ; UC1.W9 140.83,78.67 v2(140.5,79.01) 140.18,79.46 UC1.U10 ; UC1.AT2 144.23,69.86 v2(144.05,69.68) 143.87,69.86 UC1.AT4 ; v2(141.56,84.95) 141.54,84.95 141.54,84.93 141.6,84.93 UC1.G6 142.23,84.3 142.57,84.3 UC1.G5 ; RC141.2 125.52,91.14 125.52,93.67 125.36,93.82 125.36,94.82 125.61,95.07 126.9,95.07 127.16,95.33 127.16,96.07 CC22.2 ; 31.1,89.25 30.91,89.25 30.56,88.89 v2(30.56,88.76) ; UC1.BA45 v2(120.25,67.75) UC1.AW45 ; UC1.AT63 v2(109.48,70.04) UC1.AR63 ; UC1.AA2 UC1.AA4 143.29,77.81 v2(143.06,78.04) UC1.W6 ; JNGFF2.11 264.45,66.69 264.08,67.06 263.3,67.06 262.93,66.69 262.93,65.85 JNGFF2.5 262.95,64.76 v2(262.68,64.49) 262.45,64.72 JNGFF2.3 ; v2(133.81,74.32) 134.14,73.99 UC1.AJ20 ; v2(133.81,74.32) 133.49,74.64 UC1.AG21 ; UC1.AN33 v2(125.94,71.31) ; JEDP1.3 59.7,116.04 v2(59.55,115.89) ; UC1.F33 126.48,85.24 v2(126.83,84.89) 127.18,85.24 UC1.F32 ; UZ12.9 167.86,86.89 167.58,87.17 167.23,87.17 v2(166.56,86.5) ; UC1.AJ4 v2(143.06,73.78) UC1.AH6 ; v2(14.12,88.08) 13.87,88.33 DT12.2 ; v2(140.54,85.5) 141.03,85.24 UC1.F8 141.16,85.24 141.81,85.89 UC1.E6 ; UC1.G45 119.81,84.59 v2(119.55,84.85) ; UC1.AR16 136.71,70.14 v2(136.89,70.14) 137.04,70.14 UC1.AR15 ; v2(56.91,97.7) 56.95,97.65 PC938.2 56.06,97.1 PR930.2 ; UC1.B10 139.93,87.38 139.93,86.88 UC1.D10 UC1.D11 139.51,86.66 139.2,86.44 UC1.E11 139.2,85.86 138.9,85.56 v2(138.83,85.56) ; v2(133.12,81.82) 133.44,81.5 UC1.N21 133.86,81.87 133.86,82 134.14,82.28 UC1.L20 ; UC1.AK21 133.49,72.91 v2(133.23,72.65) 132.8,73.08 UC1.AK22 ; CT87.2 26.62,60.48 v2(26.79,60.48) ; UC1.P21 UC1.T21 133.81,79.5 v2(133.81,79.4) ; v2(105.89,76.57) 105.89,76.57 105.86,76.55 105.86,76.39 UC1.AE69 UC1.AE68 UC1.AE67 UC1.AE66 UC1.AE65 108.85,76.13 109.38,76.13 UC1.AE64 ; CC321.2 108.64,94.44 CC312.2 v2(109.21,95.42) ; UC1.U63 110.09,79.59 v2(109.76,79.27) 109.44,79.59 UC1.U64 ; UC1.G66 v2(107.34,84.84) ; UC1.AP63 v2(109.48,70.67) ; UC1.E56 v2(113.14,86.11) ; UC1.E15 137.37,85.89 137.79,85.51 v2(137.83,85.51) 138.01,85.51 UC1.F13 ; v2(142.43,69.99) 142.84,70.31 UC1.AR5 ; UC1.E65 v2(108.36,86.11) ; JEDP1.19 67.7,116.74 v2(67.34,116.38) 67.34,116.48 67.2,116.62 JEDP1.18 ; v2(14.63,88.31) DT8.2 ; UC1.L16 136.74,82.29 v2(136.41,81.87) 136.08,82.29 UC1.L17 ; v2(33.39,34.93) 33.52,34.93 33.58,34.87 33.6,34.87 33.7,34.77 PU200.15 ; v2(135.13,84.22) 135.14,84.19 135.53,83.96 UC1.H18 UC1.K18 ; UC1.AN35 v2(125.02,71.31) ; UC1.AM46 v2(118.6,71.94) ; PR654.1 48.31,77.21 v2(47.83,77.69) 48.34,78.2 PC644.2 ; UC1.AT28 v2(128.68,70.04) UC1.AR28 ; UC1.AR48 v2(117.71,70.04) ; UC1.D44 v2(120.36,87.14) UC1.B44 ; UC1.F2 144.06,85.77 v2(144.05,85.75) 144.03,85.77 UC1.F4 ; UC1.T4 143.87,80.46 v2(144.05,80.28) 144.23,80.46 UC1.T2 ; UC1.AB8 v2(141.77,76.98) ; UC1.B58 v2(112.93,87.14) UC1.D58 ; UC1.K16 v2(137.08,82.76) ; UC1.AL35 v2(125.94,73.62) ; UC1.AR42 121.78,70.4 v2(121.33,70.04) 121.78,69.75 UC1.AT42 ; RV82.2 123.65,110.53 124.08,110.96 124.08,111.93 RV80.2 123.57,112.92 122.9,113.6 120.95,113.6 v2(120.82,113.47) ; UC1.B62 110.49,87.6 v2(110.49,87.15) 110.49,86.66 UC1.D62 ; UC1.BA49 v2(117.84,67.75) UC1.AW49 ; UC1.A5 v2(143.75,89.12) ; UC1.P17 v2(135.76,81.08) ; v2(58.5,116.47) 58.7,116.67 JEDP1.1 ; UC1.AR20 v2(134.17,70.04) ; UC1.G55 v2(114.05,84.84)
  BOTTOM w0.305: v2(29.05,15.4) 28.85,15.6 JNGFF3.39 ; JDIMM2.206 178.68,26.87 178.29,26.49 v2(177.68,26.49) JDIMM2.202 ; v2(29.26,86.16) 29.35,86.06 CT39.2 ; v2(282.48,41.05) JNGFF1.24 ; v2(51.58,23.59) 51.57,23.59 JDIMM1.22 ; v2(287.26,47.9) 287.36,47.81 287.46,47.81 287.47,47.8 JNGFF1.51 ; JDIMM2.44 136.17,26.67 136.27,26.57 v2(137.17,26.57) JDIMM2.48 ; JDIMM1.188 95.07,23.96 95.39,23.65 v2(96.01,23.65) 96.07,23.71 JDIMM1.192 ; JDIMM2.107 v2(151.93,38.21) ; JXDP1.32 v2(79.51,105.86) ; CV39.2 19.89,74.8 v2(20.16,74.53) ; JDIMM1.206 99.57,23.87 99.19,23.49 v2(98.57,23.49) JDIMM1.202 ; JDIMM1.227 104.82,34.06 v2(105.49,34.73) 105.82,34.4 JDIMM1.231 ; JDIMM1.60 61.07,26.17 v2(61.2,26.3) ; v2(109.55,34.58) 109.83,34.3 JDIMM1.247 ; v2(173.17,26.49) 173.18,26.49 JDIMM2.184 ; JXDP1.13 85.21,100.81 v2(85.21,100.81) ; v2(72.52,34.64) 72.82,34.34 JDIMM1.107 ; JDIMM1.103 71.82,34.37 71.68,34.52 v2(71.68,34.57) ; v2(178.42,37.4) 178.43,37.4 JDIMM2.205 ; v2(178.42,37.4) 179.37,37.4 179.43,37.34 JDIMM2.209 ; v2(178.42,37.4) 177.73,37.4 177.43,37.09 JDIMM2.201 ; JESPI.9 227.41,39.85 v2(228.63,41.07) ; JDIMM1.52 59.07,24.1 58.46,23.49 v2(58.07,23.49) ; CT1.2 24.64,73.02 v2(24.89,72.76) ; v2(58.07,23.49) JDIMM1.48 ; v2(58.07,23.49) 58.08,23.49 ; JDIMM2.26 v2(131.67,26.57) ; v2(74.42,105.84) 74.42,105.73 74.11,105.42 JXDP1.50 ; JKBTP1.18 244.35,28.25 v2(244.18,28.42) 243.85,28.08 JKBTP1.19 ; JDIMM1.30 53.57,23.95 53.19,23.57 v2(53.03,23.57) 52.89,23.57 52.57,23.88 JDIMM1.26 ; v2(174.04,26.63) 174.18,26.77 JDIMM2.188 ; JDIMM1.197 97.32,33.9 96.92,34.3 v2(96.49,34.3) 96.32,34.14 JDIMM1.193 ; JDIMM2.239 186.92,37.03 186.62,37.34 186.09,37.34 v2(186.08,37.34) 186.05,37.34 185.92,37.22 JDIMM2.235 ; JDIMM1.15 49.82,34.11 49.52,34.42 v2(48.32,34.42) JDIMM1.9 ; JDIMM2.196 176.18,26.61 v2(176.17,26.61) ; 20.33,17.53 20.33,17.51 20.35,17.49 JNGFF3.73 ; 20.33,17.53 20.16,17.53 19.85,17.22 JNGFF3.75 ; 20.33,17.53 v2(20.36,17.53) ; v2(271.01,26.12) 270.65,26.47 JUSH1.10 ; v2(111.51,34.46) 111.08,34.46 110.83,34.21 JDIMM1.251 ; v2(77.71,105.85) JXDP1.38 ; JDIMM2.85 146.42,38.21 146.66,38.45 v2(146.67,38.45) ; JDIMM1.248 110.07,23.78 110.2,23.65 110.68,23.65 v2(110.68,23.65) 110.87,23.65 111.07,23.86 JDIMM1.252 ; JNGFF3.15 34.85,17.15 34.3,17.71 ; JDIMM2.78 v2(144.67,26.57) ; JDIMM1.196 v2(97.07,23.54) ; v2(187.83,30.02) 188.18,29.67 JDIMM2.244 188.18,27.07 187.68,26.57 186.92,26.57 186.68,26.82 JDIMM2.238 ; JDIMM2.77 144.42,37.33 144.66,37.56 v2(145.42,37.56) JDIMM2.81 ; 125.67,26.8 125.98,26.5 126.37,26.5 126.67,26.8 JDIMM2.6 ; 125.67,26.8 JDIMM2.2 ; 125.67,26.8 124.74,26.8 124.65,26.89 v2(124.53,26.89) ; v2(142.53,37.71) 142.42,37.6 JDIMM2.69 ; JDIMM2.213 180.43,37.32 v2(180.46,37.36) 181.3,37.36 181.43,37.23 JDIMM2.217 ; JDIMM1.94 69.57,23.77 v2(69.47,23.67) 68.85,23.67 68.57,23.95 JDIMM1.90 ; v2(103,35.2) 103.39,35.2 103.82,34.77 JDIMM1.223 ; JDIMM1.64 v2(62.07,26.45) ; JDIMM1.209 100.32,30.99 v2(99.74,30.4) 99.28,30.85 99.28,31.47 99.32,31.51 JDIMM1.205 ; JXDP1.8 v2(86.71,105.85) ; v2(26.64,18.31) 27.35,17.6 JNGFF3.45 ; JDIMM1.35 54.82,34.03 55.12,34.33 v2(55.82,34.33) JDIMM1.39 ; JDIMM2.47 136.93,37.69 v2(136.91,37.71) ; v2(84.91,105.86) JXDP1.14 ; JXDP1.62 89.42,102.35 89.42,101.18 v2(89.04,100.8) ; JDIMM2.72 v2(143.17,26.45) 142.47,26.45 142.17,26.75 JDIMM2.68 ; v2(87,100.81) 87.01,100.82 JXDP1.7 ; JDIMM1.244 v2(109.07,23.65) ; JNGFF3.57 24.35,17.12 v2(23.88,17.6) ; JDIMM2.43 135.93,37.4 135.51,37.81 134.99,37.81 v2(134.96,37.78) ; CV40.2 15.12,73.63 v2(14.89,73.86) ; JDIMM1.51 v2(58.82,34.35) 59.98,34.35 60.32,34 JDIMM1.57 ; v2(124.03,33.73) 125.42,35.12 JDIMM2.1 ; JNGFF3.9 36.35,17.68 v2(36.37,17.69) ; v2(68.71,34.45) 68.32,34.07 JDIMM1.89 ; JDIMM2.60 140.17,26.5 v2(140.15,26.48) 139.56,26.48 139.17,26.86 JDIMM2.56 ; JDIMM1.238 v2(107.57,23.65) ; JDIMM1.167 v2(89.82,34.64) 89.89,34.58 90.36,34.58 90.82,34.11 JDIMM1.171 ; JDIMM2.230 184.68,26.43 184.84,26.26 v2(185.89,26.26) 185.87,26.28 185.87,26.38 185.68,26.58 JDIMM2.234 ; JDIMM2.19 129.93,37.48 v2(129.7,37.71) 128.93,36.94 JDIMM2.15 ; JDIMM1.69 63.32,31.51 63.29,31.47 63.29,30.99 v2(63.77,30.51) ; JDIMM2.14 128.67,29.39 v2(129.34,30.05) ; v2(151.56,26.5) 151.67,26.61 JDIMM2.106 ; v2(150.99,26.41) 150.98,26.41 150.67,26.71 JDIMM2.102 ; JNGFF3.1 38.35,15.63 v2(38.09,15.37) 37.85,15.6 JNGFF3.3 ; v2(287.42,44.8) JNGFF1.39 ; JDIMM1.86 v2(67.57,23.66) 66.9,23.66 66.57,23.98 JDIMM1.82 ; JDIMM1.180 93.07,23.93 93.25,23.75 v2(93.35,23.75) 93.95,23.75 94.07,23.88 JDIMM1.184 ; JXDP1.2 v2(88.51,105.84) ; JDIMM1.68 v2(63.07,26.45) ; JDIMM1.6 v2(47.57,23.66) 46.89,23.66 46.57,23.98 JDIMM1.2 ; JDIMM1.201 98.32,30.3 v2(98.48,30.14) ; JDIMM2.86 146.67,26.74 146.49,26.55 v2(145.67,26.55) JDIMM2.82 ; JDIMM1.56 v2(60.07,26.32) ; JEDP1.41 53.21,112.36 DV8.2 ; JDIMM2.39 134.93,37.75 v2(134.96,37.78) ; v2(34.42,18.26) 34.3,18.14 34.3,17.71 ; JDIMM1.61 v2(61.32,34.33) 62.02,34.33 62.32,34.02 JDIMM1.65 ; JDIMM1.230 v2(105.57,23.59) ; UZ21.5 128.7,105.5 CZ101.2 ; JNGFF1.57 287.64,49.3 v2(287.4,49.54) ; JDIMM1.14 49.57,23.9 49.98,23.49 50.36,23.49 v2(50.46,23.59) 50.57,23.7 JDIMM1.18 ; JDIMM1.168 90.08,26.17 v2(90.65,26.74) ; v2(64.14,26.45) 64.07,26.39 JDIMM1.72 ; JDIMM2.94 148.67,26.78 148.37,26.48 v2(147.67,26.48) JDIMM2.90 ; v2(282.51,42.69) 282.37,42.55 JNGFF1.30 ; v2(21.73,29.9) 22.14,29.49 CI3.2 ; 130.67,26.48 JDIMM2.22 ; JDIMM1.77 65.32,34.72 65.15,34.89 64.82,34.89 v2(64.81,34.89) 64.45,34.89 64.32,34.76 JDIMM1.73 ; JDIMM1.23 51.82,34.17 51.66,34.34 v2(50.82,34.34) JDIMM1.19 ; JDIMM1.31 53.82,34.09 53.59,34.33 v2(52.82,34.33) JDIMM1.27 ; v2(70.68,23.67) 70.57,23.78 JDIMM1.98 ; JDIMM2.231 184.92,37.32 184.71,37.54 184.32,37.54 v2(184.31,37.52) 184.25,37.52 183.92,37.19 JDIMM2.227 ; v2(83.23,105.85) 83.11,105.74 JXDP1.20 ; JDIMM2.175 170.92,37.16 171.23,37.46 v2(172.02,37.46) 172.23,37.46 172.43,37.27 JDIMM2.181 ; JNGFF3.27 v2(31.85,15.35) ; JDIMM2.31 132.93,37.44 132.66,37.71 v2(131.66,37.71) ; v2(183.17,37.26) 183.17,37.25 182.92,37 JDIMM2.223 ; JKBTP1.6 250.35,28.33 v2(250.47,28.45) ; JDIMM2.40 135.17,26.96 134.92,26.7 134.37,26.7 v2(134.18,26.52) 134.17,26.52 ; JDIMM1.189 95.32,34.11 95.02,34.41 93.79,34.41 v2(93.79,34.41) 93.81,34.41 94.32,33.9 JDIMM1.185 ; v2(172.17,29.29) 172.18,29.29 JDIMM2.180 ; JDIMM2.5 126.42,37.36 126.62,37.56 127.11,37.56 v2(127.26,37.71) 127.42,37.54 JDIMM2.9 ; 34.3,17.71 33.7,17.71 33.35,17.36 JNGFF3.21 ; JDIMM2.93 148.42,37.88 v2(148.11,38.19) 147.7,38.19 147.42,37.92 JDIMM2.89 ; JUSH1.7 272.15,26.4 v2(272.48,26.07) 272.65,26.24 JUSH1.6 ; v2(287.4,53.8) JNGFF1.75 ; v2(287.42,36.8) JNGFF1.7 ; v2(131.66,37.71) 131.16,37.71 130.93,37.47 JDIMM2.23 ; v2(131.66,37.71) 131.93,37.44 JDIMM2.27 ; JDIMM1.235 106.82,34.34 107,34.51 107.75,34.51 v2(107.8,34.46) 107.8,34.18 107.82,34.15 JDIMM1.239 ; v2(169.7,75.67) 169.74,75.67 170.39,76.32 JSPI1.3 ; v2(83.41,100.81) JXDP1.19 ; JAPS1.12 v2(317.85,102.55) ; v2(108.94,30.57) 108.82,30.69 JDIMM1.243 ; JSPI1.1 169.39,76.45 v2(169.6,76.25) 169.89,76.54 JSPI1.2 ; JDIMM2.251 189.93,36.95 189.22,37.65 v2(188.92,37.65) 188.93,37.65 JDIMM2.247 ; v2(187.42,38.13) 187.92,37.63 JDIMM2.243 ; JDIMM1.172 91.08,23.91 91.27,23.72 v2(91.87,23.72) 91.89,23.72 91.89,23.86 92.08,24.04 JDIMM1.176 ; v2(128.07,30.43) 127.67,30.04 JDIMM2.10 ; JAPS1.14 318.85,103.8 v2(319.53,104.49) ; JDIMM1.217 102.32,34.32 102.11,34.54 v2(100.85,34.54) 101.32,34.06 JDIMM1.213 ; JDIMM1.78 65.57,25.98 65.36,26.19 65.36,26.67 v2(65.03,27) ; JDIMM2.210 v2(179.68,26.49) ; JDIMM2.99 149.93,37.73 150.38,38.18 v2(150.5,38.18) 150.61,38.18 150.93,37.87 JDIMM2.103 ; JXDP1.49 74.41,100.93 74.28,100.81 v2(74.23,100.81) 73.94,100.81 CC33.2 ; v2(78.02,100.81) 78.02,100.86 78.01,100.88 JXDP1.37 ; JDIMM1.43 56.82,33.96 57.16,34.3 v2(57.43,34.3) 57.82,33.9 JDIMM1.47 ; v2(244.53,32.83) CZ82.2 ; JDIMM2.214 180.68,26.67 v2(180.85,26.49) 181.36,26.49 181.68,26.8 JDIMM2.218 ; v2(247.39,28.42) 247.35,28.38 JKBTP1.12 ; v2(48.38,23.64) 48.57,23.84 JDIMM1.10 ; CI7.2 27.66,27.18 v2(27.41,26.94) ; JAPS1.10 v2(316.85,102.48) ; JUSH1.24 263.65,26.3 263.52,26.17 v2(263.06,26.17) 263.15,26.26 JUSH1.25 ; RC139.2 70.39,100.25 v2(70.39,100.83) 70.39,101.11 70.16,101.34 JXDP1.63 ; JDIMM1.102 71.57,23.92 71.89,23.61 v2(72.35,23.61) 72.57,23.83 JDIMM1.106 ; JDIMM2.197 176.43,37.17 176.22,37.37 v2(175.45,37.37) 175.43,37.35 JDIMM2.193 ; v2(20.39,18.14) 20.55,18.14 20.85,17.84 JNGFF3.71 ; JDIMM1.214 v2(101.57,23.49) 102.26,23.49 102.57,23.8 JDIMM1.218 ; JDIMM2.185 173.43,37.16 173.92,37.65 v2(173.92,37.65) 173.94,37.65 174.43,37.17 JDIMM2.189 ; v2(81.61,100.81) 81.61,100.81 JXDP1.25 ; v2(134.96,37.78) 134.48,37.78 133.93,37.22 JDIMM2.35 ; JKBTP1.4 251.35,28.33 v2(251.47,28.45) ; JNGFF3.33 v2(30.35,15.34) ; JDIMM1.222 103.57,23.96 v2(104.01,23.53) 104.08,23.53 104.57,24.02 JDIMM1.226 ; JDIMM2.30 v2(132.67,26.57) ; v2(143.75,32.72) 143.75,33.7 143.42,34.03 JDIMM2.73 ; v2(175.52,26.57) 175.18,26.92 JDIMM2.192 ; JXDP1.31 79.81,101.09 v2(80.11,100.78) ; v2(149.8,26.7) 149.67,26.83 JDIMM2.98 ; JNGFF1.18 282.4,39.55 v2(282.51,39.66) ; JDIMM1.44 57.07,23.86 56.71,23.49 v2(56.07,23.49) JDIMM1.40 ; v2(289.76,46.3) JNGFF1.45 ; JKBTP1.1 252.85,28.34 v2(252.97,28.47) ; JDIMM1.181 93.32,34.29 92.47,35.15 91.94,35.15 v2(91.82,35.03) JDIMM1.175 ; v2(46.03,31.73) 46.32,32.03 JDIMM1.1 46.32,34.24 46.5,34.41 47.11,34.41 47.32,34.19 JDIMM1.5 ; v2(287.34,52.13) 287.52,52.3 288.52,52.3 JNGFF1.69 ; JDIMM2.222 182.68,26.58 v2(182.95,26.31) 183.22,26.31 183.68,26.77 JDIMM2.226 ; JAPS1.8 v2(315.85,102.59) ; JDIMM1.93 69.32,33.97 v2(70.03,34.67) 70.05,34.69 70.53,34.69 70.82,34.39 JDIMM1.99 ; v2(26.27,15.17) 25.85,15.58 JNGFF3.51 ; JXDP1.61 70.81,101.46 ; v2(287.42,50.8) JNGFF1.63 ; JDIMM1.210 v2(100.57,23.49) ; JDIMM2.64 v2(141.17,26.57) ; JNGFF1.36 281.9,44.05 282.13,43.82 v2(282.55,43.82) ; v2(137.86,26.45) 138.05,26.45 138.17,26.57 JDIMM2.52 ; JXDP1.26 v2(81.31,105.85) ; JDIMM1.85 67.32,34.02 67.02,34.32 v2(66.79,34.32) 66.63,34.32 66.32,34.02 JDIMM1.81 ; JDIMM1.36 v2(55.07,23.62) ; JDIMM2.61 140.42,37.6 v2(140.53,37.71) 139.65,37.71 139.42,37.49 JDIMM2.57 ; JDIMM2.252 190.18,26.98 v2(189.91,26.72) 189.52,26.72 189.18,27.07 JDIMM2.248 ; JDIMM2.18 129.67,26.78 129.98,26.48 130.03,26.48 ; JDIMM1.234 v2(106.57,23.65)
  BOTTOM w0.356: CZ54.2 174.94,83.22 175.09,83.07 175.09,82.56 v2(175.33,82.33) ; v2(31.86,83.56) 31.72,83.69 CT41.2 31.71,84.22 CT40.2 ; v2(181.66,92.23) CC9.2 ; CC28.2 115.48,99.85 CC32.2 ; CT100.2 v2(8.79,94.41) ; CZ101.2 127.92,105.15 128.13,104.93 CZ105.2 127.68,104.11 v2(127.31,103.74) ; CT36.2 CT35.2 30.18,91.06 v2(30.55,90.7) ; v2(166.29,83.03) 166.29,82.91 CZ51.2 ; CZ53.2 v2(169.7,88.8)
  BOTTOM w0.381: v2(166.56,86.5) 166.51,86.56 CZ50.2 ; v2(11.02,87.82) 11.01,87.8 CT102.2 ; CT29.2 33.25,85.49 32.75,84.98 31.81,84.98 CT40.2 ; RC227.2 149.54,103.43 149.84,103.13 149.84,102.12 149.73,102 UC12.3 ; v2(30.89,58.11) 30.75,58.26 29.54,58.26 RT71.2 ; v2(287.42,43.3) JNGFF1.33 ; CT62.2 27.44,86.68 v2(27.31,86.81) ; v2(303.17,64.8) 303.27,64.8 303.31,64.77 DI4.3 ; JNGFF1.23 289.56,40.8 v2(289.78,41.01) ; v2(26.64,90.06) 26.64,89.7 CT63.2 ; RT23.2 28.42,80.41 28.81,80.03 v2(29.09,80.03) 29.31,80.26 RT129.2 ; PC1063.2 82.91,60.71 CD32.2 ; v2(133.4,105.26) 132.78,105.87 CZ100.2 132.95,106.37 133.43,106.37 133.78,106.02 133.78,105.99 UZ35.3 ; PQ1209.4 43.33,70.66 42.83,70.66 PC1214.2 ; v2(31.21,83.56) 31.08,83.43 CT25.2 ; CT31.2 33.18,88.63 32.63,88.63 v2(32.51,88.76) ; v2(27.31,83.56) 27.39,83.48 CT30.2 ; v2(110.71,97.91) 110.46,97.91 109.98,97.43 CC308.2 110.1,97.29 CC305.2 ; v2(290.63,42.61) 290.32,42.3 JNGFF1.29 ; PR945.2 PC1286.2 57.08,93.54 57.76,92.86 v2(57.76,92.7) ; UC7.3 174.68,92.57 v2(174.39,92.87) ; RV84.2 123.85,109.19 125.15,110.49 v2(125.15,111.27) ; RC65.2 170.85,91.51 v2(170.59,91.77) ; v2(11.02,88.4) 11.01,88.39 CT101.2 ; CT33.2 29.42,87.61 v2(29.26,87.46) 29.24,87.43 CT27.2 29.28,86.77 CT38.2 ; CT26.2 29.87,84.89 v2(29.91,84.86) ; v2(10.93,90.72) 10.88,90.72 10.5,91.11 CT99.2 ; v2(27.31,87.46) 27.1,87.66 CT48.2 26.79,88.22 CT64.2 ; v2(115.65,99.1) CC32.2 ; CV41.2 15.93,73.87 14.9,73.87 v2(14.89,73.86) ; CI17.2 300.23,57.69 v2(300.1,57.82) ; CC310.2 102.8,97.29 101.96,96.46 v2(101.96,95.74) ; CC304.2 v2(112.73,95.22) ; v2(31.21,88.11) 31.17,88.07 CT28.2 ; PQ1216.3 38.25,87.47 37.81,87.91 37.81,88.88 38.33,89.4 v2(38.33,89.45) ; v2(287.4,53.8) 287.3,53.9 287.3,54.45 JNGFF1.76 ; v2(17.53,98.68) 17.43,98.68 16.87,98.12 PC1208.2 ; CV85.2 v2(124.26,106.65)
  BOTTOM w0.406: JIR1.3 102.95,115.69 v2(103.25,115.39) 103.55,115.68 JIR1.2
  BOTTOM w0.457: PC931.1 55.7,91.23 55.3,90.83 v2(55.3,90.7) ; CC195.2 135.85,93.15 v2(134.86,93.15) ; RT38.2 32.55,90.11 v2(32.5,90.05)
  BOTTOM w0.508: v2(209.09,41.96) 208.36,41.96 PC937.1 ; v2(324.99,44.43) 324.59,44.02 JSIM1.C5 ; CC22.2 126.66,97 v2(126.98,97.32) ; RC349.2 151.31,68.63 RC4.2 150.43,67.89 v2(150.79,67.53) ; v2(84.52,69.81) 84.48,69.84 PC1180.2 ; CV96.2 111.18,103.71 v2(111.18,101.05) ; JDIMM2.262 194.72,46.12 198.58,46.12 201.04,43.66 ; PC641.2 49.98,66.2 PR658.1 49.98,67.42 v2(50.29,67.74) ; v2(60.66,97.66) 60.55,97.77 PR925.2 ; PC1177.2 85.57,73.06 85.6,73.03 v2(85.6,72.73) ; RA35.2 302.25,30.47 v2(302.27,30.45) ; PR412.1 v2(180.87,114.37) ; v2(25.01,25.24) 24.98,25.21 DI2.1 ; JNGFF3.76 v2(16.75,9.93) ; JNGFF3.76 17.72,10.2 17.33,10.59 v2(16.77,10.59) ; JNGFF3.76 17.72,9.66 17.36,9.3 v2(16.76,9.3) ; CLIP2.1 v2(319.41,70.65) 319.41,70.65 JUSB1.13 ; v2(64.25,97.88) 64.42,97.71 64.42,97.6 PC946.2 ; JRTC1.3 v2(302.05,14.11) ; JRTC1.3 302.82,16.87 303.8,16.87 304.6,17.67 JRTC1.2 ; JRTC1.3 v2(300.61,16.1) ; CC300.2 99.02,95.23 98.2,95.23 ; RC227.2 149.22,103.94 v2(149.57,104.29) ; v2(254.19,24.73) JKBTP1.21 v2(256.2,24.76) ; RT27.2 24.61,76.09 v2(24.74,75.96) ; v2(37.07,18.77) 37.07,19.24 37.88,20.06 UT8.2 ; CC7.2 160.4,75.92 v2(161.03,76.55) ; PC943.2 PC944.2 59,96.97 PR932.2 58.93,97.18 v2(59.35,97.6) ; CT94.2 24.21,98.06 24.26,98.11 PC1209.2 PR1227.2 25.81,97.41 25.52,97.12 v2(25.15,97.12) ; CT67.2 19.21,83.56 v2(19.61,83.56) ; RZ334.2 303.94,43.58 303.43,43.08 v2(303.43,42.97) ; PC402.2 v2(191.56,109.68) ; PR302.2 190.67,94.6 v2(190.53,94.46) ; JLED1.4 v2(312.29,9.09) ; PBATT1.7 209.25,33.08 210.06,33.89 PC1.2 ; CZ55.2 172.53,89.6 v2(172.51,89.63) ; PC677.2 71.59,76.26 v2(71.19,75.85) ; v2(88.01,75.71) 88.09,75.79 PC1133.2 ; v2(25.27,92.83) 25.49,92.6 CT60.2 ; v2(121.81,33.85) 121.81,37.32 125,40.51 JDIMM2.261 ; v2(260.85,69.43) JNGFF2.68 v2(260.85,63.32) ; v2(307.09,12.54) 308.4,13.85 JRTC1.4 ; v2(166.18,84.75) 165.78,84.35 CZ75.2 ; v2(295.91,72.1) 296.41,71.6 JDEG1.11 ; CC8.2 176.16,87.2 175.9,87.47 175.9,88.53 v2(176.15,88.78) ; 163.35,65.81 163.35,65.58 164.39,64.54 JUART1.5 ; 163.35,65.81 163.38,65.84 JUART1.4 ; 163.35,65.81 v2(163.25,65.91) ; v2(302.91,45.94) 302.41,46.44 CZ40.2 ; RZ62.2 171.38,79.39 171.9,79.91 v2(171.9,80.36) ; UT2.4 34.33,69.56 34.54,69.35 v2(34.55,69.35) ; JESPI.11 220.53,40.83 v2(220.02,40.83) ; PR653.1 58.7,73.78 v2(59.41,74.49) ; CC301.2 105.96,98.66 v1(105.25,99.37) v2(104.45,100.16) ; RE86.2 297.86,74.8 v2(298.33,74.32) ; PC1186.2 v2(88.01,72.73) ; PC401.2 v2(180.09,113.89) ; v2(185.93,104.88) 186.06,104.74 PC312.2 ; v2(308.9,62.19) 308.31,61.6 CLIP1.1 ; 24.13,83.71 23.78,83.36 RT26.2 ; PR1247.2 39.15,71.21 PC1212.2 38.29,70.61 v2(38.11,70.43) ; v2(36.7,107.22) 37.17,106.75 PJPDC1.7 ; PQ909.3 62.83,101.7 v2(63.62,100.91) ; PR403.2 v2(191.54,111.45) ; v2(242.28,32.99) UZ6.3 ; v2(79.19,98.33) 78.74,98.77 CC307.2 ; v2(57.28,115.92) 56.81,115.45 JEDP1.41 ; PC1017.2 86.87,75.77 v2(86.81,75.71) ; RV94.2 119.05,102.39 v1(118.46,101.79) v2(118.04,101.38) ; PC111.2 234.18,21.71 234.57,21.32 v2(234.92,21.32) ; v2(175.41,79.38) 175.41,79.38 175.4,79.37 RC316.2 ; PC1214.2 42.73,70.47 43.49,69.72 v2(43.49,69.64) ; v2(280.67,68.3) 281.55,67.42 JNGFF2.69 ; PR424.2 170.27,109.2 v2(170.3,109.16) ; PR416.2 191.28,114.52 v2(190.96,114.84) ; v2(152.64,72.13) 152.64,71.8 152.58,71.74 152.58,71.37 152.83,71.12 CC326.2 ; CZ41.2 305.24,45.67 CZ37.2 305.43,45.9 v2(306.28,45.9) ; PC928.2 v2(70.56,94.19) ; v2(94.46,115.99) 94.46,115.46 94.97,114.95 JTS1.7 ; v2(167.52,80.99) 168.02,80.49 168.02,80.23 ; v2(316.93,101.73) 316.94,101.75 CC302.2 ; v2(28.17,44) 28.46,44.29 PR103.2 ; PC950.1 62.96,97.05 62.46,97.55 v2(62.38,97.55) ; UT8.2 38.79,19.67 v2(37.97,18.84) ; UT8.2 41.48,20.06 v2(42.42,21) ; JESPI.12 229.47,41.07 v2(228.63,41.07) ; v2(191.56,65.69) 191.56,64.53 RC411.2 ; UV2.2 19.33,72.71 19.84,73.22 v2(19.94,73.22) ; v2(151.76,80.62) 151.71,80.67 150.03,80.67 RC268.2 ; v2(145.12,96.67) 144.69,97.11 RC372.2 ; CI1.2 24.77,27.13 v2(24.47,27.44) ; PR427.2 186.01,114.15 PC410.2 186.03,114.58 v2(185.65,114.97) ; v2(59.16,69.18) 58.94,68.97 PR681.2 ; v2(45.85,64.83) 45.97,64.95 PC10.2 ; v2(179.3,114.19) PR407.2 178.61,114.15 PC411.2 ; v2(98.24,83.91) 98.4,84.08 RC163.2 ; JSIM1.6 307.21,34.76 v2(307.96,35.51) ; PC1137.2 89.3,75.79 v2(89.22,75.71) ; JDIMM1.262 113.5,39.63 111.43,37.56 v2(111.43,36.71) ; v2(291.75,9.58) JSPK1.5 291.75,5.99 v2(290.72,4.96) ; PU2.1 41.62,67.79 v2(41.62,66.63) ; v2(109.63,101.05) v1(109.63,102.39) 109.63,103.94 RV97.2 ; JNGFF1.77 v2(289.51,34.2) ; v2(88.65,82.23) 88.79,82.37 88.79,82.56 PC1005.2 ; v2(169.54,115.65) 169.91,116.01 PR420.2 ; v2(66.78,113.89) 67.17,113.5 JEDP1.43 ; v2(104.52,104.76) 104.98,105.22 RV77.2 ; PC1079.2 86.37,82.56 86.37,82.33 v2(86.24,82.19) ; v2(165.78,75.12) 165.78,75.1 CMOS1.2 166.98,74.4 JSPI1.21 ; v2(192.18,97.68) 191.72,98.14 PR310.2 ; v2(309.59,4.26) 309.39,4.46 JLED1.8 ; PC116.2 v2(39.76,45.33) ; v2(66.41,94.98) 65.86,94.42 PC942.2 65.83,94.32 PC939.2 ; JSIM1.4 v2(316.1,48.9) ; PC1183.2 v2(86.81,72.73) ; PC915.2 v2(71.4,92.4) ; JTS1.8 91.62,114.95 92.38,115.71 v2(92.38,115.99) 92.44,116.05 JTS1.4 ; v2(302.03,7.12) 301.82,6.9 JSPK1.6 ; RT25.2 v2(25.5,75.99) ; v2(161.86,77.76) 161.86,78.83 161.67,79.03 RZ111.2 ; v2(102.88,95.75) 102.88,94.97 RC113.2 102.89,94.93 RC110.2 101.94,94.92 RC112.2 ; PR311.2 187.64,102.61 v2(187.93,102.89) ; RC219.2 75.81,95.73 74.96,94.88 v2(74.61,94.88) ; PC1178.2 v2(84.36,72.73) ; UE9.4 231.88,36.7 232.02,36.84 v2(232.02,37.88) ; v2(239.13,31.95) PC100.2 PC103.2 ; v2(175.71,89.27) 175.41,89.27 174.94,88.8 CZ56.2 ; JSIM1.8 316.81,31.47 316.57,31.23 310.61,31.23 JSIM1.7 309.91,32.62 v2(310.24,32.94) ; JSPI1.22 v2(180.99,75.9) ; CZ57.2 CZ58.2 164.06,80.23 v2(163.85,80.44) ; PC119.2 v2(30.74,49.84) ; v2(85.08,82.19) 85.14,82.25 85.14,82.56 PC1008.2 ; v2(85.6,75.71) 85.65,75.76 PC1189.2 ; PC926.2 56.14,89.34 56.1,89.37 v2(55.3,89.37) ; v2(105.72,113.57) 105.72,114.05 JIR1.8 ; PC669.2 v2(63.97,68.98) ; UI1.2 25,29.94 v2(24.53,29.46) 24.5,29.5 CI45.2 23.84,29.51 CI46.2 ; v2(124.99,90.1) 125.36,90.46 RC141.2 ; v2(83.41,100.81) 83.41,100.65 83.43,100.63 RC122.2 ; RT126.2 37.56,80.46 37.22,80.8 v2(37.22,81.24) 37.72,81.24 RT128.2 ; JEDP1.44 78.53,113.5 78.54,113.49 v2(79.02,113.49) ; PC5.2 v2(49.36,105.84) ; JEDP1.42 60.83,113.5 v2(61.22,113.89) ; DI3.1 25.37,37.4 v2(24.6,38.17) ; UT6.4 v2(20.39,52.74) ; v2(26.71,25.51) 26.9,25.71 CI6.2 ; PQ6.3 59.5,102.65 v2(60.2,102.65) 60.38,102.83 PR927.2 ; PC1190.2 v2(85.73,69.81) ; v2(323.33,33.51) 323.61,33.23 JSIM1.9 ; v2(142.77,98.41) 142.04,99.13 CC221.2 ; JSIM1.5 v2(307.21,43.56) ; PC419.2 168.66,107.64 168.29,108.01 v2(168.29,108.44) ; JUSB1.7 v2(310.94,61.6) ; v2(47.31,85.87) 47.71,86.27 PQ7.3 ; CT93.2 32.33,20.31 v2(31.8,19.79) ; 98.2,95.23 98.2,95.57 98.51,95.89 v2(98.85,95.89) ; 98.2,95.23 RC109.2 ; v2(100.35,115.98) 100.2,115.82 JIR1.7 ; v2(87.47,82.19) 87.58,82.3 87.58,82.56 PC1082.2 ; v2(30.36,92.38) 30.42,92.38 31.16,91.65 RT34.2 ; v2(29.42,68.27) 29.26,68.12 RT81.2 ; RT82.2 27.82,68.29 v2(28.25,68.73) ; v2(148.55,85.1) 148.87,85.41 RC412.1 ; v2(304.04,70.45) JDEG1.12 305.11,69.38 v2(305.44,69.06) ; CZ39.2 306.08,40.6 v2(306.15,40.67) ; JDB1.8 23.27,41.76 v2(23.48,41.98) ; PC1181.2 v2(84.46,75.66) ; JAPS1.20 v2(322.95,107.92) ; RV76.2 v2(103.18,104.77) ; v2(89.03,72.69) 89.22,72.88 PC1199.2 ; v2(258.01,30.43) 258.01,28.12 RZ10.1 ; JAPS1.19 v2(311.52,106.45) ; RV84.2 RV90.2 ; PC1215.2 12.95,93.5 v2(12.38,93.5) ; v2(175.17,58.55) 169.76,58.55 v2(164.75,53.53) ; v2(83.31,69.81) 83.21,69.91 PC1191.2 ; JEDP1.45 80.6,116.93 v2(80.1,117.43) ; v2(261.9,23.48) 261.64,23.74 JUSH1.27 ; DA2.1 v2(316.41,11.17) ; v2(44.72,38.15) 45.9,39.33 JDIMM1.261 ; v2(114.06,95.22) 114.49,94.79 114.49,94.77 114.56,94.71 RC86.2 ; RT101.2 v2(34.74,61.37) ; JDB1.7 28.96,41.05 v2(29.2,41.05) ; v2(189.38,81.6) 189.33,81.6 188.76,81.03 UC6.4 ; v2(77.76,95.88) 77.76,96.64 CC269.2 ; JUSH1.28 277.48,24.2 v2(278.53,25.25) ; PC126.2 30.55,48.04 29.59,48.04 28.78,47.22 v2(28.78,46.37) ; JFAN1.1 185.45,71.87 v2(185.96,72.38) ; v2(50.34,82.47) 50.21,82.34 PR24.2 ; v2(87,69.75) PC1103.2 87.02,70.62 PC1187.2 ; JLED1.7 315.99,4.3 v2(315.89,4.2) ; PR506.2 v2(170.69,98.8) ; JSIM1.3 v2(322.85,47.41) ; PC11.2 38.52,68.71 v2(37.95,69.28) ; v2(31.26,25.06) PC204.2 ; v2(39.22,70.58) 39.49,70.31 PR1246.2 40.08,71.19 PC1211.2 40.09,72.04 PC1213.2 ; CC303.2 v2(114.2,97.5) ; v2(124.78,97.33) 124.54,97.33 124.02,96.81 124.02,96.63 CC21.2 ; v2(188.85,87.27) 188.74,87.17 UC5.4 ; PR415.2 v2(187.84,114.84) ; v2(34.67,86.5) 34.14,85.97 RT29.2 RT35.2 ; v2(167.95,110.87) 168.36,110.87 168.45,110.95 PC420.2 PR428.2 ; CZ60.2 170.54,90.58 CZ59.2 169.06,90.6 v2(168.81,90.85)
  vias: v1(23.56,84.23) v1(24.45,88.3) v1(30.29,34.77) v1(41.02,90.65) v1(42.36,25.81) v1(61.03,62.32) v1(77.35,86.2) v1(80.9,61.5) v1(81.66,78.2) v1(85.33,64.31) v1(89.22,42) v1(93.25,39.26) v1(94.81,99.98) v1(116.14,32.42) v1(123.76,101.82) v1(163.26,90.2) v1(178.44,102.14) v1(185.55,108.49) v1(186.55,105.25) v1(194.88,32.02) v1(239.62,22.26) v1(299.21,41.88) v1(308.23,101.89) v1(315.22,11.33) v2(0.51,97.78) v2(0.47,78.97) v2(0.45,15.25) v2(0.45,13.98) v2(0.45,12.71) v2(0.45,11.44) v2(0.45,10.17) v2(0.45,8.9) v2(0.45,7.63) v2(0.45,6.36) v2(0.49,5.09) v2(0.81,59.42) v2(0.99,16.4) v2(1.34,5.59) v2(1.5,81.71) v2(1.64,98.35) v2(1.72,4.75) v2(1.91,79.45) v2(2.11,99.53) v2(2.06,97.12) v2(2.25,8.55) v2(2.26,16.41) v2(2.47,12.3) v2(2.99,4.75) v2(3.12,100.3) v2(3.17,10.16) v2(3.17,6.94) v2(3.54,14.53) v2(3.78,98.3) v2(3.78,81.4) v2(4.13,99.41) v2(4.2,53.52) v2(4.26,4.75) v2(4.39,100.3) v2(4.51,34.26) v2(4.62,36.79) v2(4.67,96.77) v2(4.67,82.93) v2(4.67,79.87) v2(5.03,18.4) v2(5.03,10.16) v2(5.03,6.94) v2(5.53,4.75) v2(5.58,59.57) v2(5.66,100.3) v2(5.95,8.55) v2(6.43,96.77) v2(6.43,82.93) v2(6.43,79.87) v2(6.8,4.75) v2(6.93,100.3) v2(6.99,99.35) v2(7.14,77.16) v2(7.05,5.9) v2(7.24,12.08) v2(7.32,98.3) v2(7.32,81.4) v2(8.07,4.76) v2(8.18,58.26) v2(8.36,100.29) v2(8.54,96.73) v2(8.55,5.93) v2(8.64,99.38) v2(8.64,7.2) v2(8.84,79.51) v2(8.79,18.18) v2(8.81,9.42) v2(9,35.52) v2(9.12,85.49) v2(9.44,53.18) v2(9.53,77.16) v2(9.59,11.45) v2(9.55,8.08) v2(9.84,85.06) v2(10.09,99.1) v2(10.09,18.06) v2(10.28,98.3) v2(10.42,80.44) v2(10.42,79.85) v2(10.42,79.22) v2(10.42,78.58) v2(10.5,59.51) v2(10.74,100.3) v2(10.8,99.6) v2(10.82,8.15) v2(10.96,13.24) v2(10.96,9.66) v2(11.17,96.77) v2(11.36,18.06) v2(11.58,36.9) v2(11.63,34.09) v2(11.69,52.92) v2(12.01,100.3) v2(12.08,8.26) v2(12.52,17.63) v2(12.93,96.77) v2(12.94,13.24) v2(12.94,9.66) v2(13.14,35.45) v2(13.21,99.66) v2(13.28,100.3) v2(13.25,8.75) v2(13.82,98.3) v2(13.77,18.08) v2(13.91,99.02) v2(13.9,19.37) v2(14.11,33.49) v2(14.31,11.45) v2(14.53,36.88) v2(14.52,8.83) v2(15.17,84.09) v2(15.19,83.51) v2(15.19,82.95) v2(15.44,35.42) v2(15.74,8.47) v2(15.82,100.3) v2(15.83,12.68) v2(15.77,10.23) v2(16.05,88.3) v2(16.12,33.67) v2(16.13,15.36) v2(16.15,55.4) v2(16.27,36.93) v2(16.61,90.43) v2(16.97,8.15) v2(17.09,100.3) v2(17.14,92.85) v2(17.38,80.1) v2(17.95,80.65) v2(17.96,80.08) v2(18,12.71) v2(18.09,68.83) v2(18.11,67.1) v2(18.24,63.34) v2(18.32,65.17) v2(18.36,100.3) v2(18.52,80.65) v2(18.53,80.08) v2(18.48,16.65) v2(19.33,92.18) v2(19.63,100.3) v2(19.61,84.32) v2(19.89,92.17) v2(20.69,55.04) v2(20.77,43.78) v2(20.9,100.3) v2(21.26,55.02) v2(21.76,59.65) v2(22.01,55.05) v2(22.17,100.3) v2(22.57,55.06) v2(22.81,91.48) v2(22.91,46.81) v2(22.89,46.2) v2(23.24,90.16) v2(23.24,89.25) v2(23.24,88.34) v2(23.44,100.3) v2(24.07,43.53) v2(24.71,100.3) v2(25.16,18.57) v2(25.36,88.11) v2(25.37,87.45) v2(25.36,86.81) v2(25.36,85.51) v2(25.36,84.21) v2(25.98,100.35) v2(26.01,85.51) v2(26.93,96.69) v2(26.96,101.16) v2(27.03,80.74) v2(27.1,111.31) v2(27.1,110.04) v2(27.1,108.77) v2(27.1,107.5) v2(27.1,106.23) v2(27.1,104.96) v2(27.1,103.69) v2(27.1,102.42) v2(27.26,112.57) v2(27.31,82.27) v2(27.4,79.09) v2(27.54,92.22) v2(27.96,90.06) v2(27.96,89.41) v2(27.96,87.46) v2(27.96,86.81) v2(28.53,112.7) v2(28.61,90.06) v2(28.61,83.56) v2(29.31,96.21) v2(29.8,112.7) v2(29.91,90.06) v2(30.17,36.65) v2(30.44,78.43) v2(30.91,96.39) v2(31.07,112.7) v2(31.24,34.84) v2(31.24,33.98) v2(31.86,88.75) v2(32.34,112.7) v2(32.59,94.89) v2(33.06,97.3) v2(33.4,42.82) v2(33.4,42.23) v2(33.45,41.64) v2(33.61,112.7) v2(33.96,95.83) v2(33.97,42.82) v2(33.97,42.23) v2(34.02,41.64) v2(34.57,42.82) v2(34.57,42.23) v2(34.61,41.67) v2(34.88,112.7) v2(35.21,45.99) v2(35.84,92.55) v2(35.84,36.85) v2(35.84,36.14) v2(36.15,112.7) v2(36.07,38.64) v2(36.07,38) v2(36.16,42.72) v2(36.17,42.08) v2(37.32,89.48) v2(37.42,112.73) v2(37.78,38.63) v2(37.78,38.06) v2(37.77,37.46) v2(37.92,52.06) v2(38.34,39.05) v2(38.43,113.5) v2(38.36,38.46) v2(38.36,37.88) v2(38.6,114.76) v2(38.98,33.8) v2(38.98,33.2) v2(39.33,83.33) v2(39.27,52.25) v2(39.31,51.64) v2(39.46,115.7) v2(39.8,26.84) v2(39.82,26.28) v2(39.83,25.71) v2(39.84,25.15) v2(40.02,57.59) v2(40.02,56.99) v2(40.02,56.38) v2(40.01,55.78) v2(40.02,55.16) v2(40.02,54.54) v2(40.01,53.92) v2(40.02,53.35) v2(40.1,52.58) v2(40.1,51.99) v2(40.24,91.63) v2(40.26,12.7) v2(40.73,115.7) v2(41.23,84.76) v2(41.32,8.2) v2(41.48,81.76) v2(41.51,80.01) v2(41.51,79.35) v2(41.53,77.64) v2(41.53,77.06) v2(41.51,10.72) v2(41.5,9.97) v2(41.51,9.26) v2(41.56,76.5) v2(42,115.7) v2(42.1,23.16) v2(42.09,13.59) v2(42.57,23.59) v2(42.61,8.21) v2(42.66,22.95) v2(42.76,43.74) v2(43.03,11.2) v2(43.07,107.87) v2(43.13,24.86) v2(43.16,24.29) v2(43.18,23.69) v2(43.22,23.11) v2(43.27,115.7) v2(43.35,43.72) v2(43.69,24.54) v2(43.77,23.96) v2(43.82,23.37) v2(43.75,16.1) v2(43.92,12.73) v2(43.92,9.67) v2(43.86,8.2) v2(44.39,116.29) v2(44.7,117.52) v2(44.76,118.27) v2(45.1,15.47) v2(45.45,118.55) v2(45.43,97.22) v2(45.44,96.62) v2(45.45,96.02) v2(45.45,97.78) v2(45.47,95.42) v2(45.68,12.73) v2(45.68,9.67) v2(46.01,118.54) v2(46.06,97.81) v2(46.06,97.24) v2(46.06,96.63) v2(46.07,96.03) v2(46.09,95.44) v2(46.23,35.25) v2(46.19,18.4) v2(46.4,8.2) v2(46.54,14.75) v2(46.55,71.11) v2(46.57,11.2) v2(46.72,118.55) v2(47.1,30.53) v2(47.1,29.01) v2(47.1,27.48) v2(47.42,20.54) v2(47.42,16.26) v2(47.64,8.47) v2(47.69,118.55) v2(47.7,14.82) v2(47.7,13.55) v2(47.7,12.28) v2(47.7,9.74) v2(48.17,47.57) v2(48.36,118.55) v2(48.74,48.11) v2(48.73,47) v2(48.79,27.31) v2(49.04,118.55) v2(48.97,30.89) v2(48.97,28.6) v2(49.29,47.58) v2(49.4,117.6) v2(49.4,116.33) v2(49.39,43.5) v2(49.47,44.2) v2(49.74,59.1) v2(49.75,57.98) v2(49.93,116.7) v2(49.88,20.54) v2(50.17,117.7) v2(50.21,44.86) v2(50.17,44.2) v2(50.53,118.55) v2(50.71,30.51) v2(50.71,28.98) v2(50.71,27.46) v2(50.82,115.17) v2(50.87,59.1) v2(50.87,57.98) v2(51.07,73.08) v2(51.07,71.56) v2(51.07,70.03) v2(51.39,56.18) v2(51.45,54.03) v2(51.67,60.99) v2(51.8,118.55) v2(51.84,55.58) v2(51.93,114.9) v2(52.01,56.17) v2(52.58,115.17) v2(52.59,73.08) v2(52.59,71.56) v2(52.59,70.03) v2(52.7,103.37) v2(53.04,30.51) v2(53.04,28.98) v2(53.04,27.46) v2(53.02,20.21) v2(53.07,118.55) v2(53.09,102.94) v2(53.34,117.57) v2(53.47,116.7) v2(53.73,116.05) v2(54.11,73.08) v2(54.11,71.56) v2(54.11,70.03) v2(54.34,118.55) v2(54.3,29.29) v2(54.3,27) v2(54.29,20.21) v2(54.6,49.5) v2(54.8,62.58) v2(55.2,49.5) v2(55.37,62.58) v2(55.56,20.21) v2(55.86,49.51) v2(55.87,35.41) v2(55.96,30.51) v2(55.96,28.98) v2(55.96,27.46) v2(56.4,58.41) v2(56.83,20.21) v2(56.88,118.55) v2(56.92,37.71) v2(57.15,79.39) v2(57.15,78.73) v2(57.76,58.43) v2(58.15,118.55) v2(58.15,40.44) v2(58.15,30.51) v2(58.15,28.98) v2(58.15,27.46) v2(58.1,20.21) v2(58.25,39.04) v2(58.46,66.59) v2(58.46,65.4) v2(58.46,64.21) v2(58.85,79.22) v2(58.93,80.99) v2(58.93,80.36) v2(58.85,78.63) v2(58.98,58.41) v2(59.31,86.84) v2(59.31,86.2) v2(59.31,85.57) v2(59.31,84.93) v2(59.31,84.3) v2(59.35,83.51) v2(59.35,82.87) v2(59.35,82.24) v2(59.31,81.63) v2(59.34,66.59) v2(59.34,65.4) v2(59.34,64.21) v2(59.42,118.55) v2(59.37,20.21) v2(59.57,80.99) v2(59.57,80.36) v2(59.56,40.63) v2(59.95,86.2) v2(59.95,85.57) v2(59.95,84.93) v2(59.95,84.3) v2(59.86,82.54) v2(59.95,30.89) v2(59.95,28.6) v2(60.14,27.47) v2(60.21,67.79) v2(60.21,66.59) v2(60.21,65.4) v2(60.21,64.21) v2(60.43,41.43) v2(60.44,20.85) v2(60.46,93.14) v2(60.46,92.02) v2(60.46,90.9) v2(60.45,85.92) v2(60.69,118.55) v2(60.71,71.47) v2(61.16,61.56) v2(61.16,60.95) v2(61.22,30.51) v2(61.22,28.98) v2(61.21,27.56) v2(61.34,71.47) v2(61.57,93.14) v2(61.57,92.02) v2(61.57,90.9) v2(61.74,61.56) v2(61.75,60.95) v2(61.96,118.55) v2(62.06,23.17) v2(62.3,61.55) v2(62.31,60.95) v2(62.69,93.14) v2(62.69,92.02) v2(62.69,90.9) v2(62.84,70.2) v2(63.23,118.55) v2(63.76,113.89) v2(63.77,28.98) v2(63.77,27.46) v2(64.39,113.89) v2(64.5,118.55) v2(64.74,23.17) v2(65.03,29.29) v2(65.77,118.55) v2(66.31,30.51) v2(66.31,28.98) v2(66.31,27.46) v2(66.36,71.14) v2(66.37,70.44) v2(66.36,20.85) v2(66.65,75.79) v2(66.65,74.59) v2(66.65,73.4) v2(66.65,72.21) v2(67.04,118.55) v2(67.53,75.79) v2(67.53,74.59) v2(67.53,73.4) v2(67.53,72.21) v2(67.83,20.2) v2(67.95,70.45) v2(68.31,118.55) v2(68.41,75.79) v2(68.41,74.59) v2(68.41,73.4) v2(68.41,72.21) v2(68.52,70.45) v2(68.62,35.55) v2(68.83,92.22) v2(68.83,91.65) v2(68.84,90.7) v2(68.86,90.09) v2(68.86,89.5) v2(68.9,87.92) v2(68.9,87.34) v2(69.1,20.2) v2(69.58,118.55) v2(70.03,26.69) v2(70.37,20.2) v2(70.64,78.92) v2(70.63,31.27) v2(70.63,29.74) v2(70.63,28.98) v2(70.85,118.55) v2(71.27,78.94) v2(71.55,82.82) v2(71.57,83.41) v2(71.57,82.23) v2(71.62,81.64) v2(71.63,81.06) v2(71.63,80.49) v2(71.64,20.2) v2(71.86,78.95) v2(72.12,118.55) v2(72.2,82.96) v2(72.18,82.38) v2(72.21,81.81) v2(72.23,81.24) v2(72.23,80.68) v2(72.35,88.81) v2(72.35,80.11) v2(72.39,79.53) v2(72.46,78.96) v2(72.51,31.08) v2(72.51,29.55) v2(72.51,28.03) v2(72.65,93.5) v2(72.91,81.73) v2(72.91,80.86) v2(72.91,79.98) v2(72.91,20.2) v2(73.39,118.55) v2(74.02,87.02) v2(74.18,20.2) v2(74.48,115.46) v2(74.6,87.15) v2(74.56,30.51) v2(74.56,28.98) v2(74.56,27.46) v2(74.66,118.55) v2(75.18,87.13) v2(75.25,65.63) v2(75.45,20.2) v2(75.7,114.34) v2(75.93,118.55) v2(76.56,31.27) v2(76.56,29.74) v2(76.56,28.22) v2(76.72,20.2) v2(77.2,118.55) v2(77.78,85.73) v2(77.91,29.74) v2(77.91,28.22) v2(77.99,20.2) v2(78.08,86.2) v2(78.41,85.71) v2(78.47,118.55) v2(78.68,86.2) v2(79.01,85.68) v2(79.02,85.09) v2(79.29,86.21) v2(79.26,20.2) v2(79.62,85.69) v2(79.74,118.55) v2(79.73,29.74) v2(79.73,28.22) v2(79.73,26.7) v2(79.86,77.9) v2(79.86,65.48) v2(80.35,78.52) v2(80.37,65.79) v2(80.37,65.22) v2(80.53,20.2) v2(80.85,64.94) v2(80.96,118.21) v2(81.31,35.22) v2(81.41,98.27) v2(81.6,31.15) v2(81.62,28.6) v2(81.62,26.32) v2(81.67,117.15) v2(81.8,20.2) v2(82.78,116.55) v2(82.91,29.7) v2(82.91,28.18) v2(83.07,20.2) v2(83.94,79.19) v2(83.99,116.94) v2(84.2,78.56) v2(84.34,20.2) v2(84.37,118.15) v2(84.71,65.69) v2(84.72,64.97) v2(85.17,79.12) v2(85.29,29.74) v2(85.29,28.22) v2(85.38,65.68) v2(85.4,64.99) v2(85.64,118.15) v2(85.61,20.2) v2(86.34,117.22) v2(86.41,79.11) v2(86.69,30.58) v2(86.69,29.05) v2(86.69,27.53) v2(86.88,20.2) v2(87.41,116.54) v2(87.45,85.34) v2(87.64,79.14) v2(87.82,90.75) v2(88.08,81.88) v2(88.15,20.2) v2(88.64,116.85) v2(88.72,85.43) v2(88.85,79.12) v2(88.95,90.73) v2(88.98,31.27) v2(88.98,29.74) v2(88.98,28.22) v2(89.36,118.07) v2(89.42,20.2) v2(89.53,39.69) v2(89.56,80.52) v2(90.38,118.54) v2(90.59,80.19) v2(90.65,31.31) v2(90.65,29.79) v2(90.65,27.5) v2(90.69,20.2) v2(90.85,38.74) v2(90.83,38.12) v2(91,77.47) v2(91.21,80.23) v2(91.37,45.2) v2(91.44,38.11) v2(91.47,38.73) v2(91.65,118.54) v2(91.89,80.21) v2(92.04,38.73) v2(91.96,20.2) v2(92.05,38.11) v2(92.14,30.51) v2(92.14,28.98) v2(92.14,27.46) v2(92.34,77.43) v2(92.57,26.12) v2(93.07,118.55) v2(93.23,20.2) v2(93.3,80.18) v2(93.41,30.89) v2(93.41,28.6) v2(93.56,77.44) v2(94.03,108.84) v2(94.19,118.54) v2(94.5,20.2) v2(94.74,80.14) v2(94.68,30.51) v2(94.68,28.98) v2(94.68,27.46) v2(94.87,98.55) v2(95.11,81.64) v2(95.61,118.55) v2(95.77,20.2) v2(96.73,118.54) v2(97.04,20.2) v2(97.22,30.51) v2(97.22,28.98) v2(97.22,27.46) v2(97.77,71.83) v2(98,118.54) v2(98.31,20.2) v2(98.49,29.36) v2(98.49,27.08) v2(99.27,118.54) v2(99.62,71.79) v2(99.58,20.2) v2(99.76,28.98) v2(99.76,27.46) v2(100.54,118.54) v2(100.51,75.2) v2(100.5,70.5) v2(100.75,71.82) v2(100.85,20.2) v2(101.96,118.55) v2(102.12,20.2) v2(102.17,101.76) v2(102.35,75.02) v2(102.32,69.53) v2(102.3,30.51) v2(102.3,28.98) v2(102.3,27.46) v2(103.08,118.54) v2(103.39,20.2) v2(103.57,30.89) v2(103.57,28.6) v2(103.7,61.94) v2(103.7,60.17) v2(104.5,118.55) v2(104.66,20.2) v2(104.84,30.51) v2(104.84,28.98) v2(104.84,27.46) v2(105.22,62.77) v2(105.16,60.37) v2(105.62,118.54) v2(105.93,20.2) v2(106.89,118.54) v2(107.2,20.2) v2(107.42,61.99) v2(107.42,60.2) v2(107.47,30.51) v2(107.47,28.98) v2(107.47,27.46) v2(108.16,118.54) v2(108.47,20.2) v2(108.99,29.36) v2(108.99,27.08) v2(109.35,60.23) v2(109.58,118.55) v2(109.74,20.2) v2(110.26,30.51) v2(110.26,27.46) v2(110.39,71.96) v2(110.7,118.54) v2(110.66,110.69) v2(110.66,108.15) v2(111.01,20.2) v2(111.62,65.4) v2(111.6,59.77) v2(112.12,118.55) v2(112.28,20.2) v2(112.52,80.23) v2(112.84,110.69) v2(112.84,108.15) v2(112.8,36) v2(113.24,118.54) v2(113.25,77.68) v2(113.25,76.82) v2(113.25,75.93) v2(113.26,74.99) v2(113.55,20.2) v2(113.82,75.67) v2(114.15,61.11) v2(114.12,58.92) v2(114.51,118.54) v2(114.82,20.2) v2(115.03,110.69) v2(115.03,108.15) v2(115.01,78.05) v2(115.06,75.65) v2(115.33,62.58) v2(115.33,60.63) v2(115.33,58.68) v2(115.61,80.4) v2(115.78,118.54) v2(115.95,31.86) v2(116.09,20.2) v2(116.33,76.37) v2(116.32,75.53) v2(116.84,31.86) v2(117.05,118.54) v2(117.21,110.69) v2(117.21,108.15) v2(117.35,60.34) v2(117.38,58.51) v2(117.36,20.2) v2(117.94,92.73) v2(117.94,90.94) v2(117.91,32.35) v2(118.2,35.36) v2(118.32,118.54) v2(118.62,82.07) v2(118.62,81.37) v2(118.62,79.66) v2(118.62,78.71) v2(118.62,76.87) v2(118.62,34.96) v2(118.63,20.2) v2(119,113.38) v2(119.13,31.86) v2(119.13,31.27) v2(119.41,79.09) v2(119.74,118.55) v2(119.9,20.2) v2(120.04,61.17) v2(120.04,59.22) v2(120.11,57.85) v2(120.43,93.67) v2(120.36,91.68) v2(120.37,89.73) v2(120.86,118.54) v2(120.96,81.15) v2(121.17,20.2) v2(121.4,65.36) v2(121.62,62.79) v2(121.68,41.19) v2(121.83,59.92) v2(122.28,118.55) v2(122.44,20.2) v2(123.4,118.54) v2(123.35,102.6) v2(123.71,20.2) v2(123.78,103.22) v2(123.95,102.66) v2(124.08,62.09) v2(124.08,60.14) v2(124.08,58.08) v2(124.08,56.79) v2(124.67,118.54) v2(124.98,20.2) v2(125.58,74.21) v2(125.86,103.74) v2(125.85,62.74) v2(125.85,60.79) v2(125.85,58.84) v2(125.85,56.73) v2(126.09,118.55) v2(126.07,81.16) v2(126.07,33.1) v2(126.07,31.58) v2(126.07,30.05) v2(126.25,20.2) v2(126.43,64.67) v2(127.21,118.54) v2(127.52,20.2) v2(127.63,61.03) v2(127.63,59.21) v2(127.67,57.5) v2(128.07,82.56) v2(128.07,81.35) v2(128.09,80.77) v2(128.1,79.11) v2(128.15,78.53) v2(128.07,33.48) v2(128.07,31.19) v2(128.22,80.16) v2(128.16,77.95) v2(128.48,118.54) v2(128.83,78.56) v2(128.79,20.2) v2(129.34,33.1) v2(129.34,31.58) v2(129.51,62.09) v2(129.51,60.14) v2(129.63,81.21) v2(129.63,80) v2(129.75,118.54) v2(129.82,78.79) v2(130.06,20.2) v2(131.02,118.54) v2(131.11,62.74) v2(131.11,60.79) v2(131.33,20.2) v2(131.42,65.35) v2(132.14,33.15) v2(132.14,31.58) v2(132.14,30.05) v2(132.44,118.55) v2(132.6,20.2) v2(132.79,90.97) v2(132.99,29.95) v2(133.1,61.44) v2(133.07,59.56) v2(133.24,32.97) v2(133.24,30.69) v2(133.56,118.54) v2(133.87,20.2) v2(134.1,33.8) v2(134.83,118.54) v2(134.83,33.1) v2(134.83,31.58) v2(134.83,30.05) v2(135.15,92.3) v2(135.14,20.2) v2(136.1,118.54) v2(136.2,57.27) v2(136.41,20.2) v2(136.6,33.1) v2(136.6,31.58) v2(136.6,30.05) v2(137.37,118.54) v2(137.68,20.2) v2(138.64,118.54) v2(138.95,20.2) v2(138.99,92.16) v2(139.05,31.19) v2(140.06,118.55) v2(140.22,20.2) v2(140.32,33.1) v2(140.32,31.58) v2(140.32,30.05) v2(141.39,91.64) v2(141.49,20.2) v2(142.36,101.39) v2(142.43,31.58) v2(142.43,30.05) v2(142.6,118.55) v2(142.76,20.2) v2(142.91,101.1) v2(143.72,118.54) v2(143.75,30.43) v2(144.03,20.2) v2(144.85,118.55) v2(145.3,20.2) v2(145.41,31.58) v2(145.41,30.06) v2(146.01,67.05) v2(146.26,118.54) v2(146.57,20.2) v2(146.92,29.65) v2(147.3,73.06) v2(147.53,118.54) v2(147.84,20.2) v2(148.55,73.07) v2(148.95,118.55) v2(149.11,20.2) v2(150.07,118.54) v2(150.36,33.13) v2(150.38,20.2) v2(150.74,29.38) v2(150.96,32.24) v2(150.96,30.71) v2(151.49,118.55) v2(151.65,20.2) v2(152.29,33.98) v2(152.3,32.49) v2(152.3,30.97) v2(152.3,29.44) v2(152.76,118.55) v2(152.92,20.22) v2(153.26,34.05) v2(153.3,32.62) v2(153.3,31.09) v2(153.34,20.78) v2(153.62,21.28) v2(153.88,118.54) v2(154.16,21.75) v2(154.71,21.93) v2(155.05,32.46) v2(155.05,30.94) v2(155.15,118.54) v2(155.41,21.96) v2(155.98,21.95) v2(156.42,118.54) v2(156.67,21.83) v2(156.86,32.74) v2(156.86,31.22) v2(156.86,29.7) v2(157.17,21.51) v2(157.59,20.95) v2(157.69,118.54) v2(157.79,20.41) v2(158.69,32.73) v2(158.69,31.2) v2(159.05,20.2) v2(159.11,118.55) v2(159.15,103.16) v2(159.12,101.38) v2(159.16,103.74) v2(159.59,115.2) v2(159.72,22.43) v2(159.7,20.8) v2(160.41,31.6) v2(161.28,117.64) v2(161.28,112.76) v2(161.45,32.74) v2(161.45,31.22) v2(161.45,29.7) v2(162.12,24.66) v2(163.41,32.74) v2(163.41,31.22) v2(163.69,24.61) v2(163.92,68.84) v2(164.12,117.64) v2(164.12,112.76) v2(164.48,68.83) v2(164.7,90.28) v2(164.87,97.5) v2(165.03,23.86) v2(165.16,104.28) v2(165.25,33.51) v2(165.25,31.98) v2(165.25,30.46) v2(165.29,90.28) v2(165.5,97.5) v2(165.65,103.81) v2(165.66,23.23) v2(165.81,115.2) v2(166.58,118.54) v2(167.23,23.2) v2(167.29,39.37) v2(167.51,32.76) v2(167.51,31.23) v2(167.85,118.54) v2(168.09,85.82) v2(168.09,84.3) v2(168.15,38.73) v2(168.49,29.64) v2(168.5,23.2) v2(168.7,37.43) v2(169.12,118.54) v2(169.25,34.18) v2(169.25,32.65) v2(169.25,31.13) v2(169.33,29.64) v2(169.61,85.82) v2(169.61,84.3) v2(169.61,82.77) v2(169.61,26.7) v2(169.77,23.2) v2(170.39,118.54) v2(170.42,33.3) v2(170.42,31.78) v2(170.42,30.26) v2(171.02,22.96) v2(171.13,85.82) v2(171.13,84.3) v2(171.13,82.77) v2(171.69,21.88) v2(171.71,20.61) v2(171.81,118.55) v2(171.88,111.93) v2(171.88,110.81) v2(172.27,33.83) v2(172.27,31.55) v2(172.93,118.54) v2(172.91,20.2) v2(173,111.93) v2(173,110.81) v2(173.89,38.45) v2(174.2,118.54) v2(174.2,33.45) v2(174.2,31.93) v2(174.2,30.4) v2(174.18,20.2) v2(174.84,111.14) v2(174.86,108.39) v2(174.87,107.58) v2(174.88,106.85) v2(174.88,106.04) v2(175.44,41.62) v2(175.47,118.54) v2(175.47,112.54) v2(175.45,111.14) v2(175.45,20.2) v2(176.05,112.55) v2(175.95,33.45) v2(175.95,31.93) v2(175.95,30.4) v2(176.7,117.87) v2(176.72,20.2) v2(176.82,116.6) v2(177.45,30.02) v2(177.56,32.29) v2(177.77,115.76) v2(177.99,20.2) v2(178.09,100.49) v2(178.21,39.34) v2(178.6,33.45) v2(178.6,31.93) v2(178.6,30.4) v2(179.04,115.7) v2(179,100.37) v2(179.01,99.8) v2(179.31,103.13) v2(179.29,102.38) v2(179.26,20.2) v2(180.31,115.7) v2(180.53,20.2) v2(180.63,33.45) v2(180.63,31.93) v2(180.63,30.4) v2(181.24,98.86) v2(181.58,115.7) v2(181.82,98.85) v2(181.8,20.2) v2(181.99,98.23) v2(182.37,98.84) v2(182.41,33.83) v2(182.41,31.55) v2(182.58,108.88) v2(182.58,107.8) v2(182.58,107.22) v2(182.56,106.58) v2(182.58,98.22) v2(182.85,115.7) v2(183.07,20.2) v2(183.68,33.45) v2(183.68,31.93) v2(183.68,30.4) v2(184.12,115.7) v2(184.07,99.87) v2(184.43,20.22) v2(184.7,99.87) v2(184.76,21.6) v2(185.34,99.87) v2(185.73,117.21) v2(185.7,110.97) v2(185.7,109.85) v2(185.87,106.75) v2(185.98,107.36) v2(185.99,105.87) v2(186.38,23.92) v2(186.51,118.55) v2(186.6,105.9) v2(186.56,31.93) v2(186.56,30.4) v2(186.83,110.98) v2(186.82,109.86) v2(187.42,70.71) v2(187.46,118.55) v2(187.83,33.07) v2(187.83,32.31) v2(188.73,118.55) v2(189.1,33.45) v2(189.1,30.59) v2(189.05,23.92) v2(189.6,78.15) v2(189.6,77.56) v2(189.89,118.55) v2(190.24,102.55) v2(190.61,20.47) v2(190.68,21.6) v2(190.86,118.46) v2(191.1,117.9) v2(191.35,116.66) v2(191.47,104.69) v2(191.47,100.41) v2(191.86,116.18) v2(191.85,20.2) v2(192.43,115.98) v2(192.7,114.74) v2(192.7,113.47) v2(192.7,112.2) v2(192.7,110.93) v2(192.7,109.66) v2(192.84,108.4) v2(192.99,71.49) v2(193.12,20.2) v2(193.83,107.59) v2(193.93,104.69) v2(193.93,100.41) v2(194.15,29.78) v2(194.25,32.25) v2(194.2,29.2) v2(194.2,27.66) v2(194.43,31.71) v2(194.39,20.2) v2(195.09,107.51) v2(195.16,102.55) v2(195.4,106.27) v2(195.4,98.65) v2(195.4,97.38) v2(195.4,96.11) v2(195.4,94.84) v2(195.4,93.57) v2(195.4,92.3) v2(195.4,91.03) v2(195.4,89.76) v2(195.4,88.49) v2(195.4,87.22) v2(195.4,85.95) v2(195.4,84.68) v2(195.4,83.41) v2(195.4,82.14) v2(195.4,80.87) v2(195.43,79.61) v2(195.53,78.34) v2(195.65,31.66) v2(195.67,77.08) v2(195.66,20.2) v2(195.88,75.82) v2(196.13,74.58) v2(196.45,73.35) v2(196.5,36.44) v2(196.49,33.92) v2(196.51,24.08) v2(196.51,22.27) v2(196.81,72.13) v2(196.78,27.04) v2(196.93,20.2) v2(197.06,36.39) v2(197.23,70.93) v2(197.39,27.05) v2(197.55,24.08) v2(197.55,22.27) v2(197.7,69.76) v2(198.02,27.04) v2(198.23,68.6) v2(198.2,20.2) v2(198.8,67.47) v2(199.43,66.36) v2(199.47,20.2) v2(199.87,43.09) v2(200.1,65.28) v2(200.28,42.66) v2(200.37,35.09) v2(200.72,42.19) v2(200.74,20.2) v2(200.82,64.23) v2(201.17,41.75) v2(201.58,63.22) v2(202.01,20.2) v2(202.39,62.24) v2(203.24,61.3) v2(203.28,20.2) v2(204.13,60.39) v2(204.41,22.64) v2(204.55,20.2) v2(204.73,22.07) v2(205.06,59.53) v2(205.11,22.64) v2(205.42,22.07) v2(205.81,22.64) v2(205.82,20.2) v2(206.03,58.7) v2(206.12,22.07) v2(206.44,22.64) v2(206.81,30.75) v2(206.76,22.07) v2(207.03,57.92) v2(207.14,22.64) v2(207.09,20.2) v2(207.46,22.07) v2(207.84,22.64) v2(208.07,57.19) v2(208.18,30.66) v2(208.16,22.07) v2(208.36,20.2) v2(208.54,22.64) v2(208.84,30.66) v2(208.85,22.07) v2(209.14,56.51) v2(209.23,22.64) v2(209.55,22.07) v2(209.63,20.2) v2(209.68,30.7) v2(210.24,55.89) v2(210.9,20.2) v2(211.38,55.33) v2(212.17,20.2) v2(212.55,54.83) v2(213.44,20.2) v2(213.75,54.4) v2(214.71,20.2) v2(214.97,54.04) v2(215.98,20.2) v2(216.2,53.74) v2(217.25,20.2) v2(217.45,53.51) v2(218.52,20.2) v2(218.71,53.36) v2(219.79,20.2) v2(219.98,53.27) v2(221.06,20.2) v2(221.25,53.25) v2(222.33,20.2) v2(222.52,53.25) v2(222.79,29.91) v2(223.38,29.9) v2(223.6,20.2) v2(223.79,53.25) v2(223.99,29.9) v2(224.6,29.9) v2(224.87,20.2) v2(225.06,53.25) v2(225.18,29.91) v2(225.77,29.91) v2(226.14,20.2) v2(226.33,53.25) v2(226.33,29.91) v2(226.9,29.91) v2(227.41,20.2) v2(227.46,29.9) v2(227.6,53.25) v2(227.95,44.55) v2(228.68,20.2) v2(228.87,53.29) v2(229.95,20.2) v2(230.13,53.4) v2(231.22,20.2) v2(231.39,53.59) v2(232.49,20.2) v2(232.63,53.84) v2(233.76,20.2) v2(233.86,54.16) v2(234.63,26.88) v2(235.03,20.2) v2(235.07,54.54) v2(236.26,55) v2(236.3,20.2) v2(236.91,27.1) v2(237.42,55.52) v2(237.62,26.38) v2(237.57,20.2) v2(237.7,27.91) v2(237.87,22.21) v2(238.3,27.91) v2(238.25,26.38) v2(238.55,56.1) v2(238.51,22.21) v2(238.84,20.2) v2(239.08,22.21) v2(239.46,28.16) v2(239.46,26.64) v2(239.46,26) v2(239.64,56.74) v2(240.1,28.16) v2(240.1,26.64) v2(240.1,26) v2(240.11,20.2) v2(240.7,57.44) v2(241.38,20.2) v2(241.72,58.19) v2(242.72,58.99) v2(242.65,20.2) v2(243.67,59.82) v2(243.92,20.2) v2(244.59,60.7) v2(245.19,20.2) v2(245.46,61.62) v2(246.3,62.58) v2(246.46,20.2) v2(247.09,63.57) v2(247.73,20.2) v2(247.84,64.6) v2(248.29,42.02) v2(248.54,65.65) v2(249,20.2) v2(249.2,66.74) v2(250.27,20.2) v2(250.36,69) v2(250.87,70.16) v2(250.89,68.61) v2(251.32,71.35) v2(251.54,20.2) v2(252.07,73.78) v2(252.17,71.39) v2(252.17,67.11) v2(252.36,75.01) v2(252.6,76.26) v2(252.79,77.52) v2(252.81,20.2) v2(252.91,78.78) v2(253,106.72) v2(253,105.45) v2(253,104.18) v2(253,102.91) v2(253,101.64) v2(253,100.37) v2(253,99.1) v2(253,97.83) v2(253,96.56) v2(253,95.29) v2(253,94.02) v2(253,92.75) v2(253,91.48) v2(253,90.21) v2(253,88.94) v2(253,87.67) v2(253,86.4) v2(253,85.13) v2(253,83.86) v2(253,82.59) v2(253,81.32) v2(252.99,80.05) v2(253.19,107.43) v2(253.96,107.55) v2(254.08,20.2) v2(254.63,71.39) v2(254.63,67.11) v2(255.18,107.91) v2(255.35,20.2) v2(255.7,115.42) v2(255.7,114.15) v2(255.7,112.88) v2(255.7,111.61) v2(255.7,110.34) v2(255.7,109.07) v2(255.86,69.25) v2(256.62,20.2) v2(256.65,116.26) v2(257.89,20.2) v2(258.43,116.7) v2(259.02,118.55) v2(259.16,20.2) v2(259.32,115.17) v2(259.74,77.31) v2(260.29,118.55) v2(260.43,20.2) v2(260.65,77.28) v2(261.04,56.31) v2(261.08,115.17) v2(261.56,118.55) v2(261.7,20.2) v2(261.97,116.7) v2(262.47,77.35) v2(262.83,118.55) v2(262.76,63.32) v2(262.97,20.2) v2(263.07,77.38) v2(263.66,77.38) v2(264.24,20.2) v2(265.37,118.55) v2(265.51,20.2) v2(266.24,61.92) v2(266.64,118.55) v2(266.78,20.2) v2(267.4,62.76) v2(267.91,118.55) v2(268.05,20.2) v2(269.18,118.55) v2(269.32,20.2) v2(270.45,118.55) v2(270.48,23.69) v2(270.59,20.2) v2(271.72,118.55) v2(271.66,84.93) v2(271.86,20.2) v2(272.42,84.93) v2(273.13,20.2) v2(273.28,59.26) v2(273.28,57.15) v2(274.03,95.69) v2(274.03,94.42) v2(274.03,93.15) v2(274.26,118.55) v2(274.33,58.21) v2(274.4,20.2) v2(274.58,63.72) v2(275.3,95.69) v2(275.3,94.42) v2(275.3,93.15) v2(275.38,59.26) v2(275.38,57.15) v2(275.53,118.55) v2(275.53,53.37) v2(275.47,50.2) v2(275.67,20.2) v2(275.85,52.8) v2(276.57,95.69) v2(276.57,94.42) v2(276.57,93.15) v2(276.8,118.55) v2(276.94,20.2) v2(277.62,78.12) v2(277.64,77.55) v2(278.07,118.55) v2(278.21,20.2) v2(278.28,78.13) v2(278.89,78.11) v2(279.34,118.55) v2(279.49,78.12) v2(279.48,20.2) v2(280.09,78.12) v2(280.61,118.55) v2(281.24,21.3) v2(281.49,118.44) v2(281.7,117.89) v2(281.69,117.19) v2(281.81,116.63) v2(282.23,116.04) v2(282.47,23.44) v2(282.74,115.77) v2(282.77,50.83) v2(283.45,115.69) v2(284.01,115.7) v2(284.11,98.96) v2(284.32,96.41) v2(284.72,115.69) v2(284.93,23.44) v2(284.96,66.81) v2(285.28,115.7) v2(285.26,89.64) v2(285.81,65.88) v2(285.99,115.69) v2(285.99,98.92) v2(286.14,96.42) v2(286.25,65.41) v2(286.16,21.3) v2(286.39,69.31) v2(286.53,89.64) v2(286.55,115.7) v2(287.15,69.31) v2(287.26,115.69) v2(287.38,64.77) v2(287.54,87.89) v2(287.56,89.65) v2(287.58,78.51) v2(287.57,19.16) v2(287.68,31.19) v2(287.77,115.35) v2(287.8,114.08) v2(287.78,69.31) v2(287.85,61.8) v2(288.17,63.42) v2(288.17,62.85) v2(288.43,112.98) v2(288.47,18.26) v2(288.88,58.36) v2(289.36,17.36) v2(289.67,112.7) v2(289.71,11.06) v2(289.71,9.79) v2(289.71,8.52) v2(289.7,7.17) v2(289.71,5.98) v2(289.71,4.71) v2(289.71,3.44) v2(289.71,2.17) v2(289.72,0.9) v2(290.83,14.6) v2(290.94,112.7) v2(290.93,0.51) v2(291.29,59.09) v2(291.72,16.13) v2(291.72,13.07) v2(292.21,112.7) v2(292.2,0.51) v2(292.67,57.56) v2(293.16,63.28) v2(293.48,112.7) v2(293.48,16.13) v2(293.48,13.07) v2(293.5,0.5) v2(294.02,68.6) v2(294.37,14.6) v2(294.64,69.22) v2(294.64,67.98) v2(294.75,112.7) v2(294.74,0.51) v2(294.77,41.81) v2(295.26,68.6) v2(296.02,112.7) v2(296.01,0.51) v2(296.48,41.61) v2(296.73,53.06) v2(296.73,50.83) v2(297.29,112.7) v2(297.28,0.51) v2(297.78,64.5) v2(297.85,51.95) v2(298.34,34.38) v2(298.34,32.42) v2(298.34,30.45) v2(298.56,112.7) v2(298.64,42.51) v2(298.55,0.51) v2(298.97,53.06) v2(298.97,50.83) v2(299.28,42.51) v2(299.83,112.7) v2(299.82,0.51) v2(299.9,42.5) v2(300.1,54.76) v2(300.31,34.38) v2(300.31,32.42) v2(300.31,30.45) v2(301.1,112.7) v2(301.12,0.5) v2(302.27,34.38) v2(302.27,32.42) v2(302.37,112.7) v2(302.43,108.2) v2(302.36,0.51) v2(303,4.94) v2(303.22,3.69) v2(303.32,109.73) v2(303.32,106.67) v2(303.34,1.32) v2(303.53,54.45) v2(303.5,6.12) v2(303.64,112.7) v2(303.59,52.14) v2(303.74,2.53) v2(304.29,54.45) v2(304.53,6.84) v2(304.91,112.7) v2(305.08,109.73) v2(305.08,106.67) v2(305.31,6.98) v2(305.44,68.29) v2(305.44,66.26) v2(305.44,54.43) v2(305.39,52.06) v2(305.97,108.2) v2(306.18,112.7) v2(306.71,98.65) v2(306.79,2.72) v2(306.89,6.26) v2(307.09,1.45) v2(307.28,98.43) v2(307.45,112.7) v2(307.35,3.86) v2(307.47,5.13) v2(307.89,0.51) v2(308.23,102.46) v2(308.72,112.7) v2(308.87,102.46) v2(308.9,70.7) v2(309.16,0.51) v2(309.39,33.33) v2(309.99,112.7) v2(310.43,0.51) v2(311.26,112.7) v2(311.7,0.51) v2(312.53,112.7) v2(312.97,0.51) v2(313.8,112.7) v2(314.11,69.16) v2(314.23,72.78) v2(314.24,0.51) v2(314.48,53.93) v2(314.57,51.04) v2(315.07,112.7) v2(315.26,99.82) v2(315.55,0.5) v2(316.34,112.69) v2(316.42,53.93) v2(316.42,10.45) v2(316.78,0.51) v2(316.87,69.14) v2(317.59,112.49) v2(318.05,0.51) v2(318.53,51.17) v2(318.75,111.97) v2(319.32,0.51) v2(319.37,50.03) v2(319.74,111.18) v2(320.17,48.86) v2(320.45,8.55) v2(320.53,100.21) v2(320.59,0.51) v2(320.71,71.84) v2(320.92,110.7) v2(321.31,14.65) v2(321.4,48.71) v2(321.37,10.16) v2(321.37,6.94) v2(321.86,0.51) v2(322.15,69.86) v2(322.26,53.62) v2(322.58,33.75) v2(322.58,14.64) v2(322.67,48.71) v2(323.13,0.51) v2(323.23,10.16) v2(323.23,6.94) v2(323.94,48.71) v2(323.85,14.65) v2(324.15,8.55) v2(324.44,0.5) v2(324.78,100.71) v2(325.11,14.42) v2(325.21,48.71) v2(325.35,33.08) v2(325.53,72.25) v2(325.48,13.21) v2(325.67,0.59) v2(325.88,109.11) v2(325.89,107.66) v2(325.9,106.39) v2(325.9,105.12) v2(325.9,103.85) v2(325.89,102.58) v2(325.89,100.04) v2(325.89,12.01) v2(325.89,5.66) v2(325.89,4.39) v2(325.89,3.12) v2(325.89,1.85) v2(326.32,48.37) v2(326.34,45.18) v2(326.34,43.91) v2(326.34,42.64) v2(326.34,41.37) v2(326.34,40.1) v2(326.34,38.83) v2(326.34,36.29) v2(326.34,35.02) v2(326.34,33.75) v2(326.37,47.11) v3(287.91,68.61)
