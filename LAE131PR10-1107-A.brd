# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_CLK: length 19.5
  TOP w0.112: RC16.1 147.45,61.31 147.45,62.24 146.67,63.02 146.24,63.02 146.05,62.83 146.05,62.62 v2(146.13,62.54)
  BOTTOM w0.076: UC1.AW9 140.62,67.84 140.44,67.66 140.44,67.66 140.26,67.08 140.26,65.92 140.51,65.68 140.91,65.68 141.03,65.55 141.03,65.44 140.99,65.4 140.99,65.29 141.1,65.18 141.21,65.18 141.25,65.23 141.36,65.23 142.57,64.01 142.68,64.01 143.02,64.36 143.13,64.36 143.24,64.25 143.24,64.14 142.9,63.79 142.9,63.69 143,63.58 143.11,63.58 143.46,63.92 143.56,63.92 143.67,63.82 143.67,63.71 143.33,63.36 143.33,63.26 143.5,63.08 144.5,63.08 144.58,63.16 144.58,63.77 144.66,63.85 144.81,63.85 144.88,63.77 144.88,63.16 144.96,63.08 145.11,63.08 145.19,63.16 145.19,63.77 145.26,63.85 145.42,63.85 145.49,63.77 145.49,63.16 145.57,63.08 145.83,63.08 145.9,63.16 145.9,63.51 145.98,63.59 146.13,63.59 146.21,63.51 146.21,63.16 146.29,63.07 146.38,63.07 146.5,62.96 146.5,62.67 146.37,62.54 v2(146.13,62.54)
ESPI_CLK_5105: length 142.7
  TOP w0.112: RE350.1 253.94,40.1 252.72,40.1 v2(252.48,39.87) ; v2(266.82,41.19) UE1.G7 ; v2(162.77,51.13) 162.77,51.12 158.11,51.12 157.41,51.82 157.27,51.82 155.72,53.37 155.72,55.32 154.58,56.47 149.88,56.47 146.81,59.53 146.81,61.03 RC16.2 146.18,61.18 CC316.1
  IN1 w0.119: v2(162.77,51.13) 163.41,51.13 163.82,51.54 171.95,51.54 172.24,51.25 180.11,51.25 181.29,50.07 189.23,50.07 189.74,49.56 190.52,49.56 197.03,43.05 197.64,43.05 200.13,40.55 200.42,40.27 200.42,40.26 200.82,40.26 200.82,40.27 202.42,40.27 203.69,39 204.71,39 205.95,37.76 210.37,37.76 211.2,36.93 215.56,36.93 215.56,36.93 216.47,36.93 217.46,37.92 230.46,37.92 v2(230.76,38.22) 231.37,37.61 231.74,37.61 231.86,37.49 238.76,37.49 239.23,37.02 241.52,37.02 241.66,36.87 243.72,36.87 243.96,37.11 244.89,37.11 245.07,36.93 245.76,36.93 245.82,36.99 247.41,36.99 249.66,39.24 251.85,39.24 v2(252.48,39.87)
  IN3 w0.135: v2(266.82,41.19) 266.69,41.05 265.94,41.05 265.72,40.83 262.68,40.83 262.4,40.55 260.7,40.55 260.22,40.08 259.93,40.08 259.49,39.64 252.79,39.64 252.56,39.87 v2(252.48,39.87)
  BOTTOM w0.112: JESPI.10 227.91,38.11 228.3,37.73 v3(229.61,37.73) 230.26,37.73 v2(230.76,38.22)
ESPI_CS#: length 164.5
  TOP w0.112: UE1.H6 268.33,40.48 v2(268.42,40.48)
  IN1 w0.119: v2(165.42,59.98) 165.42,59.88 168.99,56.31 179.34,56.31 180.4,55.25 183.66,55.25 184.11,55.7 188.35,55.7 189.13,54.92 191.44,54.92 196.73,49.63 197.2,49.63 198.03,49.63 202.59,45.07 203.9,45.07 205.53,45.07 206.36,44.24 207.44,43.16 221.9,43.16 222.32,43.16 222.65,42.82 227.58,42.82 v2(227.75,42.99) 229.41,42.99 229.73,42.66 232.6,42.66 232.69,42.57 244.49,42.57 252.67,50.75 257.23,50.75 258.64,52.16 262.19,52.16 262.56,51.8 265.35,51.8 v2(266.24,52.7)
  IN2 w0.124: v2(268.42,40.48) 268.03,40.86 268.03,47.36 267.13,48.26 267.13,51.81 v2(266.24,52.7)
  BOTTOM w0.076: UC1.BA12 138.79,66.93 138.79,64.92 140.1,63.61 141.06,63.61 141.77,62.9 141.77,62.26
  BOTTOM w0.112: v2(227.75,42.99) 227.75,42.89 226.39,41.54 226.39,38.58 JESPI.7 ; 141.77,62.26 141.77,62.06 142.01,61.82 142.9,61.82 143.39,62.31 145.1,62.31 145.82,61.59 145.82,60.82 147.17,59.48 157.84,59.48 158.6,60.24 164.45,60.24 164.78,59.92 165.36,59.92 v2(165.42,59.98)
ESPI_IO0: length 118
  TOP w0.112: RC366.2 180.96,59.7 180.98,59.67 v3(181.35,59.67) v2(182.26,59.67) ; 269.62,39.99 269.93,39.68 v2(270.02,39.68)
  IN1 w0.119: v2(182.26,59.67) 182.38,59.79 189.04,59.79 189.04,59.79 189.2,59.79 190.55,58.45 192.65,58.45 198.04,53.05 198.43,53.05 204.81,46.67 206.09,46.67 208.05,44.71 v2(223,44.71) 223.36,44.35 223.6,44.35 223.6,44.35 224.96,44.35 224.97,44.35 225.2,44.35 225.2,44.35 226.04,44.35 226.04,44.35 226.15,44.35 226.74,44.94 230.15,44.94 230.91,44.18 243.95,44.18 252.53,52.75 256.36,52.75 256.79,53.18 v2(259.18,53.18)
  BOTTOM w0.112: v2(259.18,53.18) 259.18,52.29 260.84,50.62 260.84,45.25 261.73,44.36 261.73,43.41 263.12,42.03 266.79,42.03 267.97,40.85 267.97,40.37 268.26,40.09 268.58,40.09 268.71,40.23 269.39,40.23 269.93,39.68 v2(270.02,39.68) ; JESPI.3 224.41,40.53 223.91,41.02 223.91,43.8 v2(223,44.71)
ESPI_IO0_R: length 51
  TOP w0.112: v2(178.36,60.51) 178.36,59.96 v3(178.45,59.87) 178.63,59.7 RC366.1
  BOTTOM w0.076: UC1.AY13 138.2,67.13 138.09,67.02 137.99,66.91 137.92,66.7 137.92,66.58 137.98,66.35 137.98,66.21 137.93,66.09 137.93,65.83 138.06,65.7 138.06,64.23 138.63,63.66 138.8,63.66 140.79,61.67
  BOTTOM w0.107: 140.79,61.67 140.79,61.49 141.29,60.99
  BOTTOM w0.112: v2(178.36,60.51) 177.99,60.51 177.49,60 168.09,60 164.77,56.68 160.97,56.68 160.4,56.1 156.59,56.1 156.02,56.68 146.69,56.68 144.24,59.12 142.21,59.12 141.29,60.05 141.29,60.99
ESPI_IO1: length 126.7
  TOP w0.112: RC367.2 181.12,61.46 181.42,61.16 v2(181.42,60.41) ; v2(270.83,38.7) 270.83,38.78 UE1.L4
  IN1 w0.119: v2(181.42,60.41) 181.57,60.56 189.13,60.56 190.75,58.94 192.85,58.94 198.25,53.54 198.64,53.54 205.01,47.17 206.29,47.17 208.09,45.37 223.49,45.37 v2(223.68,45.18) 224.01,44.85 224.53,44.85 225.11,45.43 226.53,45.43 226.53,45.43 226.94,45.43 230.35,45.43 230.56,45.43 230.97,45.02 241.3,45.02 242.1,45.81 244.35,45.81 252.48,53.94 260.86,53.94 262.71,52.1 264.73,52.1 265.79,53.16 267.42,53.16 268.46,54.2 v2(268.68,54.2)
  IN2 w0.124: v2(270.83,38.7) 272.03,39.9 272.03,44.53 271.18,45.38 271.18,47.46 270.75,47.89 270.75,51.84 269.99,52.6 269.99,52.88 v2(268.68,54.2)
  BOTTOM w0.112: v2(223.68,45.18) 224.15,44.71 224.15,41.12 224.91,40.37 JESPI.4
ESPI_IO1_R: length 48.5
  TOP w0.112: v2(177.56,61.27) 177.75,61.46 v3(178.26,61.46) RC367.1
  BOTTOM w0.076: UC1.BA13 138.2,66.43 138.46,66.17 138.46,64.78 140.01,63.23 140.67,63.23 141.25,62.66
  BOTTOM w0.112: v2(177.56,61.27) 176.89,60.6 166.96,60.6 164.04,57.68 160.76,57.68 160.04,56.96 156.95,56.96 156.23,57.68 147.44,57.68 144.16,60.96 142.08,60.96 141.25,61.79 141.25,62.66
ESPI_IO2: length 117.8
  TOP w0.112: v2(181.01,60.83) 180.77,60.59 RC368.2 ; v2(266.82,40.39) UE1.G6
  IN1 w0.119: v2(263.73,52.6) 262.61,52.6 261.02,54.19 252.38,54.19 244.25,46.06 242,46.06 241.2,45.27 231.07,45.27 230.8,45.53 230.66,45.68 230.45,45.68 227.04,45.68 226.43,45.68 226.43,45.68 224.77,45.68 v2(224.38,45.29) 223.99,45.68 208.48,45.68 208.13,45.68 206.39,47.41 205.12,47.41 198.74,53.79 198.35,53.79 192.95,59.19 190.85,59.19 189.24,60.8 181.04,60.8 v2(181.01,60.83)
  IN2 w0.124: v2(263.73,52.6) 265.66,52.6 266.88,51.38 266.88,48.15 267.73,47.3 267.73,41.29 v2(266.82,40.39)
  BOTTOM w0.112: v2(224.38,45.29) 224.48,45.19 224.48,41.13 225.41,40.2 JESPI.5
ESPI_IO2_R: length 49.1
  TOP w0.112: v3(177.21,60.51) 177.58,60.51 v2(178.03,60.96) 178.03,60.96 179,60.96 RC368.1
  BOTTOM w0.076: 141.02,61.98 139.18,63.83 138.7,63.83 138.29,64.24 138.29,65.89 UC1.BB13
  BOTTOM w0.107: 141.23,61.41 141.02,61.61 141.02,61.98
  BOTTOM w0.112: 141.23,61.41 141.91,60.72 144.06,60.72 147.48,57.3 156.28,57.3 156.85,56.72 160.14,56.72 160.72,57.3 164.09,57.3 167.11,60.31 177.39,60.31 v2(178.03,60.96)
ESPI_IO3: length 121.5
  TOP w0.112: v2(181.89,60.09) 181.89,61.48 v3(181.63,61.74) 181.01,62.36 RC369.2 ; UE1.L5 270.73,39.68 270.82,39.68 v2(270.84,39.66)
  IN1 w0.119: v2(181.89,60.09) 182.11,60.31 189.03,60.31 190.65,58.69 192.75,58.69 198.15,53.3 198.54,53.3 204.91,46.92 206.19,46.92 207.99,45.12 208.19,45.12 223.18,45.12 223.7,44.6 224.86,44.6 v2(225.08,44.82) 225.3,44.6 225.94,44.6 226.52,45.19 226.63,45.19 226.63,45.19 226.84,45.19 226.84,45.19 230.05,45.19 230.25,45.19 230.39,45.04 230.39,45.04 231.01,44.43 243.85,44.43 253.06,53.63 260.14,53.63 v2(260.73,53.04)
  BOTTOM w0.112: v2(260.73,53.04) 260.72,53.02 260.72,51.09 261.08,50.72 261.08,45.35 261.97,44.46 261.97,43.51 263.22,42.27 266.89,42.27 268.26,40.9 269.06,40.9 269.88,40.07 270.43,40.07 v2(270.84,39.66) ; v2(225.08,44.82) 224.78,44.52 224.78,41.45 225.91,40.32 JESPI.6
ESPI_IO3_R: length 49.9
  TOP w0.112: v2(176.78,62) 177.53,62.74 v3(178.08,62.74) 179.01,62.74 RC369.1
  BOTTOM w0.076: 141.15,63.21 140.97,63.4 140.08,63.4 138.63,64.85 138.63,66.53 138.46,66.69 138.46,67.12 138.77,67.42 UC1.AY12
  BOTTOM w0.112: v2(176.78,62) 175.62,60.84 166.85,60.84 163.94,57.93 160.68,57.93 159.95,57.2 157.05,57.2 156.32,57.93 147.52,57.93 144.26,61.2 142.25,61.2 141.53,61.91 141.53,62.83 141.15,63.21
ESPI_RESET#: length 154.3
  TOP w0.112: 269.62,40.79 269.72,40.79 v2(270.02,40.48)
  IN2 w0.124: v2(270.02,40.48) 269.58,40.04 269.58,38.64 269.33,38.39 268.27,38.39 267.03,37.15 260.72,37.15 259.43,38.43 257.37,38.43 255.87,39.93 253.15,39.93 252.17,40.91 250.85,40.91 248.71,43.05 237.49,43.05 237.08,43.46 232.35,43.46 231.72,44.09 222.64,44.09 221.52,45.21 208.94,45.21 208.04,45.21 198.17,55.08 197.66,55.08 192.19,60.55 191.52,60.55 190.52,61.54 190.52,62.24 185.64,67.13 v2(185.64,67.37)
  BOTTOM w0.076: 145.51,62.25 145.02,62.75 143.09,62.75 141.8,64.04 140.14,64.04 139.12,65.05 139.12,66.37 UC1.BA11
  BOTTOM w0.112: v2(185.64,67.37) 183.51,65.25 v1(182.44,65.25) 181.56,65.25 180.47,64.15 178.15,64.15 177.05,63.05 177.05,62.86 175.27,61.08 166.75,61.08 166.16,60.48 158.5,60.48 157.74,59.72 147.27,59.72 146.08,60.91 146.08,61.69 145.51,62.25
EXPANDER_ALERT#: length 1.5
  TOP w0.102: T267.1 274.83,61.08 UE2.7
EXPANDER_GPU_SMCLK: length 29.6
  TOP w0.102: UE2.19 274.83,55.75 275.38,55.2 276.68,55.2 277.14,54.74 277.14,54.4 RE525.1 276.66,53.92 276.66,53.17 277.02,52.81 277.62,52.21 v3(277.62,52.03) 278.54,51.11 278.54,50.81 278.77,50.58 278.77,49.81 278.93,49.65 278.93,48.89 279.64,48.18 v2(279.64,48.12) ; v2(273.87,38.85) 271.74,38.85 271.4,39.19 UE1.M4
  IN2 w0.102: v2(273.87,38.85) 273.69,38.85 273.22,39.31 273.22,40.03 273.58,40.39 274.79,40.39 275.31,40.91 275.31,42.18 273.9,43.59 273.9,44.3 274.34,44.75 276.4,44.75 277.86,46.21 277.86,46.77 279.21,48.12 v2(279.64,48.12)
EXPANDER_GPU_SMDAT: length 26.2
  TOP w0.102: UE2.20 275.33,55.74 275.63,55.44 276.85,55.44 277.9,54.39 RE524.1 278.65,53.8 278.65,52.99 278.32,52.66 278.32,51.85 278.74,51.43 278.74,50.9 279.02,50.62 279.02,49.96 v1(279.6,49.38) 279.59,49.37 279.59,48.83 v2(279.62,48.8)
  TOP w0.107: v2(271.62,41.28) 271.62,41.28 271.53,41.28 UE1.M7
  IN2 w0.102: v2(274.3,43.78) 274.3,44.24 274.61,44.55 277.7,44.55 280.3,47.15 280.3,48.12 v2(279.62,48.8)
  IN3 w0.102: v2(271.62,41.28) 271.92,40.99 274.1,40.99 274.7,41.6 274.7,43.38 v2(274.3,43.78)
FAN1_PWM: length 114.3
  TOP w0.112: v2(270.9,44.41) 270.84,44.41 UE1.L10
  IN2 w0.124: v2(270.9,44.41) 270.9,44.56 270.44,45.02 270.44,46.26 269.86,46.85 269.86,49.53 268.88,50.5 268.88,52.52 267.14,54.27 265.15,54.27 265.08,54.2 264.35,54.2 264.21,54.34 259.48,54.34 259.15,54.66 256.8,54.66 256.68,54.54 250.83,54.54 244.46,48.17 237.68,48.17 237.22,47.7 233.05,47.7 232.16,48.59 209.62,48.59 191.36,66.86 190.45,66.86 189.56,67.75 189.56,68.7 187.91,70.35 187.91,71.52 187.49,71.94 v2(186.39,71.94)
  BOTTOM w0.112: JFAN1.2 183.64,73.12 183.14,72.61 183.14,71.58 RE48.2 185.12,70.67 v2(186.39,71.94)
FAN1_TACH: length 103.9
  TOP w0.112: v2(265.22,37.98) UE1.E3
  IN2 w0.124: v2(265.22,37.98) 264.81,38.39 260.52,38.39 259.74,39.17 258.25,39.17 257.8,39.62 257.23,39.62 256.18,40.67 254.05,40.67 250.93,43.79 237.79,43.79 237.38,44.2 232.66,44.2 230.91,45.94 208.63,45.94 208.34,45.94 198.47,55.81 197.97,55.81 196.57,57.21 196.57,57.33 186.94,66.96 186.94,67.62 183.98,70.58 182.42,70.58 v2(182.32,70.48)
  BOTTOM w0.112: JFAN1.3 183.62,74.37 182.63,73.37 182.63,71.34 183.1,70.87 RE51.2 182.91,70.48 v2(182.32,70.48)
FB_1.8VALW: length 1.1
  BOTTOM w0.102: PR506.1 171.11,100.39 v3(171.58,99.92)
FB_+1VALWP: length 4.3
  BOTTOM w0.102: PR308.2 187.66,100.17 PR306.2 188.54,101.12 v3(188.6,101.17) ; PR308.2 187.64,101.03 PR311.1 ; PR308.2 187.59,100.13 PU301.4
FB_IA: length 3.8
  TOP w0.203: PR650.1 57.9,71.99 PR645.2 57.88,71.99 PR648.2 56.92,72.08 56.21,72.08 56.13,72.16 PU602.17
FB_VSA: length 4.8
  TOP w0.203: PU602.25 52.79,74.93 53,75.14 53,75.88
  TOP w0.254: 53,75.88 53.29,76.17 PR649.1 53.3,76.68 53.67,76.31 PR646.1 PR652.1
FCCM_GT: length 26.6
  TOP w0.203: v2(56.34,69.01) 56.2,69.14 56.05,69.14 55.44,69.76 PU602.11
  IN2 w0.254: v2(68.3,76.36) 65.3,76.36 65.06,76.12 63.12,76.12 62.09,75.09 61.06,75.09 60.44,74.48 v2(60.44,73.72) 59.22,73.72 56.97,71.47 56.97,69.51 56.47,69.01 v2(56.34,69.01)
  BOTTOM w0.254: v2(68.3,76.36) PR671.2 ; v2(60.44,73.72) 60.35,73.81 59.54,73.81 v1(58.42,72.69) 58.42,70.12 58.8,69.74 59.59,69.74 60.36,68.98 PR664.2
FCCM_IA: length 31.7
  TOP w0.102: v2(78.04,83.11) 78.16,83 v3(78.64,83)
  TOP w0.203: v2(56.26,76.09) 56.24,76.07 56.24,76 55.7,75.47 55.24,75.47 54.39,74.62 PU602.21
  TOP w0.254: PR659.2 v2(78.04,83.11)
  IN2 w0.254: v2(78.04,83.11) 78.04,80.77 77.9,80.63 77.9,79.27 76.65,78.01 64.96,78.01 64.57,78.4 61.65,78.4 60.78,77.54 59.11,77.54 57.66,76.09 v2(56.26,76.09)
FCCM_VSA: length 51.4
  TOP w0.203: v2(50.92,75.52) 50.92,75.37 51.19,75.09 PU602.29
  IN1 w0.254: v2(50.92,75.52) 50.92,77.48 50.6,77.79 50.6,79.77 49.68,80.69 49.68,84.65 49.96,84.93 49.96,87.8 51.31,89.15 51.31,92.24 55.43,96.36 69.68,96.36 72.06,93.97 v2(72.06,92.37)
  BOTTOM w0.254: PR679.2 70.49,87.1 70.49,90.71 v1(71.07,91.29) 72.06,92.28 v2(72.06,92.37)
FIVR_EN: length 1.9
  BOTTOM w0.102: RC218.1 RC219.1 75.81,98.14 RC217.1
FIVR_EN_R: length 3.9
  BOTTOM w0.102: JXDP1.45 75.61,100.63 RC126.2 RC132.1 RC217.2
GPIO126: length 4.9
  TOP w0.102: UE1.E12 265.62,45.62 265.17,46.07 265.17,47.08 263.03,49.22 RE5.1
GPP_B23: length 20.6
  BOTTOM w0.076: UC1.AM7 142.26,72.68 143.02,72.68 143.23,72.46 143.23,71.7 143.4,71.53 143.87,71.53 143.91,71.57 144.3,71.57 144.43,71.62 144.62,71.62 144.65,71.61 144.85,71.56 144.92,71.56 145.06,71.61 145.11,71.65 145.25,71.65 145.34,71.6 145.5,71.56 145.57,71.56 145.71,71.61 145.89,71.8 147.47,71.8 148.31,70.96 149.91,70.96
  BOTTOM w0.102: RC317.1 154.15,73.8 154.55,74.21 154.65,74.21 155.04,74.59 155.41,74.59 155.58,74.42 155.58,72.3 v1(154.82,71.53) 153.8,70.52 152.73,70.52 152.24,71.01 149.96,71.01 149.91,70.96
GPP_C5: length 2.5
  BOTTOM w0.076: UC1.W1 145.53,78.49 147.9,78.49 RC25.1
GPP_C8: length 5.2
  BOTTOM w0.076: 149.91,77.63 149.8,77.63 v3(149.46,77.29) 149.17,77 146.04,77 145.9,77.15 UC1.AB1
  BOTTOM w0.102: RC405.1 149.91,77.63
GPP_E23: length 1.2
  TOP w0.254: v2(138.6,81.24) 138.26,81.58 T120.1
  BOTTOM w0.254: UC1.N12 138.88,81.53 v2(138.6,81.24)
GPU_B+: length 1.9
  BOTTOM w0.102: PC665.1 55.93,61.96 v1(55.09,61.96)
  vias: v2(55.06,65.06) v2(55.95,64.93) v2(55.91,64.29) v2(56.53,65.26) v2(56.53,64.61) v2(63.86,72.41) v2(64.02,71.82) v2(64.37,72.69) v2(64.82,72.35) v2(64.84,71.79)
GT1N: length 16.6
  TOP w0.254: v2(76.08,73.46) 76.72,73.46 PR673.1 77.4,72.79 77.4,72.05 76.86,71.52 76.86,69.28 75.97,68.39 v3(74.88,68.39) 73.84,68.39 PR670.1
  BOTTOM w0.254: PL612.2 76.37,73.75 v2(76.08,73.46)
GT1P: length 5.8
  TOP w0.254: PR674.2 75.94,74.12 v2(76.01,74.2) 76.1,74.29 v3(76.49,74.29) 77.88,74.29 PR675.1
  BOTTOM w0.254: v2(76.01,74.2) 75.57,73.75 PL612.3
GT2N: length 17.5
  TOP w0.102: v3(79.15,70.7) 79,70.85 v2(78.68,70.85)
  TOP w0.254: PR677.2 v2(78.68,70.85) ; v2(68.09,66.54) 68.21,66.67 PR666.1
  IN3 w0.254: v2(68.09,66.54) 69.86,68.32 71.78,68.32 74.31,70.85 v2(78.68,70.85)
  BOTTOM w0.254: PL613.2 68.62,66.01 v2(68.09,66.54)
GT2P: length 6.3
  TOP w0.102: v3(69.36,66.58) 69.24,66.47 PR668.1
  TOP w0.254: PR668.1 68.24,65.47 v2(68.05,65.67) 67.3,65.67 PR667.2
  BOTTOM w0.254: PL613.3 67.71,66.01 v2(68.05,65.67)
GT_SNUB1: length 1.8
  TOP w0.127: PR676.2 v1(72.66,72.21)
GT_SNUB2: length 1.8
  BOTTOM w0.102: v3(63.44,62.62) 64.39,61.66 PC670.1
GT_SW1: length 1.9
  TOP w0.127: v1(72.76,74.81) 72.7,74.87 PR676.1
  vias: v2(70.49,74.01) v2(70.49,73.44)
GT_SW2: length 1.3
  BOTTOM w0.102: PR669.1 v3(69.6,61.18)
H_CATERR#: length 11.8
  BOTTOM w0.076: 108.84,97.5 108.84,97.06 109.52,96.38 109.52,96.24 109.77,95.99 109.77,95.24 109.52,95 109.52,92.35 v3(109.69,92.18) 109.69,91.52 109.84,91.37 109.84,91.11 109.98,90.97 110.08,90.87 110.08,88.96 110.21,88.84 110.21,88.48 110.17,88.38 110.17,88.19 110.21,88.1 110.21,87.85 110.07,87.37 110.07,87.26 109.99,86.98 UC1.D63
  BOTTOM w0.112: 108.84,97.5 RC79.1
H_CPU_SVIDALRT#: length 12.7
  BOTTOM w0.076: UC1.B63 109.45,88.29 109.45,89.88 109.19,90.14 109.19,90.25 109.52,90.57 109.52,90.7 109.43,90.79 109.3,90.79 v3(109.17,90.66) 108.98,90.46 108.87,90.46 108.35,90.98 108.35,91.26 108.6,91.51 108.6,91.62 108.49,91.73 108.38,91.73 108.05,91.39 107.94,91.39 107.83,91.5 107.83,91.61 108.17,91.94 108.17,92.05 108.06,92.16 107.95,92.16 107.62,91.82 107.51,91.82 107.38,91.95 107.38,92.23 107.28,92.33 107,92.33 106.92,92.42 106.92,92.96 106.99,93.04 107.96,93.04 108.07,92.92 108.2,92.92 108.28,93 108.28,93.83 108.18,93.92 107.86,93.92 107.8,93.86 RC153.1
H_CPUPWRGD: length 11.2
  BOTTOM w0.076: 101.1,93.06 101.73,93.06 104.24,90.54 104.24,89.48 104.75,88.97 106.36,88.97 106.65,88.69 UC1.A68
  BOTTOM w0.112: CC300.1 99.03,94.33 RC77.2 99.94,93.46 v3(100.27,93.13) 100.34,93.06 101.1,93.06
H_CPUPWRGD_R: length 1.1
  BOTTOM w0.112: T9.1 100.54,95.84 RC77.1
H_PROCHOT#: length 347.6
  TOP w0.112: PR926.1 58.68,97.14 58.05,97.77 58.05,98.34 56.15,100.23 56.15,101.71 v2(56.23,101.8) ; RE288.2 268.66,53.16 268.22,53.6 v2(268.22,54.65) ; PC605.2 52.54,64.71 v2(52.54,64.55)
  IN2 w0.124: v2(45.84,64.11) 46.58,64.85 46.58,66.16 47.97,67.55 47.97,76.11 46.04,78.05 46.04,85.06 46.37,85.39 46.37,93.86 44.71,95.52 44.71,98.52 46.23,100.04 46.23,101.47 48.61,103.86 51.52,103.86 53.58,101.8 v2(56.23,101.8) 56.49,102.05 58.99,102.05 60.1,103.16 70.89,103.16 71.61,102.44 75.25,102.44 76.78,103.97 96.65,103.97 98.12,102.51 100.85,102.51 101.35,102.01 v2(101.35,101.76) 101.87,101.24 105.41,101.24 107.11,102.94 118.9,102.94 119.93,103.97 121.92,103.97 123.54,105.59 128.68,105.59 130.72,103.55 132.11,103.55 133.36,104.8 133.67,104.8 133.95,105.08 133.95,105.77 135.83,107.64 136.91,107.64 137.67,106.88 149.84,106.88 156.07,100.65 156.07,99.46 159.31,96.22 160.5,96.22 163.8,92.92 164.29,92.42 167.38,92.42 168.04,91.77 168.04,86.42 168.79,85.67 168.79,80.57 172.38,76.99 172.38,74.95 174.04,73.29 174.4,73.29 176.3,71.38 177.17,71.38 180.52,68.04 180.52,67.31 186.27,61.56 186.4,61.56 190.25,57.71 190.77,57.71 196.35,52.14 196.93,52.14 201.19,47.87 201.48,47.87 206.93,42.42 207.69,42.42 207.69,42.42 220.44,42.42 222.22,40.64 227.38,40.64 228.02,40 238.37,40 238.95,39.42 242.46,39.42 242.65,39.24 245.67,39.24 v2(245.67,39.24)
  IN3 w0.135: v2(52.54,64.55) 52.54,63.51 51.45,62.41 48.92,62.41 47.22,64.11 v2(45.84,64.11) ; v2(245.67,39.24) 246.82,39.24 247.22,39.63 247.45,39.63 250.22,42.41 250.22,44 253.77,47.55 254.83,47.55 255.19,47.91 258.7,47.91 259.34,48.55 262.57,48.55 263.44,49.41 263.44,50.17 265.56,52.28 265.56,53.12 267.09,54.65 v2(268.22,54.65)
  BOTTOM w0.112: v2(101.35,101.76) 101.35,101.89 100.93,102.3 100.5,102.3 100.08,101.89 100.08,101.4 v3(102.7,98.77) 102.7,98.31 RC83.1 103.86,96.29 RC84.1 103.46,96.26 103.35,96.38 CC310.1 ; PR678.1 v2(52.54,64.55)
H_PROCHOT#_R: length 11.9
  BOTTOM w0.076: UC1.C65 108.47,87.62 108.38,87.88 108.38,88.05 108.44,88.24 108.44,88.39 108.38,88.51 108.38,88.77 108.58,88.96 108.58,89.77 107.96,90.39 107.4,90.39 106.91,89.9 106.1,89.9 105.77,90.24 105.77,90.43 105.58,90.62 105.58,91.37 v3(104.43,92.52) 103.84,93.1 103.84,94.57
  BOTTOM w0.112: 103.84,94.57 RC84.2
H_PROCHOT#_R1: length 6
  TOP w0.102: RE288.1 269.08,51.02 v3(269.55,51.49)
  TOP w0.112: UE1.H13 268.31,46.68 268.31,50.68 RE288.1
H_THERMTRIP#: length 327
  TOP w0.112: v2(79.73,23.53) 79.73,23.89 80.06,24.22 RD27.2 ; RD27.2 RD14.2 ; RD27.2 82.78,24.47 84.68,26.36 v2(84.68,26.58)
  IN1 w0.076: 119,78.28 119,79.48 119.52,80 119.52,82.76 119.64,82.87 119.64,83.78 119.47,83.94 118.09,83.94 118.08,83.94 115.35,83.94 115.28,84.01
  IN1 w0.119: v2(242.73,23.87) 242.61,23.75 240.32,23.75 240.28,23.71 238.63,23.71 238.27,24.07 237.62,24.07 236.23,25.46 235.38,25.46 233.76,27.08 233.08,27.76 233.08,27.76 231.68,29.15 222.6,29.15 222.25,28.8 214.39,28.8 213.09,27.5 209.96,27.5 209.19,26.73 199.29,26.73 198.41,27.61 196.79,27.61 193.67,24.49 191.03,24.49 189.87,25.65 186.03,25.65 185.86,25.82 177.71,25.82 175.87,27.66 167.24,27.66 166.33,28.56 161.41,28.56 161.07,28.22 155.25,28.22 151.19,24.16 128.74,24.16 127.9,25 121.55,25 118.86,22.31 80.74,22.31 79.73,23.31 v2(79.73,23.53) ; v2(109.19,91.42) 109.19,87.9 110.33,86.76 110.98,86.76 111.73,86.01 111.73,84.76 112.49,84.01 115.28,84.01 ; v2(98.53,76.89) 99.47,75.95 102.4,75.95 105.96,72.4 111.94,72.4 112.59,73.04 121.45,73.04 121.77,73.36 121.77,73.96 121.21,74.52 118.26,74.52 117.96,74.82 117.96,76.97 119,78.01 119,78.28
  IN3 w0.135: v2(98.53,76.89) 98.33,77.1 94.74,77.1 87.77,70.13 87.77,40.39 85.57,38.19 85.57,31.81 85.98,31.4 85.98,27.02 85.54,26.58 v2(84.68,26.58)
  BOTTOM w0.076: CC312.1 107.74,95.42 RC80.1 109.19,96.32 109.6,95.91 109.6,95.31 109.36,95.06 109.36,93.17 108.78,92.59 108.78,91.91 108.98,91.71 108.98,91.7 109.19,91.49 v2(109.19,91.42) 109.48,91.42 109.66,91.23 109.66,91.03 109.92,90.77 109.92,88.89 110.04,88.77 110.04,88.51 109.99,88.39 109.99,88.24 110.04,88.05 110.04,87.88 109.96,87.62 UC1.C63
  BOTTOM w0.112: v2(242.73,23.87) 242.73,23.99 242.55,24.17 242.55,25.87 240.88,27.54 240.88,31.34 238.75,33.47 v1(238.75,33.57) 238.29,34.03 238.29,36.1 237.84,36.55 237.84,38.02 238.46,38.64 QE4.3
H_VCCST_PWRGD_XDP: length 32.6
  IN3 w0.135: v2(103.84,100.12) 103.64,100.32 98.33,100.32 97.75,100.89 97.44,101.2 77.82,101.2 v2(77.42,100.81)
  BOTTOM w0.112: v2(103.84,100.12) 103.84,99.84 105.03,98.65 RC123.2 ; CC307.1 RC124.2 77.83,100.23 77.42,100.64 v2(77.42,100.81) 77.41,100.82 JXDP1.39
HDA_BIT_CLK: length 13.1
  TOP w0.112: v2(135.77,56.85) 136.82,56.85 RC93.2
  BOTTOM w0.076: v2(135.77,56.85) 134.32,58.29 134.32,63.13 134.05,63.4 134.05,63.86 133.42,64.49 133.42,65.29 133.09,65.62 133.09,66.09 133.14,66.21 133.14,66.35 133.08,66.58 133.08,66.7 133.15,66.91 133.25,67.02 133.35,67.13 UC1.AY22
HDA_BIT_CLK_R: length 185.6
  TOP w0.112: UA1.6 295.18,32.62 RA17.1 295.07,32.61 294.58,32.12 291.6,32.12 291.26,32.45 v3(291.26,32.75) 289.67,32.75 v2(289.57,32.65) ; RC93.1 137.07,55.08 CC27.1 137.33,54.66 136.69,54.02 136.69,53.01 137.66,52.04 146.38,52.04 146.84,51.58 v2(146.84,51.16)
  IN1 w0.119: v2(146.84,51.16) 148.1,51.16 155.93,43.32 180.19,43.32 181,44.14 186.77,44.14 187.94,42.97 188.71,42.97 192.65,39.03 192.93,38.75 192.93,37.66 195.65,34.94 196.83,34.94 202.78,28.99 207.02,28.99 207.71,29.69 212.87,29.69 213.82,30.64 219.2,30.64 219.2,30.64 219.61,30.64 220.93,31.96 226.43,31.96 226.83,31.55 228.67,31.55 229.34,30.88 231.41,30.88 231.48,30.96 231.9,30.96 232.25,30.96 234.46,28.75 235.28,28.75 235.57,28.75 236.79,27.53 237.24,27.53 237.37,27.4 240.18,27.4 242.03,25.54 243.37,25.54 243.67,25.25 254.65,25.25 254.71,25.2 259.57,25.2 260.69,24.08 272.96,24.08 273.05,23.99 278.81,23.99 281.45,26.63 283.11,26.63 284.79,28.32 285.67,28.32 287.07,29.72 288.85,29.72 289.92,30.79 289.92,32.31 v2(289.57,32.65)
HDA_RST#: length 14.2
  TOP w0.112: RC95.2 133.61,57.04 133.99,57.42 CC331.1 134.5,56.98 v2(134.5,56.86)
  BOTTOM w0.076: UC1.AW22 133.22,67.8 132.96,66.96 132.96,66.88 132.9,66.72 132.9,66.58 132.97,66.36 132.97,66.24 132.94,66.16 132.92,66.13 132.92,65.54 133.26,65.2 133.26,64.21 v3(133.56,63.91) 133.86,63.61 133.86,57.5 v2(134.5,56.86)
HDA_RST#_R: length 188.4
  TOP w0.112: v2(145.51,51.16) 145.51,50.84 144.79,50.12 142.5,50.12 141.75,49.37 137.12,49.37 133.81,52.68 133.81,54.87 RC95.1 ; v2(292.91,38.98) 292.83,38.91 RA50.1
  IN1 w0.119: v2(292.91,38.98) 292.8,38.88 292.8,37.44 292.41,37.05 290.19,34.83 290.19,33.82 289.18,32.81 289.18,32.03 289.34,31.87 289.34,31.01 288.69,30.36 287,30.36 285.46,28.82 284.58,28.82 282.9,27.13 281.24,27.13 278.6,24.49 273.25,24.49 273.16,24.58 260.89,24.58 259.78,25.7 254.98,25.7 254.57,26.11 242.17,26.11 241.19,27.1 241.19,27.62 239.89,28.92 238.17,28.92 237.85,29.25 234.66,29.25 232.45,31.46 231.69,31.46 231.27,31.46 229.47,31.46 228.88,32.05 227.04,32.05 226.64,32.46 220.73,32.46 219.41,31.14 213.61,31.14 212.66,30.19 212.37,30.19 208.04,30.19 207.51,30.19 206.81,29.49 202.98,29.49 197.03,35.44 195.86,35.44 193.43,37.87 193.43,38.96 192.86,39.53 188.92,43.47 188.15,43.47 186.98,44.64 180.8,44.64 180.45,44.29 176,44.29 176,44.28 175.67,44.28 175.66,44.29 155.67,44.29 148.31,51.66 146.01,51.66 v2(145.51,51.16)
HDA_SDIN0: length 197.1
  TOP w0.112: RA9.1 293.75,30.62 291.13,30.62 v1(290.15,31.6) 289.74,32.01 288.18,32.01 v2(287.69,32.5) ; CC332.1 135.64,61.39 135.64,62.8 v2(135.46,62.99)
  IN1 w0.076: 138.35,62.37 136.08,62.37 v2(135.46,62.99)
  IN1 w0.119: v2(287.69,32.5) 286.97,32.5 284.98,30.51 281.74,30.51 280.5,29.27 279.07,29.27 277.25,27.45 265.35,27.45 264.52,28.28 264.31,28.28 263.74,27.71 263.57,27.71 263.4,27.88 263.4,28.05 263.99,28.64 263.99,28.81 263.84,28.96 263.64,28.96 263.17,28.49 263,28.49 262.84,28.66 262.84,28.83 263.32,29.31 263.32,29.48 263.18,29.62 262.57,29.62 262.42,29.48 262.42,28.86 262.16,28.6 260.36,28.6 259.9,29.05 259.68,29.05 259.56,28.93 259.56,28.65 259.44,28.53 259.2,28.53 259.08,28.65 259.08,28.93 258.97,29.05 258.73,29.05 258.61,28.93 258.61,28.65 258.49,28.53 258.25,28.53 258.13,28.65 258.13,28.93 258.01,29.05 256.82,29.05 256.7,28.93 256.7,28.65 256.58,28.53 256.35,28.53 256.23,28.65 256.23,28.93 256.11,29.05 255.87,29.05 255.75,28.93 255.75,28.65 255.63,28.53 255.39,28.53 255.27,28.65 255.27,28.93 255.15,29.05 249.06,29.05 248.94,28.93 248.94,28.65 248.82,28.53 248.58,28.53 248.46,28.65 248.46,28.93 248.34,29.05 246.3,29.05 245.89,29.47 242.86,29.47 241.03,31.29 239.16,31.29 238.58,31.87 238.58,32.48 238.45,32.61 235.72,32.61 235.33,32.99 233.87,32.99 233.4,33.46 231.68,33.46 230.41,33.46 229.4,34.47 218.89,34.47 217.9,33.48 217.86,33.43 206.06,33.43 205.88,33.25 204.5,33.25 204.14,33.61 203.29,33.61 203.16,33.74 203.16,34.17 203.49,34.5 203.49,35.19 203.13,35.55 202.9,35.55 202.76,35.41 202.76,34.84 202.64,34.71 202.11,34.71 201.01,35.82 199.98,35.82 196.21,39.59 195.6,39.59 189.75,45.45 188.97,45.45 187.8,46.62 156.22,46.62 148.98,53.85 146.87,53.85 145.87,54.85 142.6,54.85 140.57,56.88 140.57,57.74 139.84,58.47 139.84,59.31 139.14,60.01 139.14,61.57 138.35,62.37
  BOTTOM w0.076: v2(135.46,62.99) 135.32,63.12 135.32,63.43 134.72,64.03 134.72,64.46 134.09,65.1 134.09,65.6 133.92,65.77 UC1.BA21
HDA_SDIN0_R: length 2.4
  TOP w0.112: RA9.2 295.52,31.13 v3(296.1,31.72) 296.2,31.82 UA1.8
HDA_SDOUT: length 13.8
  TOP w0.112: RC94.2 RC223.2 135.83,55.92 RC187.1 134.94,56.81 CC333.1 135.59,57.42 v2(135.73,57.56)
  BOTTOM w0.076: UC1.BB22 133.35,65.7 133.71,65.35 133.71,64.59 134.41,63.88 134.41,63.68 134.49,63.6 134.49,61.3 134.61,61.18 134.61,58.68 v2(135.73,57.56)
HDA_SDOUT_R: length 187.2
  TOP w0.112: v2(291.81,33.3) 291.98,33.13 295.9,33.13 296.01,33.02 UA1.5 ; RC94.1 134.94,53.14 v3(136.06,52.02) 137.32,50.76 144.1,50.76 144.49,51.15 v2(144.49,51.16)
  IN1 w0.119: v2(291.81,33.3) 290.44,31.93 290.44,30.61 288.82,28.99 288.82,27.99 288.46,27.62 287.64,27.62 285.9,25.89 281.8,25.89 277.78,21.87 276.14,21.87 274.89,23.11 272.42,23.11 272.13,22.83 261.17,22.83 260.82,23.19 260.37,23.19 259.78,23.77 258.58,23.77 258.27,23.47 254.39,23.47 253.35,24.5 243.36,24.5 243.06,24.8 241.64,24.8 241.44,24.99 240.7,24.99 240.51,25.18 239.29,25.18 239.11,24.99 238.09,24.99 237.94,25.14 236.68,26.4 236.49,26.4 234.89,28 234.35,28 234.15,28 232.01,30.14 229.36,30.14 229.36,30.14 229.03,30.14 228.36,30.81 226.52,30.81 226.12,31.21 221.24,31.21 219.92,29.89 219.3,29.89 218.89,29.89 214.13,29.89 213.17,28.94 208.02,28.94 207.32,28.24 202.38,28.24 199.57,31.05 199.01,31.05 196.57,33.5 196.04,33.5 192.19,37.35 192.19,38.44 188.41,42.22 187.63,42.22 186.52,43.33 181.25,43.33 180.5,42.57 155.62,42.57 148.39,49.81 145.82,49.81 144.94,50.69 144.94,50.7 v2(144.49,51.16)
HDA_SYNC: length 12.2
  TOP w0.112: v2(135.7,58.92) 135.7,58.89 v3(136.9,57.69) 137.49,57.1 137.54,57.1 137.96,56.68 RC92.2
  BOTTOM w0.076: UC1.BA22 133.35,66.47 133.65,66.17 133.65,65.65 133.87,65.42 133.87,65.08 134.56,64.39 134.56,63.96 134.88,63.64 134.88,63.09 135.08,62.88 135.08,62.45 134.78,62.15 134.78,59.84 v2(135.7,58.92)
HDA_SYNC_R: length 188.3
  TOP w0.112: v2(288.31,28.25) 288.87,27.69 290.09,27.69 290.23,27.55 292.26,27.55 293.15,28.44 295.24,28.44 296.55,29.74 296.55,30.7 296.86,31.02 UA1.10 ; RC92.1 138.2,55.45 138.2,54.15 139.81,52.53 146.59,52.53 147.42,51.7 147.42,50.61 147.29,50.48 146.52,50.48 146.4,50.61 146.4,50.86 v2(146.1,51.16)
  IN1 w0.119: v2(288.31,28.25) 287.91,28.25 285.8,26.13 281.7,26.13 277.68,22.12 276.24,22.12 275,23.36 272.31,23.36 272.03,23.08 261.41,23.08 261,23.49 260.42,23.49 259.35,24.55 257.97,24.55 257.14,23.72 254.48,23.72 253.46,24.75 243.46,24.75 243.16,25.04 241.74,25.04 241.54,25.24 241.07,25.24 240.88,25.43 239.2,25.43 239.01,25.24 238.19,25.24 236.78,26.65 236.59,26.65 234.99,28.25 234.25,28.25 232.11,30.38 229.13,30.38 228.46,31.05 226.62,31.05 226.22,31.46 221.14,31.46 219.82,30.14 219.41,30.14 219.41,30.14 218.99,30.14 214.03,30.14 213.07,29.18 207.92,29.18 207.22,28.49 202.57,28.49 196.62,34.44 195.45,34.44 192.43,37.45 192.43,38.54 188.51,42.47 187.73,42.47 186.62,43.58 181.15,43.58 180.39,42.82 155.73,42.82 148.49,50.06 146.12,50.06 145.96,50.22 145.96,51.01 v2(146.1,51.16)
HDD_DET#: length 22.4
  BOTTOM w0.076: 149.08,87.36 147.77,87.36 147.24,86.84 147.24,85.89 146.02,84.67 145.36,84.67 145.25,84.72 145.12,84.72 145.03,84.67 144.77,84.67 UC1.H2
  BOTTOM w0.102: 149.08,87.36 151.09,87.36 153.7,84.75 157.94,84.75 159.87,86.68 v1(161.46,86.68) 161.97,86.68 162.57,87.28 RPC4.3
HDMI_CEC: length 12.4
  TOP w0.102: RV19.1 19.32,71.18 19.03,70.88 17.5,70.88 17.2,71.19 15.98,71.19 15.65,70.86 14.78,70.86 14.07,71.57 14.07,72.59 13.67,72.99 12.83,72.99 12.27,72.43 12.27,70.52 JHDMI1.13
HDMI_CLKN: length 3.9
  TOP w0.112: RV17.1 16.84,68.05 18.08,68.05 v2(18.29,68.26)
  BOTTOM w0.112: CV38.1 18.79,68.05 18.49,68.05 v2(18.29,68.26) 18.13,68.1 17.7,68.1 LV12.1 17.39,68.41 LV38.1
HDMI_CLKP: length 3.9
  TOP w0.112: RV16.1 16.84,67.79 18.18,67.79 v2(18.29,67.68)
  BOTTOM w0.112: LV37.1 17.4,67.54 LV12.2 17.7,67.84 18.13,67.84 v2(18.29,67.68) 18.4,67.79 18.57,67.79 CV37.1
HDMI_CTRL_CLK: length 16.2
  BOTTOM w0.112: JHDMI1.15 12.19,71.44 12.19,72.97 12.7,73.48 13.65,73.48 14.13,73 14.13,71.11 14.33,70.91 16.74,70.91 16.89,71.06 RV22.1 17.34,70.95 v4(19.43,70.95) 21.77,70.95 22.05,71.23 QV3.6
HDMI_CTRL_DATA: length 13.9
  BOTTOM w0.112: JHDMI1.16 12.62,71.3 12.43,71.48 12.43,72.87 12.8,73.24 13.55,73.24 13.89,72.9 13.89,71.01 14.23,70.67 16.73,70.67 16.89,70.5 RV23.1 17.44,70.71 v4(18.04,70.71) 20.63,70.71 20.75,70.58 20.75,70.15 QV3.3
HDMI_HPD: length 5.1
  TOP w0.102: QV5.1 15.27,74.66 RV21.1 13.73,73.82 v1(12.83,73.82) 12.57,73.82 JHDMI1.19
HDMI_L_CLKN: length 4.4
  BOTTOM w0.112: JHDMI1.12 13.1,69.21 13.45,68.86 13.7,68.86 14.64,67.92 15,67.92 RV35.1 15.57,68.09 16.15,68.09 LV12.4 16.46,68.4 LV38.2
HDMI_L_CLKP: length 4.3
  BOTTOM w0.112: JHDMI1.10 13.4,68.6 13.59,68.6 14.53,67.66 15.08,67.66 15.11,67.63 15.12,67.63 RV35.2 15.8,67.82 16.18,67.82 LV12.3 16.46,67.54 LV37.2
HDMI_L_TX_N0: length 9.4
  BOTTOM w0.112: LV36.2 16.42,64.68 LV9.4 16.13,64.4 15.64,64.4 RV32.1 14.96,64.29 14.57,64.29 13.77,63.49 12.65,63.49 12.44,63.71 12.44,67.19 12.19,67.43 11.92,67.43 JHDMI1.9
HDMI_L_TX_N1: length 4
  BOTTOM w0.112: LV34.2 LV6.4 16.1,66.16 15.69,66.16 RV29.1 15.01,66.15 13.96,66.15 13.74,65.93 13.47,65.93 JHDMI1.6
HDMI_L_TX_N2: length 7.1
  IN1 w0.119: v2(14.35,62.57) 14.34,62.57 14.18,62.42 12.96,62.42 12.51,62.87 12.51,64.14 12.24,64.41 11.94,64.41 JHDMI1.3
  BOTTOM w0.112: LV32.2 16.44,62.75 LV3.4 16.14,62.46 15.68,62.46 RV26.1 15.07,62.45 14.48,62.45 v2(14.35,62.57)
HDMI_L_TX_P0: length 9.4
  BOTTOM w0.112: JHDMI1.7 11.92,67.17 12.08,67.17 12.17,67.08 12.17,63.6 12.54,63.23 13.88,63.23 14.67,64.03 15.1,64.03 RV32.2 15.72,64.14 16.11,64.14 LV9.3 16.42,63.84 LV35.2
HDMI_L_TX_P1: length 3.9
  BOTTOM w0.112: LV33.2 16.41,65.6 LV6.3 16.12,65.9 15.68,65.9 RV29.2 15.05,65.88 14.07,65.88 13.85,65.67 13.47,65.67 JHDMI1.4
HDMI_L_TX_P2: length 7.2
  IN1 w0.119: JHDMI1.1 11.9,64.15 12.14,64.15 12.26,64.03 12.26,62.77 12.86,62.16 14.18,62.16 v2(14.34,62.01)
  BOTTOM w0.112: v2(14.34,62.01) 14.51,62.19 15.04,62.19 RV26.2 15.73,62.19 16.13,62.19 LV3.3 16.44,61.88 LV31.2
HDMI_OB: length 11.5
  TOP w0.102: v3(13.76,60.29) 15.23,61.77 15.56,61.77 RV10.2 RV11.2 RV14.2 RV15.2 15.58,64.66 RV12.2 RV13.2 15.62,66.48 RV16.2 RV17.2 15.62,69.55 QV4.1
HDMI_TX_N0: length 3.8
  TOP w0.112: v2(18.11,64.57) 17.89,64.34 16.82,64.34 RV15.1
  BOTTOM w0.112: CV36.2 18.71,64.36 18.32,64.36 v2(18.11,64.57) 17.95,64.4 17.65,64.4 LV9.1 17.37,64.68 LV36.1
HDMI_TX_N1: length 3.8
  TOP w0.112: v2(18.13,66.33) 17.94,66.13 16.81,66.13 RV13.1
  BOTTOM w0.112: LV34.1 17.34,66.47 LV6.1 17.65,66.17 17.97,66.17 v2(18.13,66.33) 18.32,66.15 18.72,66.15 CV34.2
HDMI_TX_N2: length 3.7
  TOP w0.112: RV11.1 16.74,62.45 17.98,62.45 v2(18.13,62.61)
  BOTTOM w0.112: CV32.2 18.76,62.4 18.34,62.4 v2(18.13,62.61) 17.97,62.45 17.67,62.45 LV3.1 17.37,62.75 LV32.1
HDMI_TX_P0: length 3.8
  TOP w0.112: v2(18.11,63.98) 18.01,64.08 16.82,64.08 RV14.1
  BOTTOM w0.112: CV35.2 18.94,63.84 18.68,64.09 18.22,64.09 v2(18.11,63.98) 17.95,64.14 17.67,64.14 LV9.2 17.34,63.81 LV35.1
HDMI_TX_P1: length 3.8
  TOP w0.112: RV12.1 16.81,65.87 18.01,65.87 v2(18.13,65.75)
  BOTTOM w0.112: CV33.2 18.57,65.88 18.27,65.88 v2(18.13,65.75) 17.97,65.91 17.65,65.91 LV6.2 LV33.1
HDMI_TX_P2: length 3.8
  TOP w0.112: v2(18.13,62.02) 17.97,62.19 16.89,62.19 RV10.1
  BOTTOM w0.112: CV31.2 18.54,62.13 18.24,62.13 v2(18.13,62.02) 17.97,62.18 17.67,62.18 LV3.2 17.37,61.88 LV31.1
HOST_DEBUG_TX: length 107
  TOP w0.102: RZ132.1 275.45,63.25 275.23,63.47 274.87,63.47 274.39,62.99 v2(274.37,62.99)
  TOP w0.107: UE1.G11 266.84,45.17 v2(266.84,45.18)
  IN1 w0.102: v2(274.37,62.99) 274.14,63.23 274.14,71.78 276.2,73.84 v2(276.2,74.6)
  IN3 w0.102: v2(276.2,74.6) 276.56,74.6 277.66,73.5 281.76,73.5 283.87,71.39 291.93,71.39 293.51,72.97 293.51,73.85 294.39,74.73 299.1,74.73 v2(299.51,74.31) 299.51,73.46 299.17,73.11 294.87,73.11 292.44,70.69 292.44,67.91 294,66.35 294,63.88 293.57,63.45 293.57,59.93 294,59.5 294,57.35 294.1,57.24 294.1,56.77 293.32,56 292.81,56 292.29,55.48 286.55,55.48 285.05,56.98 280.96,56.98 280.08,56.09 277.58,56.09 276.94,55.46 276.94,54.31 276.47,53.83 273.08,53.83 272.52,53.27 269.58,53.27 268.16,51.85 268.16,48.12 267.99,47.94 267.41,47.94 266.36,46.89 266.36,45.66 v2(266.84,45.18)
  BOTTOM w0.102: RE73.2 299.35,75.65 RE306.2 299.13,75.35 299.13,74.93 299.51,74.55 v2(299.51,74.31) JDEG1.8
HOST_SD_WP#: length 223.6
  TOP w0.102: QR1.2 312.51,48.57 v2(311.79,49.3)
  IN1 w0.076: v2(138.75,77.99) 140.29,77.99 140.74,77.54 144.62,77.54 146.02,78.93 148.8,78.93 149.18,79.31 149.18,79.75 149.91,80.48
  IN1 w0.102: v2(152.37,81.71) 151.95,81.3 151.27,81.3 151,81.03 150.46,81.03 149.91,80.48 ; v2(301.71,47.51) 297.58,47.51 296.53,46.47 296.53,45.74 293.84,43.04 293.84,41.3 291.93,39.39 291.93,37.64 288.05,33.77 v2(288.05,32.93)
  IN2 w0.102: v2(162.42,77.41) 163.59,77.41 164.61,76.39 166.86,76.39 167.26,75.98 167.26,75.66 173.19,69.73 173.19,69.24 176.98,65.45 178.54,65.45 179.7,64.29 179.7,63.35 180.53,62.52 181.8,62.52 189.96,54.35 191.14,54.35 203.33,42.16 203.33,41.42 205.62,39.13 210.98,39.13 212.51,37.61 219.9,37.61 221.39,36.12 242.51,36.12 242.96,35.67 246.09,35.67 248.15,33.61 248.92,33.61 249.67,32.85 251.13,32.85 251.87,32.1 251.87,30.75 252.43,30.2 253.63,30.2 254.23,29.59 257.84,29.59 259.24,28.2 259.62,28.2 261,26.82 266.66,26.82 267.06,27.21 278.21,27.21 280.34,29.34 281.08,29.34 281.96,30.22 284.88,30.22 287.58,32.93 v2(288.05,32.93)
  BOTTOM w0.076: UC1.W10 140.18,78.43 139.74,77.99 v2(138.75,77.99)
  BOTTOM w0.102: v2(162.42,77.41) v1(162.42,76.8) 162.42,76.61 159.43,73.62 158.7,73.62 158.49,73.82 158.49,75.44 157.51,76.42 157.51,78.22 157.16,78.58 155.59,78.58 154.93,77.92 153.93,77.92 153.62,77.6 RC292.1 153.22,79.94 152.82,80.34 152.82,81.36 152.46,81.71 v2(152.37,81.71) ; v2(311.79,49.3) 305.24,49.3 303.45,47.51 v2(301.71,47.51)
HP_OUT_L: length 10.5
  TOP w0.203: UA1.32 v3(304.55,33.02) 305.21,33.02 RA7.1
  TOP w0.381: RA7.1 305.6,33.46 v2(304.92,33.46)
  IN3 w0.381: v2(303.35,26.78) 304.92,28.36 v2(304.92,33.46)
HP_OUT_R: length 12.4
  TOP w0.203: UA1.33 304.09,33.42 304.7,34.02 305.33,34.02 RA8.1
  TOP w0.381: RA8.1 305.38,34.57 v2(304.94,34.57)
  IN3 w0.381: v2(302.13,26.8) 302.13,26.93 303.49,28.28 303.49,32.85 304.94,34.3 v2(304.94,34.57)
HV_GATE1_A: length 3.2
  TOP w0.076: UT5.B9 30.51,60.06 31.85,60.06
  TOP w0.102: RT64.1 32.63,60.06 31.85,60.06
HV_GATE2_A: length 4.6
  TOP w0.076: UT5.A9 31.76,59.81
  TOP w0.102: v1(33.11,56.89) 33.15,56.93 RT65.1
  TOP w0.107: 31.76,59.81 32,59.81
  TOP w0.112: 32,59.81 RT65.1
HW_GPS_DISABLE#: length 93.6
  TOP w0.102: v2(299.87,58.75) 299.87,58.49 299.74,58.36 298.16,58.36 297.63,58.9 295.66,58.9 v1(295.53,59.02) 294.85,59.71 293.67,59.71 290.81,62.57 290.81,63.81 288.49,66.13 288.49,66.13 288.26,66.35 288.26,66.35 282.06,72.55 271.26,72.55 269.04,70.33 DZ6.1 ; v2(268.38,39.58) 268.02,39.94 UE1.H5 ; v2(276.12,33.61) 275.97,33.75 275.97,34.22 RE12.1
  IN1 w0.102: v2(299.87,58.75) 299.85,58.74 299.85,58.11 299.72,57.97 299.72,57.03 298.17,55.49 298.17,53.39 296.35,51.56 296.35,49.96 295.68,49.29 295.68,48.9 293.19,46.41 293.19,44.7 292.53,44.04 292.53,42.89 288.82,39.17 287.95,39.17 286.3,37.52 284.3,37.52 283.1,36.32 283.1,36.06 282.18,35.14 279.77,35.14 279.34,35.57 276.88,35.57 276.12,34.81 v2(276.12,33.61)
  BOTTOM w0.102: v2(268.38,39.58) 268.49,39.58 268.9,39.99 269.29,39.99 269.64,39.64 269.64,39.4 269.77,39.28 272.65,39.28 273.28,38.65 273.28,34.12 273.79,33.61 v2(276.12,33.61)
HW_GPS_DISABLE#_R: length 3.2
  TOP w0.102: v3(268.16,72.36) v2(268.16,71.73) DZ6.2
  BOTTOM w0.102: JNGFF2.18 268.2,71.76 v2(268.16,71.73)
I2C1_SCK_TP: length 29.2
  IN3 w0.076: v2(140.45,80.14) 140.79,79.8 144.35,79.8 145.51,78.64 149.94,78.64
  IN3 w0.102: v2(165.79,77.92) 165.35,77.47 164.72,77.47 163.37,78.82 150.12,78.82 149.94,78.64
  BOTTOM w0.076: v2(140.45,80.14) 140.45,79.95 UC1.U9
  BOTTOM w0.102: v2(165.79,77.92) 166.03,77.68 RZ29.1 166.44,77.31 166.58,77.45 RZ21.2
I2C1_SCK_TP_R: length 116.6
  TOP w0.102: v2(252.31,28.43) 252.31,28.38 252.28,28.34 252.28,28.16 252.5,27.93 RZ347.2 ; RZ117.2 169.19,76.98 169.19,75.75 168.72,75.28 167.48,75.28 167.33,75.43 v1(167.28,75.43) 167.24,75.47 167.24,75.47 v2(166.88,75.82)
  IN2 w0.102: v2(252.31,28.43) 252.31,28.78 249.22,31.87 248.3,31.87 247.11,33.06 245.86,33.06 244.1,34.82 241.83,34.82 241.34,35.31 239.44,35.31 238.11,33.98 235.64,33.98 234.75,34.87 221.78,34.87 219.65,37 212.25,37 210.73,38.52 205.37,38.52 202.72,41.17 202.72,41.76 190.93,53.55 189.72,53.55 183.22,60.05 183.22,60.21 181.53,61.91 180.27,61.91 179.09,63.09 179.09,64.03 178.28,64.84 176.73,64.84 172.56,69.01 171.62,69.01 170.76,69.88 170.76,70.2 166.88,74.07 v2(166.88,75.82)
  BOTTOM w0.102: JKBTP1.2 252.35,28.39 v2(252.31,28.43) ; v2(166.88,75.82) 166.31,76.4 RZ29.2
I2C1_SDA_TP: length 28.6
  IN3 w0.076: 149.94,78.92 149.93,78.92 146.22,78.92 144.4,80.74 141.73,80.74 141.16,80.16 v2(141.02,80.16)
  IN3 w0.102: 149.94,78.92 150.04,79.03 163.45,79.03 164.21,78.26 164.82,78.26 v2(165.15,77.93)
  BOTTOM w0.076: v2(141.02,80.16) 141.49,79.7 UC1.U8
  BOTTOM w0.102: v3(165.43,78.37) 165.15,78.09 v2(165.15,77.93) RZ26.1 165.01,77.45 RZ20.2
I2C1_SDA_TP_R: length 130.2
  TOP w0.102: RZ116.2 168.76,76.64 168.76,75.61 168.63,75.48 167.99,75.48 167.02,76.45 166.27,76.45 166.04,76.21 164.97,76.21 v2(164.65,75.89) ; RZ346.2 250.69,22.27 252.57,22.27 253.08,22.78 v1(253.08,23.21) v2(253.08,23.82)
  IN2 w0.102: v2(253.08,23.82) 250.9,25.99 250.9,29.91 249.14,31.67 248.22,31.67 247.02,32.86 245.77,32.86 244.1,34.53 241.37,34.53 240.79,35.11 239.52,35.11 238.19,33.77 235.56,33.77 234.81,34.52 221.85,34.52 219.57,36.8 212.16,36.8 210.64,38.32 205.28,38.32 202.52,41.08 202.52,41.67 190.84,53.35 189.64,53.35 188.42,54.56 188.04,54.56 183.02,59.58 183.02,60.12 181.44,61.7 180.19,61.7 178.89,63 178.89,63.95 178.21,64.63 176.66,64.63 172.47,68.81 171.54,68.81 170.56,69.79 170.56,70.05 166.4,74.21 166.4,75.14 165.65,75.89 v2(164.65,75.89)
  BOTTOM w0.102: RZ26.2 165.15,76.39 v2(164.65,75.89) ; v2(253.08,23.82) 251.85,25.04 JKBTP1.3
I_ADP: length 271.3
  TOP w0.102: v2(54.99,106.06) 55.2,105.86 55.2,105.35 55.55,105 55.55,103.57 57.22,101.91 57.22,100.32 59.85,97.68 59.85,96.84 PR935.2
  TOP w0.107: v2(262.8,45.21) UE1.B11
  IN2 w0.102: v2(262.8,45.21) 262.8,45.38 262.35,45.83 262.35,46.27 262.77,46.7 262.77,47.78 261.44,49.1 261.44,49.71 259.39,51.77 258.83,51.77 257.8,52.8 256.67,52.8 255.25,51.38 252,51.38 246.84,46.23 244.5,46.23 243.85,45.57 233.05,45.57 231.71,46.91 208.93,46.91 196.82,59.02 196.15,59.02 188.05,67.13 188.05,68.07 181.08,75.04 180.98,75.04 178.05,77.97 177.7,77.97 173.75,81.92 173.75,86.2 173.19,86.77 173.19,93.76 169.64,97.31 167.01,97.31 164.99,99.33 160.6,99.33 159.94,99.98 159.94,101.91 159.19,102.66 159.04,102.66 158.36,103.34 158.36,104.2 150.58,111.98 123.46,111.98 119.13,107.65 106.24,107.65 105.77,108.12 101.81,108.12 101.41,108.52 97.39,108.52 97.03,108.16 93.59,108.16 92.64,109.11 77.95,109.11 77.08,109.98 62.86,109.98 59.15,106.27 59.15,105.7 58.65,105.2 58.3,105.2 57.84,105.66 57.84,106.04 57.1,106.77 55.4,106.77 54.99,106.37 v2(54.99,106.06)
I_BATT: length 288
  TOP w0.102: v2(272.83,33.62) 272.68,33.46 272.68,31.8 272.25,31.37 272.25,30.56 272.86,29.95 v1(272.86,28.47) 273.32,28.01 274.77,28.01 275.11,28.35 275.11,29.34 RE64.2 ; v2(56.31,105.99) 56.56,105.99 56.98,105.56 56.98,104.16 57.46,103.69 57.46,100.36 60.07,97.74 60.07,97.04 PR947.2
  IN2 w0.102: v2(269.58,34.14) 269.6,34.16 269.6,35.52 268.58,36.53 262.58,36.53 261.88,35.84 261.4,35.84 259.85,37.39 257.94,37.39 257.37,37.96 257.21,37.96 256.54,38.63 252.89,38.63 252.19,39.34 251.8,39.34 248.53,42.61 237.3,42.61 236.93,42.98 232.21,42.98 231.54,43.65 222.46,43.65 221.34,44.77 209.12,44.77 207.85,44.77 197.98,54.63 197.38,54.63 191.91,60.1 191.29,60.1 190.08,61.31 190.08,62.05 185.03,67.11 185.03,68.36 183.54,69.85 182.77,69.85 182.59,69.67 182.13,69.67 180.3,71.5 180.3,73.72 178.1,75.91 176.99,75.91 173.47,79.43 173.47,80.88 172.21,82.14 172.21,86.64 171.72,87.14 171.72,90.6 172.21,91.1 172.21,93.59 170.99,94.81 168.07,94.81 166.39,96.49 164.67,96.49 163.13,98.03 161.66,98.03 161.37,98.31 160.17,98.31 158.19,100.29 158.19,101.49 150.71,108.97 143.81,108.97 143.52,109.26 143.52,109.96 142.24,111.23 127.32,111.23 125.38,109.29 121.72,109.29 119.44,107.01 105.61,107.01 105.26,107.36 101.34,107.36 100.82,107.88 97.83,107.88 97.51,107.55 93.33,107.55 92.54,108.35 77.85,108.35 77.6,108.6 62.64,108.6 59.76,105.71 59.76,105.45 58.9,104.59 58.04,104.59 56.65,105.99 v2(56.31,105.99)
  BOTTOM w0.102: v2(272.83,33.62) 272.82,33.62 271.88,34.57 271.54,34.57 271.08,34.11 269.62,34.11 v2(269.58,34.14)
I_BATT_R: length 17.5
  TOP w0.102: v2(272.67,30.88) 272.67,30.62 v3(272.91,30.38) 273.88,30.38 CE3.1 274.88,30.49 RE64.1 ; UE1.J4 269.13,38.88 v2(269.13,38.78)
  BOTTOM w0.102: v2(272.67,30.88) 272.46,31.1 269.42,31.1 268.46,32.05 268.05,32.05 267.63,31.63 267.14,31.63 266.96,31.81 266.96,33.62 268.55,35.21 268.55,37.12 268.84,37.41 268.84,38.4 269.13,38.69 v2(269.13,38.78)
I_SYS: length 349.2
  TOP w0.102: PR620.1 46.83,67.02 46.34,66.54 v2(44.3,66.54) ; v2(274.86,31.31) 274.94,31.39 RE312.2 ; v2(72.68,103.91) 72.58,103.8 70.96,103.8 68.84,101.68 68.84,98.93 69.01,98.76 69.01,97.65 68.51,97.15 64.5,97.15 63.89,96.53 PR936.2
  IN2 w0.102: v2(274.86,31.31) 274.22,30.67 273.82,30.67 273.38,30.23 268.55,30.23 267.6,29.28 266.82,29.28 266.56,29.54 266.56,30.05 266.19,30.43 265.29,30.43 265.16,30.3 263.51,30.3 262.57,31.24 261.53,31.24 260.48,32.29 260.48,33.54 258.48,35.54 256.62,35.54 255.86,36.3 255.4,36.3 254.97,35.86 254.19,35.86 253.9,36.15 249.5,36.15 248.42,37.23 248.42,38.92 247.05,40.29 243.64,40.29 243.18,40.75 242.35,40.75 242.07,40.47 240.12,40.47 239.54,41.05 237.1,41.05 236.44,41.71 222.63,41.71 220.87,43.47 207.37,43.47 197.45,53.39 196.58,53.39 191.11,58.86 190.69,58.86 188.84,60.71 188.84,61.49 188.65,61.68 188.23,61.68 185.35,64.56 185.25,64.56 181.82,68 181.82,68.51 177.88,72.45 177.88,72.66 175.86,74.68 175.7,74.68 175.48,74.68 174.96,75.2 174.96,76.25 170.53,80.68 170.53,87.03 170.68,87.18 170.68,91.04 171.18,91.53 171.18,93.16 170.65,93.68 166.01,93.68 163.44,96.25 162.24,96.25 161.02,97.47 159.83,97.47 157.34,99.96 157.34,101.15 150.36,108.13 141.33,108.13 140.94,108.53 140.94,108.53 140.55,108.92 137.6,108.92 137.44,109.07 129.98,109.07 127.96,107.05 126.82,107.05 126.16,107.72 122.3,107.72 120.01,105.43 119.33,105.43 118.6,104.7 108.9,104.7 105.25,104.7 104.38,105.57 100.71,105.57 100.65,105.63 93.1,105.63 92.33,106.41 77.47,106.41 74.97,103.91 v2(72.68,103.91) 72.68,103.9 71.89,103.9 71.38,104.41 59.59,104.41 59.16,103.98 55.45,103.98 54.21,105.23 45.92,105.23 43.06,102.36 41.73,102.36 40.75,103.35 39.63,103.35 38.22,101.94 38.22,96.69 39.91,95.01 39.91,92.57 40.86,91.61 40.86,88.21 42.7,86.38 42.7,83.76 42.82,83.65 42.82,75.9 43.55,75.17 43.55,70.51 42.79,69.75 42.79,68.04 v2(44.3,66.54)
I_SYS_R: length 11.7
  TOP w0.102: UE1.J5 268.82,39.92 v2(269.18,39.56) ; RE312.1 274.04,32.95 RE313.1 273.17,32.94 CE4.1 273.13,33.22 273.28,33.37 v3(273.28,33.97) 273.07,34.18 v2(272.84,34.18)
  BOTTOM w0.102: v2(272.84,34.18) 272.36,34.66 272.36,37.7 270.99,39.08 269.66,39.08 v2(269.18,39.56)
ILIM_SEL: length 3.1
  TOP w0.102: v3(293.09,66.02) UI3.4 293.09,67.85 RI13.1
ILMT_+1VALWP: length 6.7
  BOTTOM w0.102: PR307.2 PR310.1 189.48,98.14 v3(189.46,98.13) 189.22,97.88 187.28,97.88 186.87,98.29 186.87,99.21 186.4,99.68 PU301.3
ILMT_DDR: length 4.4
  TOP w0.102: PR207.2 32.87,38.09 v3(32.39,38.58)
  TOP w0.254: v2(33.44,36.84) 33.28,36.67 PR205.1 32.86,37.52 PR207.2
  BOTTOM w0.254: PU200.17 33.79,35.67 33.44,36.02 v2(33.44,36.84)
IMON_IA: length 3.4
  TOP w0.203: PU602.14 55.53,70.96 55.63,70.86 56.31,70.86 v2(56.44,70.73)
  BOTTOM w0.254: PR629.2 55.65,69.56 PC625.2 55.79,70.33 56.2,70.73 v2(56.44,70.73)
IMON_VSA: length 4.7
  TOP w0.203: PU602.23 53.59,74.82 54.04,75.27 v2(54.04,75.32)
  BOTTOM w0.102: PR651.1 55.23,74.62 v3(55.6,74.99)
  BOTTOM w0.254: v2(54.04,75.32) 54.15,75.2 PR651.1 PC643.1
IMVP_VR_ON: length 350.7
  TOP w0.102: v2(45.99,67.56) 46.8,67.56 PR616.1 ; v2(248.68,41.48) 248.68,42.23 248.07,42.83 v1(248.07,48.29) 248.07,49.58 258.27,59.79 259.49,59.79 259.85,59.43 UE4.2 259.85,55.7 RE304.1 260.37,55.18 UE3.4 ; PR1325.1 v2(43.87,55.01) ; PR1326.1 v2(43.33,44.58)
  IN2 w0.102: v2(247.75,38.12) 247.75,39.3 246.97,40.08 243.56,40.08 243.1,40.54 242.43,40.54 242.16,40.27 240.04,40.27 239.46,40.85 237.02,40.85 236.38,41.49 222.57,41.49 220.79,43.27 207.28,43.27 197.37,53.19 196.5,53.19 191.03,58.66 190.61,58.66 188.6,60.66 188.51,60.66 188.07,61.1 188.07,61.26 185.25,64.09 185.09,64.09 181.37,67.81 181.37,68.39 176.83,72.92 176.11,72.92 174.86,74.18 174.35,74.18 173.36,75.17 173.36,77.2 169.99,80.57 169.99,87.07 170.18,87.26 170.18,90.82 167.74,93.27 165.84,93.27 163.27,95.84 162.07,95.84 160.85,97.07 159.66,97.07 156.91,99.81 156.91,101 150.19,107.73 141.15,107.73 140.37,108.51 137.43,108.51 137.27,108.66 134.42,108.66 134.13,108.37 134.13,108.18 131.69,105.74 131.69,104.62 131.47,104.4 131.08,104.4 129.03,106.44 126.57,106.44 125.9,107.11 122.57,107.11 120.28,104.82 119.58,104.82 118.86,104.09 108.65,104.09 107.07,104.09 106.65,103.68 97.54,103.68 96.75,104.46 76.68,104.46 75.08,102.86 71.78,102.86 71.07,103.58 59.93,103.58 58.82,102.47 54.16,102.47 52.35,104.28 47.5,104.28 45.32,102.09 45.32,99.76 44.29,98.73 44.29,95.35 45.37,94.27 45.37,93.26 43.57,91.46 43.57,87.84 43.72,87.69 43.72,84.92 44.45,84.18 44.45,78.81 43.63,77.98 43.63,76.24 44.37,75.5 44.37,71.88 45.29,70.97 45.29,68.27 v2(45.99,67.56) 45.99,67.03 45.54,66.58 45.54,65.99 43.88,64.32 43.88,57.1 44.44,56.54 44.44,55.58 v2(43.87,55.01) 43.87,54.98 44.27,54.58 44.27,53.93 43.97,53.62 43.73,53.62 41.76,51.66 41.76,45.4 42.57,44.58 v2(43.33,44.58)
  BOTTOM w0.102: v2(248.68,41.48) 248.68,40.62 247.75,39.69 v2(247.75,38.12)
IMVP_VR_ON_EC: length 35
  TOP w0.102: UE3.1 259.07,52.5 259.83,53.26 259.83,53.71 259.93,53.81 260.53,53.81 260.72,54.01 260.72,55.12 RE304.2 v3(262.38,55.43) 266.36,55.43 v2(266.64,55.15) ; RPE10.2 275.86,49.35 275.62,49.12 275.62,48.74 275.38,48.51 274.86,48.51 v2(274.51,48.16)
  TOP w0.107: v2(273.14,41.44) 273.14,41.44 273.08,41.38 272.23,41.38 UE1.N7
  BOTTOM w0.102: v2(266.64,55.15) 269.12,55.15 270.64,53.63 271.27,53.63 271.72,54.07 272.06,54.07 272.32,53.81 272.32,53.12 273.81,51.62 273.81,50.2 274.73,49.28 274.73,48.38 v2(274.51,48.16) 274.52,48.16 275.02,47.66 275.02,46.45 273.9,45.33 273.9,42.59 273.14,41.83 v2(273.14,41.44)
INT_SPK_L+: length 29.8
  IN1 w1.016: 300.87,12.16 299.87,13.15 299.13,13.15 297.01,15.27 296.99,15.37 296.99,17.6 294.17,20.43 294.17,23.92 294.35,24.1 294.35,24.74 295.52,25.92 295.52,29.38 297.36,31.21 297.36,34.59 297.99,35.22 298.68,35.22 298.69,35.22 299.49,35.22
  BOTTOM w0.102: v2(300.85,37.19) v3(300.36,37.19)
  vias: v2(300.73,11.03) v2(300.73,10.42) v2(300.84,36.58)
INT_SPK_L-: length 31.6
  IN1 w1.016: 298.66,11.47 295.53,14.6 295.53,14.89 295.47,15.22 295.47,16.97 292.64,19.8 292.64,24.55 292.83,24.73 292.83,25.37 294,26.55 294,30.01 295.84,31.84 295.84,35.22 297.36,36.75 299.21,36.75
  vias: v1(299.91,10.7) v2(299.44,11.09) v2(299.38,10.39) v2(300.16,38.44) v2(300.17,37.88)
INT_SPK_R+: length 27
  IN3 w1.016: 297.36,12.74 297.31,12.79 297.31,17.7 294.16,20.85 294.16,24.57 295.37,25.78 295.37,29.65 296.9,31.18 296.9,36.26 297.63,36.99
  vias: v1(298.71,36.92) v2(296.85,11.89) v2(296.85,11.26) v2(298.36,37.59) v2(298.93,37.59)
INT_SPK_R-: length 30.5
  IN3 w1.016: 298.39,38.58 296.72,38.58 295.38,37.23 295.38,31.81 293.84,30.28 293.84,26.41 292.63,25.21 292.63,20.22 295.79,17.07 295.79,14.07 295.4,13.68 295.4,12.9
  vias: v1(295.72,11.72) v2(294.9,11.17) v2(295.49,11.18) v2(299.32,38.66) v2(299.3,38.1)
INT_SPKR_L+:
  vias: v1(301.5,5.49) v2(302.01,8.54) v2(302.01,7.91)
INT_SPKR_L-:
  vias: v1(298.45,7.35) v2(297.25,7.84) v2(297.25,7.21)
