# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_TX1N_C: length 15.8
  TOP w0.175: JUSBC1.A3 8.25,91.6 arc(8.38,91.69) 8.54,91.72 9.21,91.72 arc(9.51,91.78) 9.76,91.95 arc(9.96,92.08) 10.19,92.12 11.15,92.12 arc(11.45,92.06) DT6.1 arc(12.01,92.06) 12.34,92.12 arc(12.95,92.06) 13.53,91.89 13.54,91.89 14.13,91.67 arc(15.31,91.34) 16.52,91.21 17.14,91.19 arc(18.22,90.66) 18.54,89.5 arc(19.17,88.6) 20.08,89.2 arc(20.26,89.48) 20.57,89.59 20.65,89.59 arc(20.85,89.55) CT96.2
TBTA_TX1P: length 2.9
  TOP w0.076: 22.46,89.84 22.48,89.84 22.53,89.8 23.42,89.8 arc(23.49,89.81) 23.55,89.85 23.58,89.89 arc(23.64,89.92) 23.7,89.93 24,89.93 24.06,89.87 24.06,89.75 24.02,89.7 UT1.A19
  TOP w0.175: 22.46,89.84 22.01,89.84 arc(21.79,89.89) CT95.1
TBTA_TX1P_C: length 15.8
  TOP w0.175: CT95.2 20.87,89.86 20.57,89.86 arc(20.09,89.69) 19.82,89.26 arc(19.22,88.86) 18.8,89.45 arc(18.43,90.83) 17.14,91.46 16.53,91.48 arc(15.36,91.6) 14.22,91.92 13.63,92.13 arc(13,92.32) 12.34,92.39 arc(12.01,92.44) DT5.1 arc(11.47,92.44) 11.18,92.39 10.19,92.39 arc(9.86,92.32) 9.57,92.13 arc(9.41,92.02) 9.21,91.98 8.55,91.98 arc(8.39,92.01) 8.26,92.1 JUSBC1.A2
TBTA_TX2N: length 2.7
  TOP w0.076: v2(22.7,89.09) 22.78,89 arc(22.92,88.91) 23.09,88.88 23.5,88.88 arc(23.54,88.88) 23.58,88.9 arc(23.6,88.91) 23.62,88.93 23.63,88.94 arc(23.7,88.99) 23.79,89 24.03,89 arc(24.1,88.99) 24.17,88.94 UT1.B17
  BOTTOM w0.208: v2(22.7,89.09) arc(22.57,89) 22.42,88.97 22.16,88.97 arc(22.02,88.99) CT98.1
TBTA_TX2N_C: length 17.2
  BOTTOM w0.175: JUSBC1.B3 5.95,88.1 arc(6.15,87.96) 6.4,87.92 7.3,87.92 arc(7.87,87.8) 8.35,87.48 9.01,86.82 arc(9.39,86.56) 9.85,86.47 11.18,86.47 arc(11.44,86.53) DT18.1 arc(11.82,86.54) 12.05,86.51 arc(13.22,86.58) 14.38,86.47 arc(15.4,86.46) 16.38,86.74 arc(17.11,87.19) 17.71,87.78 arc(18.07,88.2) 18.44,88.59 18.45,88.59 arc(18.89,88.89) 19.41,88.99 21.13,88.99 arc(21.23,89.01) CT98.2
TBTA_TX2P: length 2.7
  TOP w0.076: v2(22.7,88.5) 22.78,88.58 arc(22.92,88.68) 23.09,88.71 23.45,88.71 arc(23.51,88.7) 23.56,88.66 23.63,88.6 arc(23.68,88.56) 23.75,88.55 23.96,88.55 24.03,88.61 24.03,88.73 23.98,88.78 23.87,88.78 UT1.A17
  BOTTOM w0.208: CT97.1 21.96,88.55 arc(22.09,88.64) 22.24,88.67 22.39,88.67 arc(22.52,88.64) 22.64,88.57 v2(22.7,88.5)
TBTA_TX2P_C: length 17.2
  BOTTOM w0.175: CT97.2 21.24,88.59 arc(21.08,88.69) 20.89,88.73 19.41,88.73 arc(18.99,88.64) 18.63,88.41 18.63,88.4 arc(18.27,88.02) 17.92,87.62 arc(17.27,86.98) 16.49,86.51 arc(15.44,86.19) 14.34,86.21 arc(13.21,86.31) 12.09,86.24 arc(11.84,86.16) DT17.1 arc(11.44,86.15) 11.18,86.21 9.85,86.21 arc(9.29,86.32) 8.82,86.63 8.16,87.29 arc(7.77,87.56) 7.3,87.65 6.29,87.65 arc(6.02,87.6) JUSBC1.B2
TBTA_USB2_RBIAS: length 3
  TOP w0.112: UT1.H19 v2(27.31,90.06)
  BOTTOM w0.102: v3(26.67,91.85) 26.27,91.45 RT41.1
  BOTTOM w0.112: v2(27.31,90.06) 27.22,90.06 26.4,90.88 RT41.1
TBTA_USB20_N: length 45.4
  TOP w0.076: UT5.K5 26.32,61.74 26.32,61.64 26.25,61.56 26.15,61.56 26.06,61.47 25.95,61.47 25.86,61.56 25.66,61.56 25.52,61.42 25.16,61.42 25.05,61.53 25.05,61.64 25.14,61.73 v2(25.16,61.73) ; v2(25.36,90.06) 25.36,90.26 25.24,90.38 UT1.D20
  IN3 w0.135: v2(25.36,90.06) 25.52,90.22 25.58,90.22 25.72,90.36 25.72,90.55 25.6,90.68 25.09,90.68 24.92,90.5 24.92,81.84 25.09,81.66 27.88,81.66 28.49,81.05 30.24,81.05 31.02,80.27 31.54,80.27 32.93,78.88 32.93,73.79 31.85,72.71 30.99,72.71 30.6,72.33 28.32,72.33 27.86,71.87 26.92,71.87 25.44,70.39 25.44,67.77 25.84,67.37 25.84,63.27 24.86,62.29 24.86,62.01 25.14,61.73 v2(25.16,61.73)
TBTA_USB20_P: length 45.4
  TOP w0.076: UT1.E20 v2(26.01,90.06) ; UT5.L5 25.63,61.81 25.34,62.1 24.95,62.1 v2(24.58,61.73)
  IN3 w0.135: v2(26.01,90.06) 26.01,90.67 25.71,90.96 24.97,90.96 24.63,90.62 24.63,81.72 24.98,81.37 27.76,81.37 28.37,80.77 30.12,80.77 30.9,79.98 31.42,79.98 32.64,78.76 32.64,73.9 31.74,73 30.87,73 30.49,72.61 28.2,72.61 27.74,72.15 26.8,72.15 25.16,70.51 25.16,67.65 25.56,67.25 25.56,63.39 24.58,62.41 v2(24.58,61.73)
TBTB_HPD: length 4.8
  TOP w0.076: UT1.G2 26.63,81.87 26.85,81.66 26.85,81.13 26.67,80.95 26.67,79.75
  TOP w0.112: 26.67,79.75 26.67,79.29 27.47,78.48 RT33.1
TBTB_I2C_INT: length 4.7
  TOP w0.076: 25.85,79.91 25.85,80.18 25.61,80.41 25.61,80.71 25.94,81.04 25.94,81.65 UT1.E2
  TOP w0.112: 25.85,79.91 25.61,79.68 25.61,78.45 25.58,78.42 25.58,77.65 RT17.1
TBTB_LSRX: length 4.1
  TOP w0.076: 22.16,84.82 22.33,84.65 22.57,84.65 23.52,83.7 23.52,83.64 23.66,83.5 24.11,83.5 24.33,83.27 UT1.B5
  TOP w0.112: RT32.1 21.75,85.23 22.16,84.82
TBTB_LSTX: length 5.9
  TOP w0.076: 22.98,82.8 23.28,82.8 23.51,82.57 24.1,82.57 UT1.B4
  TOP w0.112: 22.98,82.8 22.39,82.8 22.23,82.96 19.55,82.96 RT31.1
TBTB_USB2_RBIAS: length 2.4
  TOP w0.112: UT1.F19 v2(26.01,89.41)
  BOTTOM w0.102: RT42.1 24.88,89.95 24.88,90.13 v3(24.59,90.42)
  BOTTOM w0.112: v2(26.01,89.41) 25.43,89.41 RT42.1
TDI_XDP: length 15.6
  TOP w0.102: UC8.5 63.12,103.18 63.38,103.43 RC229.1 63.31,103.73 62.91,104.13 62.91,105.14 63.33,105.56 v2(63.56,105.56)
  BOTTOM w0.102: JXDP1.56 72.31,104.38 72.06,104.13 71.22,104.13 70.61,104.74 69.34,104.74 68.1,105.98 67.64,105.98 67.44,105.78 67.44,105.25 66.93,104.74 64.38,104.74 v2(63.56,105.56)
TDO_XDP: length 18.7
  TOP w0.102: UC8.2 64.62,102.56 65.66,103.6 RC230.1 66.12,103.6 66.6,104.08 66.6,105.76 66.83,105.99 67.19,105.99 67.62,105.56 v2(67.9,105.56) 67.9,106.86 67.11,107.64 66.35,107.64 66.14,107.86 65.79,107.86 65.48,107.55 CC306.1
  BOTTOM w0.102: JXDP1.52 73.51,104.56 73.33,104.39 72.6,104.39 72.15,103.93 71.14,103.93 70.53,104.54 68.91,104.54 v2(67.9,105.56)
TDOCK_BATLOW#: length 4.5
  TOP w0.076: 26.27,79.75 26.27,80.03 26.34,80.1 26.34,81.09 26.39,81.14 26.39,81.66 UT1.F2
  TOP w0.112: 26.27,79.75 26.27,78.86 26.52,78.61 RT20.1
TEST_EN: length 4.2
  TOP w0.076: 25.35,79.75 25.35,79.86 25.45,79.96 25.45,80.78 25.71,81.04 UT1.E1
  TOP w0.112: RT36.1 25.25,78.11 25.25,79.05 25.35,79.15 25.35,79.75
TEST_PWRGD: length 3.1
  TOP w0.076: UT1.AB5 33.76,83.03 34.54,83.03 34.92,82.65
  TOP w0.112: RT37.1 35.23,82.61 34.96,82.61 34.92,82.65
THERMATRIP1#: length 6.1
  TOP w0.112: v2(262.22,49.16) 262.22,49.47 RE301.1 261.69,49.74 v3(261.01,49.06) ; v2(262.83,46.01) 263.22,45.61 UE1.B12
  BOTTOM w0.112: v2(262.83,46.01) 263.07,46.25 263.07,48.3 v2(262.22,49.16)
THERMATRIP2#: length 33.5
  TOP w0.112: v2(268.42,37.96) 268.42,37.99 UE1.H3
  IN3 w0.135: v2(248.51,35.8) 253.6,35.8 254.49,36.69 256.07,36.69 256.68,36.08 257.25,36.08 257.86,36.69 267.26,36.69 268.42,37.85 v2(268.42,37.96)
  BOTTOM w0.112: QE4.1 241.25,38.65 RE69.2 242.35,39.03 CE36.1 243,38.38 243,35.5 243.25,35.26 244.75,35.26 244.89,35.4 v1(246,35.4) 248.11,35.4 v2(248.51,35.8)
THERMDA: length 0.5
  TOP w0.127: UT1.AC23 UT1.AB23
TOUCH_SCREEN_DET#: length 182.3
  TOP w0.102: RV8.1 92.89,116.48 v1(91.88,116.48) 91.64,116.24 v2(91.64,116)
  IN2 w0.102: v2(91.64,116) 92.02,116.38 95.4,116.38 96.08,115.69 98.56,115.69 99.24,116.38 150.99,116.38 158.56,108.81 158.75,108.81 158.92,108.64 159.3,108.64 159.37,108.57 163.42,108.57 168.52,103.47 168.72,103.47 172.47,99.72 172.47,98.79 175.94,95.33 175.94,95.07 176.47,94.54 176.47,92.55 178.44,90.58 178.44,88.13 177.04,86.73 177.04,84.32 186.34,75.01 186.53,75.01 v2(187.68,73.86)
  BOTTOM w0.076: UC1.AY5 142.86,67.33 143.3,66.9 143.3,66.46 143.46,66.3 143.86,66.3 144.1,66.06 144.1,65.66 144.71,65.04 147.15,65.04 148.6,63.58 148.6,62.25
  BOTTOM w0.102: JTS1.5 v2(91.64,116) ; 148.6,62.25 148.6,62.11 148.71,62.01 152.62,62.01 153.3,61.32 157.73,61.32 158.13,61.72 161.37,61.72 161.77,62.12 167.66,62.12 168.45,62.91 168.59,62.91 168.98,63.29 170.43,63.29 171.2,64.06 173.89,64.06 174.49,63.47 174.9,63.47 175.36,63.01 175.67,63.01 177.54,64.88 180.52,64.88 181.32,65.68 183.59,65.68 185.18,67.26 185.18,69.71 187.25,71.79 187.25,73.42 v2(187.68,73.86)
TOUCH_SCREEN_PD#: length 130.3
  TOP w0.102: v2(90.93,116) v1(90.43,115.49)
  IN2 w0.102: v2(172.93,99.05) 172.93,99.71 168.9,103.74 168.54,103.74 163.51,108.77 159.46,108.77 159.1,109.12 158.53,109.12 151.08,116.58 99.15,116.58 98.47,115.9 96.16,115.9 95.48,116.58 91.52,116.58 v2(90.93,116)
  BOTTOM w0.076: UC1.A7 141.89,88.72 141.89,89.75 143.28,91.15 143.28,91.61 144.06,92.38
  BOTTOM w0.102: 150.19,96.37 150.19,96.2 150.55,95.83 151.77,95.83 152.24,96.3 166.82,96.3 166.98,96.14 168.01,96.14 169.86,97.99 171.86,97.99 v2(172.93,99.05) ; 150.19,96.37 149.8,95.98 149.05,95.98 148.57,95.5 148.57,94.28 147.93,93.65 145.35,93.65 144.23,92.52 144.2,92.52 144.06,92.38 ; 150.19,96.37 RC272.1 ; v2(90.93,116) 90.84,116.09 JTS1.6
TOUCHPAD_INTR#: length 164.5
  TOP w0.102: RE318.2 267.79,25.78 267.89,25.68 v2(267.89,23.56) ; RC414.1 176.66,63.64 v1(176.88,63.86) 176.99,63.97 v2(177.4,63.97)
  IN2 w0.102: v2(267.89,23.56) 267.89,23.08 267.76,22.95 263.3,22.95 261.97,24.28 261.08,24.28 260.38,24.98 258.04,24.98 256.48,23.42 252.32,23.42 250.06,25.68 250.06,30.19 v2(249.32,30.93) 248.78,31.47 248.13,31.47 247.15,32.45 244.18,32.45 243.56,31.83 243.56,31.56 243.13,31.13 242.75,31.13 242.56,31.32 241.3,31.32 239.57,33.05 233.29,33.05 232.5,33.83 221.95,33.83 219.4,36.39 212,36.39 210.48,37.91 205.11,37.91 202.11,40.92 202.11,41.39 195.4,48.1 195.26,48.1 190.43,52.94 188.39,52.94 186.96,54.37 186.96,54.95 185.42,56.48 184.76,56.48 179.92,61.32 179.92,61.39 178.48,62.83 178.48,63.6 178.11,63.97 v2(177.4,63.97)
  BOTTOM w0.076: 148.24,62.25 148.24,63.65 147.01,64.88 144.64,64.88 143.84,65.68 143.65,65.68 143.39,65.94 143.39,66.13 143.13,66.39 143.13,66.46 UC1.BA5
  BOTTOM w0.102: JKBTP1.5 250.85,28.02 250.97,28.14 250.97,29.03 249.7,30.3 249.7,30.54 v2(249.32,30.93) ; 148.24,62.25 148.24,61.79 148.34,61.69 152.65,61.69 153.22,61.12 157.81,61.12 158.16,61.47 161.41,61.47 161.85,61.92 167.75,61.92 168.53,62.71 168.68,62.71 169.06,63.09 170.51,63.09 171.29,63.86 173.81,63.86 174.41,63.26 174.81,63.26 175.27,62.8 175.76,62.8 176.93,63.97 v2(177.4,63.97)
TP_LAN_JTAG_TCK: length 4.8
  TOP w0.102: v1(270.45,99.54) 271.91,99.54 RL2.1 272.06,98.55 272.52,98.09 273.37,98.09 273.5,97.96 UL1.35
TP_LAN_JTAG_TDI: length 1.3
  TOP w0.102: UL1.32 274.7,98.29 T88.1
TP_LAN_JTAG_TDO: length 2
  TOP w0.102: T89.1 273.47,98.49 273.9,98.07 UL1.34
TP_LAN_JTAG_TMS: length 2.2
  TOP w0.102: UL1.33 274.3,98.1 273.59,98.81 RL1.1
TPM_GPIO4: length 3.6
  BOTTOM w0.102: T283.1 169.29,87.92 169.86,87.35 UZ12.13
TPM_LPM#: length 9.1
  BOTTOM w0.102: RZ363.2 159.73,81.49 v3(160.66,80.56) RZ111.1 162.46,81.35 QZ9.1 164.25,81.35 164.49,81.59 164.49,81.77 166.27,83.55 UZ12.3
TPM_PIRQ#: length 62.8
  TOP w0.102: v2(173.13,85.61) 172.6,85.07 172.6,82.91 172.43,82.74 172.43,71.62 171.29,70.48 171.29,67 v2(170.25,65.96)
  IN1 w0.076: v2(140.59,70.68) 140.93,71.02 140.93,72.08 141.23,72.37 142.59,72.37 143.54,71.42 143.54,71.07 145.28,69.34 145.45,69.34
  IN1 w0.102: 145.45,69.34 148.85,69.34 149.33,68.87 151.6,68.87 152.52,69.79 156.94,69.79 157.6,69.13 160.48,69.13 161.46,70.11 162.67,70.11 162.94,69.85 164.21,69.85 168.49,65.58 168.91,65.58 169.29,65.96 v2(170.25,65.96)
  BOTTOM w0.076: UC1.AP8 140.96,71.05 v2(140.59,70.68)
  BOTTOM w0.102: UZ12.18 173.07,85.55 v2(173.13,85.61) 173.36,85.83 173.36,87.01 RZ69.2 173.93,87.74 174.44,88.24 174.44,89.24 v3(174.74,89.54)
TPM_TYPE: length 14.4
  IN3 w0.076: v2(141.88,68.61) 141.96,68.61 142.19,68.84 142.83,68.84 143.15,69.16 144.13,69.16 144.22,69.25 144.25,69.25
  IN3 w0.102: v2(151.43,67.6) 150.95,68.08 149.56,68.08 148.39,69.25 144.25,69.25
  BOTTOM w0.076: v2(141.88,68.61) 141.48,68.21 141.48,68.14 141.42,68.08 141.42,67.79 141.75,67.46 UC1.AY7
  BOTTOM w0.102: v2(151.43,67.6) 151.61,67.78 151.61,68.12 151.82,68.32 151.82,69.03 RC349.1
TRST#_XDP: length 17.8
  TOP w0.102: v2(73.2,105.86) 72.09,104.74 71.61,104.74 68.63,101.76 68.63,98.85 68.81,98.67 68.81,97.73 68.46,97.38 65.32,97.38 64.12,98.58 UC8.12
  BOTTOM w0.102: v2(73.2,105.86) 72.91,105.56 JXDP1.54
TYPEC_ID: length 8.5
  TOP w0.102: UE1.F2 266.1,37.26 266.1,35.51 265.24,34.65 265.24,33.19 v3(264.74,32.69) 264.14,32.09 264.14,31.68 CE62.1 263.6,30.27 RE343.1
UART_MISO: length 4.9
  TOP w0.076: 28.23,64.84 28.23,64.45 28.01,64.22 28.01,63.56 UT5.F2
  TOP w0.112: 28.23,64.84 28.23,65.51 v2(28.16,65.59)
  BOTTOM w0.102: v2(28.16,65.59) 28.44,65.31 v3(28.7,65.31)
  BOTTOM w0.112: v2(28.16,65.59) 27.8,65.94 RT83.1 27.82,66.34 RT82.1
UART_MOSI: length 5.8
  TOP w0.076: 29.27,64.84 29.27,64.59 29.01,64.33 29.01,63.56 UT5.E2
  TOP w0.102: 29.27,64.84 29.27,65.38 v2(29.38,65.49)
  BOTTOM w0.102: v2(29.38,65.49) 29.57,65.3 v3(29.57,64.18)
  BOTTOM w0.112: RT81.1 28.72,67.19 RT83.2 28.72,66.15 v2(29.38,65.49)
UG1_ISL88738: length 9
  IN2 w0.762: 61.72,88.49 59.88,88.49 59.44,88.04 53.33,88.04 53.04,87.75
  vias: v2(52.54,86.84) v2(53.17,86.84) v2(62.42,88.87) v2(62.42,88.3)
UG2_ISL88738: length 8.5
  TOP w0.127: PQ904.1 v1(67.71,84.02)
  IN2 w0.762: 65.48,91.04 65.48,87.24 66.04,86.67 66.04,84.11 66.04,84.1
  vias: v2(64.46,91.63) v2(64.85,91.23) v2(66.23,83.34) v2(66.23,82.76)
UIM_CLK: length 75.5
  BOTTOM w0.112: JSIM1.C3 310.3,39.58 308.38,39.58 307.87,40.08 307.87,41.38 306.81,42.44 305.63,42.44 305.35,42.17 304.61,42.17 CZ38.1 303.57,42.13 302.14,42.13 v4(300.29,43.97) 300.12,44.15 298.06,44.15 297.7,44.51 297.7,46.47 298.11,46.88 299.21,46.88 299.96,47.63 299.96,49.88 299.63,50.21 299.63,51.49 297.92,53.21 297.92,55.69 297.15,56.46 297.15,57.32 293.25,61.23 293.25,61.96 292.28,62.92 292.28,65.48 291.94,65.82 291.94,69.68 287.03,74.6 282.43,74.6 280.09,76.93 274.75,76.93 274.55,77.13 270.75,77.13 269.83,76.21 269.83,74.4 269.7,74.27 JNGFF2.24
UIM_DATA: length 90.2
  IN3 w0.135: v2(310.09,38.8) 323,38.8 v2(323.95,39.75)
  BOTTOM w0.112: RZ335.2 304.58,41.93 305.45,41.93 305.73,42.21 306.71,42.21 307.63,41.28 307.63,39.99 308.28,39.34 309.55,39.34 v2(310.09,38.8) ; RZ335.2 CZ39.1 ; RZ335.2 303.73,41.89 302.04,41.89 v4(301.65,42.27) 300.02,43.91 297.96,43.91 297.46,44.41 297.46,46.57 298.01,47.12 299.11,47.12 299.72,47.73 299.72,49.78 299.39,50.11 299.39,51.39 297.68,53.11 297.68,55.59 296.91,56.36 296.91,57.22 293.01,61.13 293.01,61.86 292.04,62.82 292.04,65.38 291.7,65.72 291.7,69.58 286.93,74.36 282.33,74.36 279.99,76.69 274.65,76.69 274.46,76.89 270.85,76.89 270.07,76.11 270.07,74.4 270.2,74.27 JNGFF2.26 ; JSIM1.C7 324.08,39.62 v2(323.95,39.75)
UIM_RESET: length 70.9
  BOTTOM w0.112: JNGFF2.22 269.2,76.29 v2(270.86,77.95) 275.73,77.95 276.35,78.58 280.42,78.58 283.91,75.09 287.47,75.09 292.78,69.78 292.78,63.12 293.5,62.4 295.28,62.4 295.92,61.75 295.92,59.24 297.64,57.53 297.64,56.66 298.41,55.9 298.41,54.32 300.18,52.55 300.18,50.7 301.31,49.57 301.31,46.77 CZ40.1 301.5,46.32 302.9,44.93 302.9,44.54 303.36,44.08 305.65,44.08 306.71,43.02 307.09,43.02 308.63,41.48 JSIM1.C2
UPD1_ALERT#: length 366.1
  TOP w0.102: RT60.1 34.41,60.98 35.13,60.98 v2(35.16,60.95) ; v2(267.85,21.93) v1(269.17,23.26) 269.17,25.65 268.78,26.04 RE91.1
  TOP w0.107: v2(265.96,44.41) 265.99,44.41 UE1.F10
  IN1 w0.102: v2(35.16,60.95) 33.85,60.95 31.42,58.52 31.42,57.48 30.6,56.66 30.6,54.45 25.41,49.26 24.41,49.26 23.9,48.74 23.9,47.74 23.5,47.35 23.5,45.94 19.92,42.36 19.92,30.59 22.07,28.43 22.07,20.67 21.39,19.99 21.39,18.47 22.05,17.8 22.05,17.26 22.68,16.63 36.98,16.63 39.44,19.09 43.33,19.09 46.45,22.22 59.11,22.22 61.35,24.46 65.55,24.46 68.56,21.44 119.45,21.44 122.18,24.18 127.56,24.18 129.85,21.88 151.83,21.88 154.34,24.4 159.2,24.4 160.49,25.69 165.6,25.69 166.29,25 185.47,25 185.67,24.8 189.52,24.8 190.68,23.64 194.91,23.64 197.05,25.78 208.5,25.78 209.53,24.75 v2(212.26,24.75)
  IN2 w0.102: v2(267.85,21.93) 267.19,21.27 243.53,21.27 v2(242.97,21.84) 242.4,21.27 236.18,21.27 235.3,22.15 234.6,22.15 233.72,21.27 223.09,21.27 219.61,24.75 v2(212.26,24.75)
  IN3 w0.102: v2(239.97,34.72) 240.36,35.11 244.31,35.11 244.93,35.74 246.31,35.74 248.67,38.09 248.67,38.7 249.51,39.54 250.67,39.54 251.85,40.72 252.05,40.72 252.11,40.78 252.94,40.78 253,40.72 253.01,40.72 253.19,40.55 256.91,40.55 259.23,42.86 259.81,42.86 259.94,42.72 260.63,42.72 260.63,42.72 261.73,42.72 263,43.99 264.75,43.99 264.88,44.12 264.88,44.56 265.13,44.81 265.44,44.81 265.83,44.41 v2(265.96,44.41)
  BOTTOM w0.102: v2(239.97,34.72) 239.42,34.17 239.42,33.38 241.35,31.45 241.35,27.66 243.22,25.79 243.22,22.09 v2(242.97,21.84)
UPD1_SMBCLK: length 351.5
  TOP w0.102: RE303.1 253.19,34.86 253.19,35.85 252.51,36.52 252.51,37.3 v2(252.63,37.42) ; v2(263.6,37.97) 264.02,38.39 UE1.C3
  IN1 w0.102: v2(35.94,62.45) 36.13,62.26 36.13,59.49 35.06,58.42 32.73,58.42 32.18,57.87 32.18,57.17 31.36,56.34 31.36,49.73 30.89,49.27 27.23,49.27 27.02,49.48 26.01,49.48 23.7,47.17 23.7,45.86 20.15,42.3 20.15,30.64 22.28,28.52 22.28,20.59 21.59,19.9 21.59,18.55 22.25,17.89 22.25,17.35 22.76,16.84 36.86,16.84 39.32,19.3 43.21,19.3 46.36,22.45 59.02,22.45 61.23,24.66 65.63,24.66 68.61,21.69 119.36,21.69 122.05,24.38 127.64,24.38 129.94,22.08 151.75,22.08 154.26,24.6 159.11,24.6 160.4,25.89 165.68,25.89 166.37,25.2 185.56,25.2 185.73,25.03 189.62,25.03 190.78,23.87 194.81,23.87 196.95,26.01 205.68,26.01 205.71,25.99 208.59,25.99 209.28,25.29 217.67,25.29 221.89,21.07 233.13,21.07 233.81,21.76 235.24,21.76 235.97,21.02 241.12,21.02 241.17,21.07 258.38,21.07 258.94,21.63 v2(258.94,22.07)
  IN3 w0.102: v2(252.63,37.42) 253.63,38.41 259.79,38.41 259.85,38.35 263.21,38.35 v2(263.6,37.97)
  BOTTOM w0.102: v2(252.63,37.42) 253.07,36.98 253.07,33.19 252.28,32.4 252.28,31.83 253.31,30.8 253.31,30.61 253.61,30.31 254.01,30.31 255.84,28.48 255.84,26.84 257.46,25.21 257.46,22.94 257.94,22.45 258.56,22.45 v2(258.94,22.07) ; v2(35.94,62.45) 35.94,64.86 36.67,65.59 v1(36.67,66.51) 36.67,66.64 36.82,66.8 38.97,66.8 39.21,66.55 RT58.1
  BOTTOM w0.112: RT58.1 39.21,65.79 39.76,65.24 QT1.1
UPD1_SMBCLK_Q: length 46.9
  TOP w0.076: 31.85,62.06 30.51,62.06 UT5.B5
  TOP w0.102: RT67.1 37.16,64.41 36.53,64.41 v2(36.37,64.26) ; RT92.1 22.21,65.43 21.68,65.96 21.68,67.59 23.84,69.75 v2(24.37,69.75)
  TOP w0.112: RT67.1 37.34,63.21 36.53,63.21 36.52,63.2 35.5,63.2 34.36,62.06 31.85,62.06
  IN1 w0.102: v2(24.37,69.75) 26.69,69.75 29.26,72.32 29.26,74.97 30.72,76.42 32.54,76.42 32.84,76.12 32.84,67.54 33.81,66.58 34.21,66.58 36.37,64.41 v2(36.37,64.26)
  BOTTOM w0.102: v2(36.37,64.26) 36.37,64.65 v3(36.53,64.8) 37.95,66.22 RT58.2 38.29,65.59 QT1.6
UPD1_SMBDAT: length 344
  TOP w0.102: v2(252.05,37.41) 252.05,36.32 252.78,35.59 RE302.1
  TOP w0.107: v2(262.82,38.79) UE1.B4
  IN1 w0.102: v2(258.38,22.07) 258.38,21.9 257.77,21.28 241.09,21.28 241.04,21.22 236.06,21.22 235.31,21.97 233.64,21.97 232.94,21.28 222.13,21.28 217.92,25.49 209.37,25.49 208.67,26.19 205.79,26.19 205.77,26.22 205.6,26.22 196.87,26.22 194.73,24.08 190.86,24.08 189.7,25.23 185.81,25.23 185.64,25.4 166.45,25.4 165.76,26.09 160.32,26.09 159.03,24.8 154.18,24.8 151.66,22.29 130.02,22.29 127.72,24.58 121.97,24.58 119.28,21.89 68.69,21.89 65.71,24.87 61.15,24.87 58.93,22.65 46.27,22.65 43.12,19.5 39.24,19.5 36.78,17.04 22.85,17.04 22.46,17.43 22.46,17.97 21.8,18.63 21.8,19.82 22.48,20.5 22.48,28.6 20.35,30.73 20.35,42.22 23.91,45.78 23.91,47.09 26.09,49.28 26.93,49.28 27.15,49.06 30.98,49.06 31.56,49.65 31.56,56.26 32.39,57.08 32.39,57.78 32.82,58.21 35.29,58.21 36.45,59.38 36.45,62.26 v2(36.58,62.39)
  IN3 w0.102: v2(252.05,37.41) 253.26,38.62 259.46,38.62 260.18,39.33 262.28,39.33 v2(262.82,38.79)
  BOTTOM w0.102: v2(258.38,22.07) 258.04,22.07 257.26,22.85 257.26,25.13 255.63,26.75 255.63,28.4 254.02,30.01 v3(253.18,30.01) 252.82,30.01 251.98,30.86 251.98,32.77 252.7,33.49 252.7,36.75 v2(252.05,37.41) ; QT1.4 38.29,63.43 RT59.1 37.64,62.86 37.17,62.39 v2(36.58,62.39)
UPD1_SMBDAT_Q: length 47.1
  TOP w0.076: UT5.A5 31.85,61.81
  TOP w0.102: v2(24.4,69.17) 23.78,69.17 22.21,67.6 RT93.1 ; v2(39.81,63.17) 39.26,63.72 RT66.1
  TOP w0.112: 31.85,61.81 34.41,61.81 35.59,62.99 38.13,62.99 RT66.1
  IN1 w0.102: v2(39.81,63.17) 38.73,63.17 38.33,63.57 36.36,63.57 35.33,64.59 35.33,65.17 34.13,66.37 33.72,66.37 32.64,67.46 32.64,76.03 32.45,76.22 30.8,76.22 29.47,74.89 29.47,72.24 26.39,69.17 v2(24.4,69.17)
  BOTTOM w0.102: v3(40.53,62.86) 40.22,63.17 v2(39.81,63.17)
  BOTTOM w0.112: QT1.3 39.81,63.81 39.81,63.17 v2(39.81,63.17) 39.5,62.86 RT59.2
UPD1_SMBUS_ALERT#: length 4
  TOP w0.076: 31.85,61.06 30.51,61.06 UT5.B6
  TOP w0.102: 31.85,61.06 32.89,61.06 RT60.2 RT68.1
UPD2_ALERT#: length 19.8
  TOP w0.102: v3(260.54,29.13) 260.91,29.5 261.39,29.5 261.89,28.99 v2(261.89,28.99) 262.48,28.4 RE92.1
  TOP w0.107: v2(266.02,39.59) UE1.F5
  BOTTOM w0.102: v2(261.89,28.99) 261.99,28.89 264.75,28.89 264.91,28.72 266.27,28.72 266.56,29.02 266.56,30.85 266.07,31.34 266.07,33.99 266.37,34.28 266.37,38.2 266.21,38.35 265.88,38.35 265.65,38.59 265.65,39.18 266.02,39.56 v2(266.02,39.59)
UPD2_SMBCLK: length 10.6
  TOP w0.102: RPE12.3 274.06,42.69 v3(273.46,42.1) 273.37,42 265.24,42 UE1.D7
UPD2_SMBDAT: length 10.6
  TOP w0.102: v2(274.31,42.05) 274.45,42.19 RPE12.4
  TOP w0.107: v2(265.24,41.24) 265.27,41.24 UE1.E7
  IN3 w0.102: v2(274.31,42.05) 271.98,42.05 271.73,41.8 266.52,41.8 266.29,41.56 265.57,41.56 v2(265.24,41.24)
USB2_ID: length 2.7
  TOP w0.102: v2(143.99,74.92) v3(144.34,74.57) 145.42,73.49 RC337.1
  BOTTOM w0.076: UC1.AG3 144.21,74.69 v2(143.99,74.92)
USB2_VBUSSENSE: length 4.3
  TOP w0.102: RC338.1 144.43,72 144.53,72.11 144.53,72.84 v1(144.36,73.01) 143.17,74.2 v2(143.17,74.85)
  BOTTOM w0.076: v2(143.17,74.85) 143.52,74.5 UC1.AG4
USB3_PRX_DTX_N1: length 241.6
  IN3 w0.076: v2(140.54,84.25) 140.54,84.32 140.7,84.47 141,84.47 141.13,84.34 141.13,84.16 140.96,83.99 140.96,83.14
  IN3 w0.135: v2(301.63,66.79) 301.5,66.67 301.5,66.31 301.26,66.08 301.18,66.08 301.15,66.05 297.36,66.05 296.12,64.8 296.12,63.32 296.52,62.91 296.52,60.07 296.19,59.74 296.19,56.13 294.12,54.06 293.62,54.06 292.67,53.11 292.67,52.13 284.7,44.16 284.7,33.32 283.85,32.47 283.85,31.56 282.39,30.1 281.4,30.1 280.26,28.96 280.1,28.96 277.28,26.13 273.8,26.13 273.21,26.72 261.81,26.72 261.38,27.15 259.22,27.15 258.7,26.63 254.65,26.63 254.28,26.26 248.13,26.26 247.61,26.78 242.13,26.78 239.09,29.82 237.67,29.82 235.2,32.29 233.91,32.29 233.05,33.15 205.07,33.15 202.82,35.4 202.82,36.34 201.08,38.08 200.87,38.08 192.35,46.6 192.35,46.62 185.7,53.27 185.7,54.74 178.73,61.7 178.73,64.18 176.01,66.91 176.01,68.93 173.75,71.19 173.07,71.19 170.13,74.12 170.13,77.95 170.55,78.37 170.55,79.68 166.8,83.42 163.73,83.42 163.25,83.91 162.58,83.91 162.36,83.69 152.88,83.69 151.39,85.18 150.47,85.18 149.55,84.27 144.81,84.27 143.02,82.48 142.15,82.48 141.98,82.64 141.45,82.64 140.96,83.14
  BOTTOM w0.076: UC1.H8 140.71,83.94 140.54,84.11 v2(140.54,84.25)
  BOTTOM w0.104: v2(301.63,66.79) 301.52,66.79 301.21,66.48 301.21,66.21 301.34,66.08 302,66.08 302.61,65.47 303.35,65.47 303.65,65.77 DI4.9 DI4.1 305.36,65.77 305.51,65.62 308.13,65.62 309.51,64.24 310.84,64.24 311.34,64.74 311.66,64.74 311.97,65.04 JUSB1.5
USB3_PRX_DTX_N2: length 226.5
  TOP w0.104: RI28.1 275.74,69.05 LI16.4 278.96,69.05 280.85,67.17 280.85,63.29 282.38,61.76 282.42,61.76 282.83,61.36 282.83,61.32 284.6,59.54 v4(284.6,56.56) 284.6,52.85 284.87,52.57 285.58,52.57 285.8,52.35 285.8,51.07 285.58,50.85 283.53,50.85 v2(283.29,50.6)
  IN3 w0.135: v2(141.5,83.61) 141.86,83.61 141.99,83.74 141.99,83.86 142.61,84.48 142.81,84.48 142.91,84.48 143.44,84.48 144.15,85.19 147.11,85.19 147.68,85.75 149.52,85.75 149.88,86.11 151.77,86.11 153.27,84.61 160.85,84.61 161.42,85.18 164.29,85.18 165.13,84.35 167.3,84.35 167.81,83.84 168.24,83.84 169.15,82.93 169.15,82.59 171.47,80.28 171.47,77.86 171.07,77.46 171.07,74.53 171.47,74.13 171.47,74.13 171.71,73.9 171.71,73.89 173.47,72.13 174.11,72.13 177.45,68.79 177.45,67.04 181.49,63.01 181.49,61.52 182.95,60.06 182.95,58.79 186.62,55.12 186.62,53.65 193.29,46.98 193.29,46.97 200.86,39.4 201.07,39.4 206.36,34.11 232.18,34.11 232.23,34.16 235.06,34.16 238.41,30.8 239.72,30.8 241.25,29.26 242.14,29.26 243.4,28.01 244.95,28.01 245.09,28.14 245.09,28.87 245.27,29.06 247.67,29.06 248.3,28.43 248.3,27.53 248.65,27.18 253.73,27.18 254.1,27.56 258.32,27.56 259.22,28.45 259.73,28.45 261,29.73 262.47,29.73 264.36,27.84 276.65,27.84 280.34,31.53 280.34,32.03 281.54,33.23 281.54,44.72 283.85,47.03 283.85,50.33 283.58,50.6 v2(283.29,50.6)
  BOTTOM w0.076: v2(141.5,83.61) 141.78,83.61 141.94,83.45 UC1.J6
USB3_PRX_DTX_N3: length 240.8
  TOP w0.104: v2(24.22,30.13) 24.03,30.33 23.44,30.33 23.27,30.49 22.66,30.49 22.53,30.37 DI1.1 DI1.9 21.03,30.37 20.83,30.56 20.16,30.56 17.15,27.55 17.15,23.38 16.81,23.04 15.64,23.04 15.15,22.55 14.54,22.55 14.45,22.46 JUSB2.5
  IN1 w0.119: v2(139.66,83.57) 139.48,83.76 139.14,83.76 138.28,84.61 138.24,84.65 138.24,85.29 138.23,85.31 138.23,89.22 140.19,91.19 140.19,95.11 137.13,98.17 137.13,101.39 134.87,103.65 134.87,105.32 131.72,108.47 123.93,108.47 123.17,109.22 107.26,109.22 106.82,108.78 97.09,108.78 96.11,107.8 93.9,107.8 92.6,109.1 68.39,109.1 67.25,110.23 60.94,110.23 60.44,109.74 41.87,109.74 38.43,106.3 38.43,96.49 39.83,95.09 40.07,95.09 42.85,92.31 42.85,88.89 42.06,88.1 42.06,86.66 42.15,86.57 42.15,81.55 41.63,81.03 41.3,81.03 40.64,80.37 40.64,78.23 40.23,77.81 40.23,76.59 39.55,75.92 39.05,75.92 38.66,75.52 38.66,72.05 39.91,70.8 39.91,68.64 41.27,67.28 41.85,67.28 42.28,66.85 42.28,65.78 43.24,64.82 43.24,49.63 43.24,49.45 39.75,45.95 39.37,45.58 39.37,45.58 38.9,45.11 36.16,45.11 35.7,44.65 35.55,44.65 35.37,44.65 35.37,44.65 31.07,44.65 30.91,44.49 30.75,44.49 27.93,44.49 26.79,43.35 26.79,34 25.05,32.26 25.05,30.68 24.71,30.34 24.44,30.34 v2(24.22,30.13)
  BOTTOM w0.076: UC1.J10 139.94,83.29 v2(139.66,83.57)
USB3_PRX_DTX_N4: length 229.2
  TOP w0.104: v2(25.92,41.19) 25.92,41.28 25.8,41.4 25.64,41.4 24.98,40.75 24.98,40.59 23.83,39.44 23.48,39.44 23.35,39.31 DI6.6 DI6.5 21.79,39.31 21.6,39.49 20.99,39.49 17.94,42.54 15.53,42.54 15.04,42.05 14.61,42.05 14.45,41.89 JUSB3.5
  IN1 w0.119: v2(25.92,41.19) 25.33,41.19 25.08,41.44 25.08,43.38 27.05,45.35 30.05,45.35 30.39,45.35 30.39,45.35 30.44,45.35 30.47,45.39 30.48,45.39 31.01,45.92 34.73,45.92 35.04,45.6 35.37,45.6 36.2,46.44 39.01,46.44 42.38,49.81 42.38,64.4 40.58,66.21 40.58,66.69 38.5,68.76 38.5,70.68 37.78,71.41 37.78,74.89 37.54,75.13 37.54,76.35 38.75,77.56 38.75,78.16 39.03,78.44 39.44,78.44 39.78,78.78 39.78,82.65 40.16,83.03 40.16,86.1 41.16,87.09 41.16,90.34 41.07,90.42 41.07,92.01 40.28,92.81 40.28,93.62 39.66,94.23 39.47,94.23 37.57,96.13 37.57,96.58 37.56,96.59 37.56,106.65 41.52,110.61 60.06,110.61 60.59,111.13 67.84,111.13 68.99,109.98 106.56,109.98 106.85,110.27 123.38,110.27 124.31,109.34 134.7,109.34 139.69,104.35 139.69,96.95 142.05,94.59 142.05,90.72 141.32,89.98 140.31,89.98 139.23,88.9 139.23,86.22 139.38,86.07 139.6,86.07 v2(139.65,86.11)
  BOTTOM w0.076: UC1.E10 139.88,85.89 v2(139.65,86.11)
USB3_PRX_DTX_P1: length 241.6
  IN3 w0.076: v2(140.52,84.89) 140.52,84.78 140.65,84.65 141.08,84.65 141.31,84.42 141.31,84.09 141.14,83.91 141.14,83.3 141.17,83.27
  IN3 w0.135: v2(300.81,66.79) 301.11,66.79 301.26,66.64 301.26,66.41 301.16,66.32 301.08,66.32 301.05,66.29 297.26,66.29 295.87,64.9 295.87,63.22 296.28,62.81 296.28,60.17 295.95,59.84 295.95,56.23 294.02,54.3 293.52,54.3 292.43,53.21 292.43,52.23 284.46,44.26 284.46,33.45 283.61,32.59 283.61,31.66 282.29,30.34 281.3,30.34 280.16,29.2 280,29.2 277.18,26.37 273.9,26.37 273.31,26.96 261.91,26.96 261.48,27.39 259.12,27.39 258.6,26.87 254.55,26.87 254.18,26.5 248.23,26.5 247.71,27.02 242.23,27.02 239.19,30.06 237.77,30.06 235.3,32.54 234.02,32.54 233.15,33.4 205.17,33.4 203.06,35.5 203.06,36.44 201.18,38.32 200.97,38.32 192.59,46.7 192.59,46.72 185.94,53.37 185.94,54.84 178.97,61.8 178.97,64.28 176.25,67.01 176.25,69.03 173.85,71.43 173.17,71.43 170.37,74.22 170.37,77.85 170.79,78.27 170.79,79.78 166.9,83.66 163.83,83.66 163.35,84.15 162.48,84.15 162.26,83.93 152.98,83.93 151.49,85.43 150.37,85.43 149.45,84.51 144.71,84.51 142.92,82.72 142.25,82.72 142.08,82.89 141.55,82.89 141.17,83.27
  BOTTOM w0.076: UC1.G8 140.73,84.89 v2(140.52,84.89)
  BOTTOM w0.104: JUSB1.6 311.97,64.29 311.72,64.54 311.43,64.54 310.93,64.04 309.43,64.04 308.05,65.42 305.51,65.42 305.36,65.27 DI4.2 DI4.8 302.53,65.27 301.91,65.88 301.26,65.88 301.01,66.13 301.01,66.67 300.88,66.79 v2(300.81,66.79)
USB3_PRX_DTX_P2: length 226.4
  TOP w0.104: RI27.1 LI16.1 276.2,68.45 276.33,68.58 276.68,68.58 276.74,68.64 276.74,68.81 276.78,68.85 278.88,68.85 280.65,67.08 280.65,63.21 v4(282.46,61.4) 284.4,59.46 284.4,56.87 284.37,56.85 284.37,56.27 284.4,56.24 284.4,52.76 284.79,52.37 285.5,52.37 285.6,52.27 285.6,51.17 285.48,51.05 283.41,51.05 283.28,51.17 v2(283.28,51.29)
  IN3 w0.135: v2(283.28,51.29) 283.28,51.26 284.09,50.46 284.09,46.93 281.78,44.62 281.78,33.13 280.58,31.93 280.58,31.43 276.75,27.6 264.26,27.6 262.37,29.49 261.1,29.49 259.83,28.21 259.32,28.21 258.42,27.32 254.2,27.32 253.83,26.94 248.55,26.94 248.06,27.43 248.06,28.33 247.57,28.81 245.45,28.81 245.33,28.69 245.33,28.04 245.05,27.77 243.3,27.77 242.04,29.02 241.15,29.02 239.62,30.56 238.31,30.56 234.96,33.91 232.33,33.91 232.28,33.87 206.26,33.87 200.97,39.16 200.76,39.16 193.05,46.87 193.05,46.88 186.38,53.55 186.38,55.02 182.7,58.69 182.7,59.96 181.24,61.42 181.24,62.91 177.21,66.94 177.21,68.69 174.01,71.89 173.37,71.89 171.46,73.79 171.46,73.8 171.26,74 171.26,74 170.83,74.43 170.83,77.56 171.23,77.96 171.23,80.18 168.91,82.49 168.91,82.83 168.14,83.6 167.71,83.6 167.2,84.1 165.03,84.1 164.19,84.94 161.52,84.94 160.95,84.37 153.17,84.37 151.67,85.87 149.98,85.87 149.62,85.51 147.78,85.51 147.21,84.95 144.25,84.95 143.54,84.24 142.81,84.24 142.71,84.24 142.39,83.92 v2(142.39,83.68)
  BOTTOM w0.076: v2(142.39,83.68) 142.38,83.68 142.2,83.68 UC1.H6
USB3_PRX_DTX_P3: length 240.8
  TOP w0.104: JUSB2.6 14.45,22.84 14.54,22.75 15.06,22.75 15.56,23.24 16.73,23.24 16.95,23.47 16.95,27.64 20.08,30.77 20.86,30.77 20.96,30.87 DI1.8 DI1.2 22.51,30.87 22.68,30.69 23.35,30.69 23.52,30.53 24.04,30.53 v2(24.22,30.71)
  IN1 w0.119: v2(139.65,84.21) 139.42,83.98 139.23,83.98 138.81,84.39 138.46,84.75 138.46,85.38 138.44,85.4 138.44,89.13 140.41,91.1 140.41,95.2 137.34,98.27 137.34,101.48 135.09,103.74 135.09,105.41 131.81,108.69 124.02,108.69 123.26,109.44 107.17,109.44 106.73,109 97,109 96.02,108.02 93.99,108.02 92.69,109.31 68.48,109.31 67.35,110.45 60.84,110.45 60.35,109.96 41.78,109.96 38.21,106.39 38.21,96.4 39.73,94.88 39.98,94.88 42.63,92.22 42.63,88.98 41.84,88.19 41.84,86.57 41.93,86.48 41.93,81.64 41.54,81.25 41.21,81.25 40.42,80.46 40.42,78.32 40.01,77.9 40.01,76.68 39.46,76.13 38.96,76.13 38.44,75.61 38.44,71.96 39.69,70.71 39.69,68.55 41.18,67.07 41.76,67.07 42.06,66.76 42.06,65.69 43.02,64.73 43.02,49.54 39.53,46.04 38.81,45.33 36.07,45.33 35.61,44.87 30.98,44.87 30.82,44.71 30.66,44.71 27.84,44.71 26.57,43.44 26.57,34.09 24.83,32.35 24.83,30.77 24.62,30.56 24.37,30.56 v2(24.22,30.71)
  BOTTOM w0.076: v2(139.65,84.21) 139.92,83.94 UC1.H10
USB3_PRX_DTX_P4: length 229.2
  TOP w0.104: JUSB3.6 14.45,42.38 14.58,42.25 14.95,42.25 15.45,42.74 18.03,42.74 21.08,39.69 21.62,39.69 21.74,39.81 DI6.4 DI6.7 23.32,39.81 23.48,39.65 23.75,39.65 24.78,40.67 24.78,40.83 25.55,41.6 25.88,41.6 v2(26.11,41.83)
  IN1 w0.119: v2(26.11,41.83) 26.11,41.72 25.96,41.58 25.76,41.58 25.59,41.41 25.42,41.41 25.3,41.53 25.3,43.29 27.15,45.14 29.96,45.14 30.53,45.14 30.57,45.17 30.57,45.17 31.1,45.7 34.64,45.7 34.95,45.38 35.28,45.38 35.46,45.38 36.29,46.22 39.1,46.22 42.6,49.72 42.6,64.49 40.79,66.3 40.79,66.78 38.72,68.85 38.72,70.77 38,71.5 38,74.98 37.76,75.22 37.76,76.26 38.97,77.47 38.97,78.07 39.12,78.23 39.53,78.23 40,78.69 40,82.56 40.38,82.94 40.38,86.01 41.37,87 41.37,90.43 41.29,90.51 41.29,92.1 40.49,92.9 40.49,93.71 39.75,94.45 39.56,94.45 37.79,96.22 37.79,96.67 37.78,96.68 37.78,106.56 41.61,110.39 60.15,110.39 60.68,110.91 67.75,110.91 68.9,109.76 106.65,109.76 106.95,110.05 123.29,110.05 124.22,109.12 134.61,109.12 139.47,104.26 139.47,96.86 141.83,94.5 141.83,90.81 141.23,90.2 140.22,90.2 139.01,88.99 139.01,86.13 139.29,85.85 139.37,85.85 139.49,85.72 139.55,85.72 139.65,85.62 v2(139.65,85.48)
  BOTTOM w0.076: UC1.F10 139.89,85.24 v2(139.65,85.48)
USB3_PRX_L_DTX_N2: length 8.4
  TOP w0.104: v2(271.32,68.79) 272.48,68.79 272.51,68.82 273.08,68.82 273.12,68.79 273.95,68.79 274.22,69.05 LI16.3 274.38,69.03 RI28.2
  BOTTOM w0.104: JNGFF2.21 268.95,67.79 269.82,68.65 271.19,68.65 v2(271.32,68.79)
USB3_PRX_L_DTX_P2: length 8.4
  TOP w0.104: v2(271.34,68.19) 271.73,68.59 v4(272.8,68.59) 273.77,68.59 274.21,68.15 LI16.2 RI27.2
  BOTTOM w0.104: v2(271.34,68.19) 271.08,68.45 269.9,68.45 269.15,67.7 269.15,66.98 269.25,66.87 269.3,66.87 269.45,66.72 JNGFF2.23
USB3_PTX_C_DRX_N1: length 19.5
  BOTTOM w0.104: CI13.1 300.17,63.98 v4(301.02,63.98) 302.15,63.98 302.15,63.99 302.63,63.99 302.63,63.98 302.95,63.98 303.07,64.1 303.57,64.1 303.73,64.27 DI4.7 DI4.4 305.22,64.27 305.39,64.1 305.82,64.1 306.19,63.72 306.19,58.5 306.75,57.94 308.14,57.94 309.34,59.14 311.23,59.14 311.68,58.69 311.86,58.69 311.97,58.79 JUSB1.8
USB3_PTX_C_DRX_N2: length 2.3
  TOP w0.104: CI29.1 277.27,70.59 276.56,70.59 LI17.4 275.78,70.96 RI30.1
USB3_PTX_C_DRX_N3: length 12.4
  TOP w0.104: JUSB2.8 14.45,28.42 14.57,28.54 14.96,28.54 15.4,28.1 16.62,28.1 19.99,31.47 20.04,31.47 20.44,31.88 20.44,31.91 20.54,32.02 20.72,32.02 20.87,31.87 DI1.7 DI1.4 22.66,31.87 22.78,31.99 23.43,31.99 CI5.1
USB3_PTX_C_DRX_N4: length 18.7
  TOP w0.104: JUSB3.8 14.45,47.88 14.61,48.04 14.96,48.04 15.73,47.27 16.41,47.27 17.58,46.09 17.58,44.27 20.2,41.65 20.2,41.61 20.62,41.18 20.63,41.18 20.87,40.95 21.69,40.95 21.84,40.81 DI6.2 DI6.8 23.44,40.81 23.62,40.99 23.85,40.99 24.3,41.44 24.3,42.37 v4(24.67,42.74) 25.06,43.12 26.27,43.12 26.6,42.8 CI27.1
USB3_PTX_C_DRX_P1: length 19.5
  BOTTOM w0.104: CI16.1 300.4,63.78 300.77,63.78 300.78,63.78 301.26,63.78 301.26,63.78 v4(302.39,63.78) 303.04,63.78 303.16,63.9 303.57,63.9 303.7,63.77 DI4.6 DI4.5 305.25,63.77 305.38,63.9 305.73,63.9 305.99,63.64 305.99,58.41 306.67,57.74 308.22,57.74 309.42,58.94 311.15,58.94 311.6,58.49 311.86,58.49 311.97,58.39 JUSB1.9
USB3_PTX_C_DRX_P2: length 2.2
  TOP w0.104: CI30.1 277.38,70.39 276.52,70.39 LI17.1 276.18,70.05 RI29.1
USB3_PTX_C_DRX_P3: length 12.3
  TOP w0.104: CI4.1 23.67,32.19 22.77,32.19 22.6,32.37 DI1.5 DI1.6 20.87,32.37 20.72,32.22 20.46,32.22 v4(20.08,31.84) 16.54,28.3 15.49,28.3 15.04,28.74 14.57,28.74 14.45,28.86 JUSB2.9
USB3_PTX_C_DRX_P4: length 18.7
  TOP w0.104: JUSB3.9 14.45,48.39 14.6,48.24 15.04,48.24 15.81,47.47 16.49,47.47 17.78,46.18 17.78,44.35 v4(20.57,41.56) 20.98,41.15 21.69,41.15 21.84,41.31 DI6.1 DI6.9 23.44,41.31 23.55,41.19 23.77,41.19 24.1,41.52 24.1,42.48 24.3,42.68 24.3,42.69 24.72,43.11 24.73,43.11 24.94,43.32 26.3,43.32 CI28.1
USB3_PTX_DRX_N1: length 221.7
  IN3 w0.135: v2(293.38,64.41) 293.38,64.44 293.19,64.25 292.92,64.25 292.23,63.56 292.23,59.81 293.12,58.92 293.12,57.45 292.75,57.08 292.75,56.87 292.06,56.19 288.46,56.19 286.22,58.42 277.33,58.42 274.93,56.03 269.97,56.03 269.52,55.58 267.38,55.58 266.89,56.07 265.56,56.07 261.95,52.46 261.95,50.93 261.46,50.44 260.06,50.44 259.89,50.27 258.35,50.27 257.25,49.17 255.48,49.17 254.54,48.23 253.49,48.23 242.26,37.01 240.13,37.01 238.77,38.37 237.1,38.37 236.45,39.01 230.43,39.01 229.48,38.06 211.92,38.06 211.34,38.64 205.82,38.64 203.46,41 203.46,41.7 196.3,48.86 196.3,49.99 190.93,55.36 190.41,55.36 189.61,56.15 189.61,56.6 185.81,60.4 185.81,61.26 184.26,62.81 184.26,64.13 180.6,67.79 180.6,69.57 179.17,71 179.17,77.81 178.11,78.87 178.11,81.84 170.44,89.5 166.96,89.5 166.65,89.81 162.03,89.81 157.95,93.9 153.54,93.9 150.51,90.87 147.57,90.87 147.24,91.19 142.9,91.19 141.68,92.41 141.09,92.41 v2(140.86,92.64)
  BOTTOM w0.076: v2(140.86,92.64) 140.85,92.64 140.61,92.4 140.17,92.4 139.81,92.04 139.81,90.25 138.66,89.09 138.16,89.09 137.95,88.89 137.95,88.48 137.99,88.38 137.99,88.19 137.95,88.1 137.95,87.85 138.09,87.37 138.09,87.26 138.14,87.08 138.24,87.03 138.37,87.03 138.47,87.13 138.47,87.23 UC1.C13
  BOTTOM w0.104: v2(293.38,64.41) 293.38,64.44 293.67,64.15 295.53,64.15 295.73,63.95 298.76,63.95 CI13.2
USB3_PTX_DRX_N2: length 236.4
  TOP w0.104: v2(285.06,52.99) 285.66,52.99 285.91,53.23 285.91,59.46 285.94,59.49 285.94,60.06 285.91,60.09 285.91,60.95 281.86,65.01 281.86,68.16 279.16,70.86 278.73,70.86 CI29.2
  IN3 w0.135: v2(285.06,52.99) 285.01,52.99 284.89,53.11 284.88,53.11 284.8,53.19 280.98,53.19 280.31,52.52 280.31,47.31 280.03,47.04 278.41,47.04 277.94,46.57 277.94,44.85 278.28,44.51 278.28,39.54 279.51,38.31 279.51,33.88 278.8,33.16 278.06,33.16 277.91,33.31 276.91,33.31 276.23,32.63 275.49,32.63 275.14,32.28 267.91,32.28 267.3,32.9 265.16,32.9 264.58,32.32 261.6,32.32 261.48,32.2 257.7,32.2 257.23,31.73 257.23,30.16 256.82,29.76 254.33,29.76 254.14,29.95 253.59,29.95 253.23,30.3 253.23,30.86 252.96,31.14 252.3,31.14 251.09,32.35 249.46,32.35 248.58,33.23 246.04,33.23 244.83,32.02 243.22,32.02 242.72,32.53 242.72,33.4 242.44,33.68 241.72,33.68 241.21,33.17 239.97,33.17 239.08,34.06 239.08,35.08 237.94,36.22 231.64,36.22 231.39,35.96 207.16,35.96 202.45,40.67 202.45,41.07 195.2,48.33 195.2,49.73 191.05,53.88 190.58,53.88 188.69,55.77 188.69,56.22 184.89,60.03 184.89,60.88 183.34,62.43 183.34,63.73 179.67,67.4 179.67,69.2 178.21,70.66 178.21,71.92 175.4,74.74 174.89,74.74 174.67,74.96 174.34,74.96 174.28,74.9 173.34,74.9 172.94,75.3 172.94,76.77 173.81,77.64 173.81,81.02 172.35,82.48 172.35,85.16 169.51,88.01 166.99,88.01 166.26,88.74 161.78,88.74 157.54,92.97 153.92,92.97 150.85,89.89 147.16,89.89 146.82,90.23 142,90.23 141.29,90.94 141.09,90.94 v2(140.84,90.69)
  BOTTOM w0.076: UC1.B13 138.39,88.12 138.45,88.19 138.77,88.19 139.09,88.51 139.09,88.7 140.43,90.04 140.43,90.82 140.5,90.9 140.64,90.9 140.84,90.7 v2(140.84,90.69)
USB3_PTX_DRX_N3: length 216.7
  TOP w0.104: CI5.2 25.15,31.87 25.45,31.87 25.58,31.74 v2(25.58,31.58)
  IN1 w0.119: v2(25.58,31.58) 25.58,31.76 25.69,31.87 25.87,31.87 27.43,33.43 27.43,42.37 28.91,43.85 29.43,43.85 31.19,43.85 31.32,43.98 35.94,43.98 36.42,44.46 39.77,44.46 41.07,45.76 41.07,46.35 44.04,49.33 44.04,52.3 44.48,52.74 44.48,57.1 44.04,57.54 44.04,64.99 42.94,66.09 42.94,67.12 42.09,67.97 41.6,67.97 40.57,69.01 40.57,71.15 40.02,71.69 40.02,75.47 40.89,76.33 40.89,77.56 41.28,77.96 41.28,78.14 42.12,78.98 42.12,80.61 42.79,81.28 42.79,86.82 43.49,87.53 43.49,92.58 40.33,95.74 40.09,95.74 39.08,96.75 39.08,106.02 42.13,109.07 60.77,109.07 61.29,109.59 66.91,109.59 68.06,108.44 92.34,108.44 93.63,107.14 96.36,107.14 97.36,108.14 107.35,108.14 107.77,108.55 122.88,108.55 123.63,107.8 126.44,107.8 126.79,107.46 131.8,107.46 134.08,105.18 134.08,103.53 136.46,101.16 136.46,97.94 139.54,94.85 139.54,91.45 139.39,91.29 139.25,91.29 139.19,91.36 139.13,91.36 139.02,91.46 v2(139.02,91.6)
  BOTTOM w0.076: v2(139.02,91.6) 138.84,91.42 137.98,91.42 137.75,91.19 137.75,91.02 136.86,90.14 136.86,89.16 136.58,88.88 136.58,88.28 136.73,88.12 UC1.B15
USB3_PTX_DRX_N4: length 206.9
  TOP w0.104: CI27.2 27.86,43.08 28.22,43.08 28.33,42.97 28.33,42.52 28.6,42.25 29.4,42.25 29.61,42.04 29.61,41.81 v2(29.45,41.65)
  IN1 w0.119: v2(29.45,41.65) 28.79,41.65 28.54,41.9 28.54,42.83 29.12,43.41 30.93,43.41 31.41,42.93 32.56,42.93 33.06,43.43 35.75,43.43 36.34,43.43 36.69,43.78 39.77,43.78 41.57,45.58 41.57,46.26 44.47,49.15 44.47,52.13 44.9,52.56 44.9,57.29 44.47,57.73 44.47,58.61 45.47,59.61 45.47,60.92 44.47,61.91 44.47,65.29 43.39,66.38 43.39,67.74 42.59,68.53 42.59,68.99 41.16,70.42 41.16,71.2 40.45,71.91 40.45,74.79 42.1,76.44 42.1,78.36 42.55,78.81 42.55,80.44 43.24,81.13 43.24,86.64 43.97,87.37 43.97,93.51 43.65,93.83 43.65,94.85 43.78,94.97 43.78,95.98 42.92,96.84 40.36,96.84 39.92,97.28 39.92,99.28 39.53,99.67 39.53,105.84 42.28,108.6 66.96,108.6 67.55,108.01 92.11,108.01 93.44,106.67 96.49,106.67 97.53,107.72 121.95,107.72 122.3,107.36 126.16,107.36 126.5,107.03 129.92,107.03 136,100.95 136,97.8 138.6,95.19 138.6,93.6 138.45,93.45 138.45,90.72 v2(138.77,90.41)
  BOTTOM w0.076: UC1.C15 137,87.34 137,87.51 137.12,87.62 137.18,87.62 137.24,87.69 137.3,87.88 137.3,88.07 137.28,88.13 137.27,88.19 137.27,88.41 137.3,88.51 137.32,88.53 137.32,88.71 137.32,89.73 137.9,90.31 138.68,90.31 138.76,90.38 138.76,90.4 v2(138.77,90.41)
USB3_PTX_DRX_P1: length 221.6
  IN3 w0.135: v2(140.86,91.98) 141.06,92.17 141.58,92.17 142.8,90.95 147.14,90.95 147.47,90.63 150.61,90.63 153.64,93.65 157.85,93.65 161.93,89.57 166.55,89.57 166.86,89.26 170.34,89.26 177.87,81.74 177.87,78.77 178.93,77.71 178.93,70.9 180.36,69.47 180.36,67.69 184.02,64.03 184.02,62.71 185.57,61.16 185.57,60.3 189.37,56.5 189.37,56.05 190.31,55.12 190.83,55.12 196.05,49.89 196.05,48.76 203.21,41.6 203.21,40.9 205.72,38.4 211.24,38.4 211.82,37.82 229.58,37.82 230.53,38.77 236.35,38.77 236.99,38.12 238.67,38.12 240.03,36.76 242.36,36.76 253.59,47.99 254.64,47.99 255.58,48.93 257.35,48.93 258.45,50.02 259.99,50.02 260.16,50.2 261.56,50.2 262.19,50.83 262.19,52.36 265.66,55.83 266.79,55.83 267.28,55.34 269.62,55.34 270.07,55.78 275.03,55.78 277.43,58.18 286.12,58.18 288.36,55.95 292.16,55.95 292.99,56.77 292.99,56.98 293.36,57.35 293.36,59.02 292.47,59.91 292.47,63.46 293.02,64.01 293.23,64.01 293.38,63.86 v2(293.38,63.85)
  BOTTOM w0.076: UC1.D13 138.39,86.82 138.69,87.12 138.69,87.5 138.56,87.62 138.29,87.62 138.16,87.75 138.12,87.88 138.12,88.05 138.18,88.24 138.18,88.39 138.12,88.51 138.12,88.82 138.23,88.93 138.73,88.93 139.98,90.19 139.98,91.97 140.24,92.22 140.54,92.22 140.79,91.98 v2(140.86,91.98)
  BOTTOM w0.104: v2(293.38,63.85) 293.38,63.86 293.47,63.95 295.45,63.95 295.65,63.75 298.59,63.75 CI16.2
USB3_PTX_DRX_P2: length 236.2
  TOP w0.104: CI30.2 278.61,70.39 278.74,70.52 278.86,70.52 279,70.66 279.08,70.66 281.66,68.08 281.66,64.92 285.71,60.87 v4(285.71,59.77) 285.71,53.32 285.58,53.19 285.4,53.19 285.22,53.37 285.14,53.37 285.01,53.5 v2(285.01,53.56)
  IN3 w0.135: v2(140.84,91.36) 141.02,91.18 141.39,91.18 142.1,90.47 146.92,90.47 147.26,90.13 150.74,90.13 153.82,93.21 157.64,93.21 161.88,88.98 166.36,88.98 167.09,88.25 169.61,88.25 172.6,85.26 172.6,82.58 174.05,81.12 174.05,77.54 173.18,76.67 173.18,75.4 173.44,75.14 174.18,75.14 174.24,75.2 174.77,75.2 174.99,74.98 175.5,74.98 178.45,72.02 178.45,70.76 179.91,69.3 179.91,67.5 183.58,63.83 183.58,62.53 185.13,60.98 185.13,60.13 188.93,56.32 188.93,55.87 190.68,54.12 191.15,54.12 195.44,49.83 195.44,48.43 202.69,41.17 202.69,40.77 207.26,36.2 231.29,36.2 231.54,36.46 238.04,36.46 239.32,35.18 239.32,34.16 240.07,33.41 241.11,33.41 241.62,33.92 242.54,33.92 242.96,33.5 242.96,32.63 243.32,32.26 244.73,32.26 245.94,33.47 248.68,33.47 249.56,32.59 251.19,32.59 252.4,31.38 253.06,31.38 253.47,30.96 253.47,30.4 253.69,30.19 254.24,30.19 254.43,30 256.72,30 256.99,30.26 256.99,31.83 257.6,32.44 261.38,32.44 261.5,32.56 264.48,32.56 265.06,33.14 267.4,33.14 268.01,32.52 275.04,32.52 275.39,32.87 276.13,32.87 276.81,33.56 278.01,33.56 278.16,33.41 278.7,33.41 279.27,33.98 279.27,38.21 278.03,39.44 278.03,44.41 277.7,44.75 277.7,46.67 278.31,47.28 279.93,47.28 280.07,47.41 280.07,52.62 280.88,53.43 284.83,53.43 284.93,53.53 284.98,53.53 v2(285.01,53.56)
  BOTTOM w0.076: UC1.A13 138.39,88.48 138.52,88.36 138.67,88.36 138.9,88.58 138.9,88.78 140.25,90.13 140.25,90.89 140.43,91.07 140.62,91.07 140.84,91.28 v2(140.84,91.36)
USB3_PTX_DRX_P3: length 216.7
  TOP w0.104: v2(25.71,32.26) 25.52,32.07 25.15,32.07 CI4.2
  IN1 w0.119: v2(139.02,90.97) 139.13,91.08 139.48,91.08 139.76,91.36 139.76,94.94 136.67,98.03 136.67,101.25 134.3,103.62 134.3,105.27 131.89,107.68 126.88,107.68 126.53,108.02 123.72,108.02 122.97,108.77 107.68,108.77 107.26,108.36 97.27,108.36 96.27,107.36 93.72,107.36 92.43,108.65 68.15,108.65 67,109.8 61.2,109.8 60.68,109.29 42.04,109.29 38.86,106.11 38.86,96.66 40,95.52 40.24,95.52 43.28,92.49 43.28,87.62 42.57,86.91 42.57,81.37 41.9,80.7 41.9,79.07 41.07,78.23 41.07,78.05 40.67,77.65 40.67,76.42 39.8,75.56 39.8,71.6 40.35,71.06 40.35,68.92 41.51,67.75 42,67.75 42.72,67.03 42.72,66 43.83,64.9 43.83,57.45 44.26,57.01 44.26,52.83 43.83,52.39 43.83,49.42 40.85,46.44 40.85,45.85 39.68,44.68 36.33,44.68 35.85,44.2 31.23,44.2 31.1,44.07 30.93,44.07 28.82,44.07 27.21,42.46 27.21,33.52 25.95,32.26 v2(25.71,32.26)
  BOTTOM w0.076: UC1.A15 137.08,88.57 137.08,88.36 136.99,88.27 136.82,88.27 136.74,88.35 136.74,88.78 137.05,89.08 137.05,90.08 137.92,90.95 137.92,91.12 138.05,91.24 138.9,91.24 139.02,91.12 v2(139.02,90.97)
USB3_PTX_DRX_P4: length 206.9
  TOP w0.104: v2(30,41.99) 29.95,41.99 29.48,42.45 28.69,42.45 28.56,42.58 v4(28.56,42.86) 28.56,43.06 28.34,43.28 27.87,43.28 CI28.2
  IN1 w0.119: v2(138.36,89.93) 138.36,90.51 138.24,90.63 138.24,93.54 138.38,93.69 138.38,95.1 135.78,97.7 135.78,100.86 129.83,106.81 126.4,106.81 126.07,107.14 122.21,107.14 121.86,107.5 97.63,107.5 96.58,106.45 93.35,106.45 92.02,107.79 67.46,107.79 66.87,108.38 42.37,108.38 39.75,105.75 39.75,99.76 40.14,99.37 40.14,97.37 40.45,97.06 43.01,97.06 43.99,96.07 43.99,94.88 43.87,94.76 43.87,93.92 44.18,93.61 44.18,87.28 43.46,86.55 43.46,81.04 42.76,80.35 42.76,78.72 42.32,78.27 42.32,76.35 40.67,74.7 40.67,72 41.38,71.29 41.38,70.51 42.81,69.08 42.81,68.62 43.6,67.83 43.6,66.47 44.69,65.38 44.69,62.01 45.68,61.01 45.68,59.52 44.69,58.52 44.69,57.82 45.12,57.39 45.12,52.47 44.69,52.04 44.69,49.06 41.79,46.17 41.79,45.49 39.87,43.56 36.78,43.56 36.43,43.21 35.75,43.21 33.15,43.21 32.65,42.71 31.32,42.71 30.84,43.19 29.21,43.19 28.76,42.74 28.76,42 28.89,41.87 29.12,41.87 29.29,42.04 29.41,42.04 29.42,42.04 29.94,42.04 v2(30,41.99)
  BOTTOM w0.076: v2(138.36,89.93) 138.36,90.06 138.29,90.14 137.97,90.14 137.49,89.66 137.49,88.7 137.49,88.53 137.46,88.46 137.45,88.44 137.43,88.38 137.43,88.21 137.44,88.17 137.47,88.1 137.47,87.85 137.46,87.82 137.33,87.37 137.33,87.26 137.25,86.99 UC1.D15
USB3_PTX_L_DRX_N2: length 9
  TOP w0.104: RI30.2 274.79,70.96 LI17.3 274.17,70.96 273.95,70.74 v4(272.16,70.74) 271.35,70.74 270.35,69.73 v2(270.35,67.49)
  BOTTOM w0.104: JNGFF2.27 270.45,66.72 270.52,66.8 270.52,67.32 v2(270.35,67.49)
USB3_PTX_L_DRX_P2: length 9.1
  TOP w0.104: v2(270.93,67.49) 270.78,67.65 270.73,67.65 270.73,67.65 270.55,67.83 270.55,69.65 271.44,70.54 271.84,70.54 271.88,70.51 272.45,70.51 272.48,70.54 273.71,70.54 274.19,70.06 LI17.2 274.82,70.06 RI29.2
  BOTTOM w0.104: JNGFF2.29 270.95,66.72 270.73,66.95 270.73,67.29 v2(270.93,67.49)
USB20_N1: length 231.1
  TOP w0.104: v2(297.23,64.33) 297.04,64.15 297.04,63.93 296.66,63.55 295.18,63.55 293.67,65.05 v4(291.98,65.05) 291.25,65.05 290.76,65.54 290.76,68.02 291.2,68.46 292.06,68.46 292.38,68.78 292.71,68.78 292.78,68.85 UI3.2
  IN3 w0.135: v2(141.14,76.98) 140.97,76.98 140.89,77.06 140.89,77.14 140.74,77.28 140.74,77.5 140.9,77.66 141.21,77.66 141.43,77.44 141.87,77.44 142.01,77.38 142.28,77.11 142.58,77.11 145.81,77.11 146.02,76.9 147.19,76.9 147.39,77.1 148.74,77.1 149.29,77.65 155.04,77.65 155.55,78.16 162.75,78.16 164.4,76.51 165.07,76.51 166.26,75.31 166.26,73.37 172.15,67.49 172.15,64.17 182.27,54.05 182.78,54.05 184.17,52.66 184.17,52.29 188.83,47.63 188.83,46.11 199.7,35.24 199.7,33.85 201.49,32.06 214.44,32.06 214.72,31.78 220.06,31.78 220.72,32.43 232.14,32.43 237.34,27.23 240.31,27.23 241.46,26.09 246.7,26.09 247.21,25.58 254.71,25.58 255.07,25.94 259.87,25.94 261.09,24.71 269.3,24.71 269.46,24.55 278.95,24.55 281.95,27.55 282.64,27.55 283.37,28.28 283.37,29.21 285.41,31.25 285.41,43.9 293.76,52.25 294.73,52.25 296.78,54.3 296.78,55.66 297.62,56.51 297.62,60.03 297.21,60.45 297.21,63.29 296.8,63.7 296.8,64.52 296.89,64.61 297.08,64.61 297.23,64.47 v2(297.23,64.33)
  BOTTOM w0.076: v2(141.14,76.98) 140.84,77.43 UC1.AB9
USB20_N1_R: length 32.7
  TOP w0.104: v2(305.44,67.61) 305.21,67.38 304.87,67.38 304.68,67.57 304.68,71.21 306.05,72.59 306.05,75.29 305.83,75.5 305.78,75.5 DI5.2 304.75,76.37 303.91,75.53 303.02,75.53 301.6,74.11 301.6,73.17 301.57,73.14 301.57,72.57 301.6,72.54 301.6,69.6 300.67,68.67 299.92,68.67 LI7.2
  IN3 w0.135: v2(305.44,67.61) 305.25,67.42 304.78,67.42 304.41,67.05 304.41,66.05 306.05,64.41 306.05,63.96 308.54,61.47 309.59,61.47 JUSB1.2
USB20_N2: length 286.2
  IN1 w0.076: v2(142.48,75.9) 142.32,76.06 142.32,76.27 142.46,76.41 145.62,76.41 146.39,75.64 147.53,75.64 148.16,76.27 149.23,76.27 149.81,76.85 149.84,76.85 149.85,76.86
  IN1 w0.119: 149.85,76.86 149.92,76.92 154.97,76.92 155.77,77.72 155.77,84.74 158.84,87.82 158.84,91.09 155.8,94.14 155.8,100.26 143.16,112.9 125.38,112.9 123.44,114.84 105.45,114.84 104.09,113.49 95.44,113.49 93.83,111.88 72.41,111.88 70.83,113.46 55.63,113.46 54.03,111.86 40.41,111.86 39.68,111.14 39.68,110.69 37.04,108.05 36.49,108.05 36.03,107.59 36.03,106.6 36.3,106.34 36.3,95.56 37.82,94.04 37.82,93.19 39.03,91.99 39.03,90.23 39.38,89.87 39.38,89.59 39.62,89.35 39.62,87.82 38.15,86.35 38.15,82.2 37.62,81.67 37.62,79.09 37.46,78.92 37.46,78.06 37.09,77.7 36.05,77.7 35.15,76.79 35.15,67.8 36.15,66.8 37.13,66.8 39.48,64.45 40.53,64.45 41.13,63.85 41.13,50.33 38.56,47.76 27.35,47.76 27.17,47.76 24.96,45.56 24.96,45.34 22.42,42.79 22.42,35.96 23.46,34.92 23.46,20.86 22.21,19.61 22.21,18.8 22.59,18.43 23.4,18.43 23.71,18.74 23.71,18.97 v2(23.88,19.14)
  BOTTOM w0.076: v2(142.48,75.9) 142.48,76.04 142.79,76.34 UC1.AD6
  BOTTOM w0.104: v2(23.88,19.14) 23.52,19.5 LI3.1
USB20_N2_R: length 13.7
  BOTTOM w0.104: 22.9,25.03 21.97,24.1 21.37,24.1 v4(21.07,24.4) 20.35,25.12 20.35,25.16 19.93,25.59 19.91,25.59 19.75,25.75 16.08,25.75 15.95,25.88 JUSB2.2 ; 22.9,25.03 22.9,24.51 23.12,24.29 23.39,24.29 24.02,23.67 24.02,22.46 23.33,21.77 23.33,21.39 LI3.2 ; 22.9,25.03 DI2.3
USB20_N3: length 278.9
  IN1 w0.076: v2(148.23,72.55) 148.19,72.58 148.19,73.31 148.32,73.44 149.21,73.44 149.46,73.19 149.87,73.19 149.89,73.17 149.91,73.17
  IN1 w0.119: 149.91,73.17 153.25,73.17 153.35,73.07 154.93,73.07 156.66,74.81 156.8,74.81 159.7,77.71 159.7,85.95 160.77,87.02 160.77,93.06 157.72,96.1 157.72,101.12 143.85,114.99 126.4,114.99 124.57,116.82 99.46,116.82 98.12,115.48 90.97,115.48 89.62,114.13 78.27,114.13 78.08,113.94 72.4,113.94 70.94,115.41 55.12,115.41 53.01,113.3 48.38,113.3 47.89,113.79 46.4,113.79 45.58,112.97 40.55,112.97 39.02,111.45 39.02,111.01 36.71,108.7 35.97,108.7 34.65,107.38 34.65,104.13 34.95,103.83 34.95,98.24 35.22,97.97 35.22,94.67 35.63,94.27 36.07,94.27 37.18,93.16 37.18,92.81 37.57,92.42 37.57,90.86 37.57,89.82 37.72,89.66 37.72,87.59 36.58,86.45 36.58,84.8 37.51,83.87 37.51,82.47 36.61,81.57 36.61,80.98 36.95,80.64 36.95,79.39 36.73,79.17 36.41,79.17 34.45,77.22 34.45,73.92 33.4,72.87 33.4,68.64 34.3,67.74 34.3,67.14 36.1,65.33 37.63,65.33 39.31,63.65 39.89,63.65 40.49,63.05 40.49,50.84 38.05,48.41 25.82,48.41 24.32,46.91 24.32,45.6 21.19,42.47 21.19,34.97 21.59,34.57 21.98,34.57 v2(22.15,34.39)
  BOTTOM w0.076: UC1.AH3 144.05,73.67 144.21,73.67 144.44,73.56 144.62,73.56 144.78,73.62 144.92,73.62 145.14,73.56 145.26,73.56 145.26,73.56 145.37,73.6 147.52,73.6 147.97,73.16 147.97,72.81 v2(148.23,72.55)
  BOTTOM w0.104: v2(22.15,34.39) 22.47,34.71 22.69,34.71 23.09,34.31 LI4.1
