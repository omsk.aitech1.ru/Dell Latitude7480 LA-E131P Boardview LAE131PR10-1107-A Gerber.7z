# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17494434: length 55.4
  TOP w0.254: PU1201.5 41.88,73.79 PQ1212.1 ; PQ1212.1 41.84,73.17 v2(41.23,73.17) 41.23,72.2 v2(41.85,71.58) ; PQ1212.1 42.17,75.22 41.13,76.26 PR1238.1 ; PR1255.2 53.37,103.37 55.2,101.54 55.2,99.94 56.25,98.89 56.25,97.95 56.19,97.88 56.19,96.67 57.52,95.33 57.91,95.33 58.17,95.08 58.17,94.63 57.89,94.35 v2(55.34,94.35)
  IN2 w0.254: v2(55.34,94.35) 55.34,91.38 51.6,87.65 v2(51.6,85.39)
  IN3 w0.254: v2(51.6,85.39) 51.28,85.39 43.48,77.6 43.48,76.54 42.36,75.42 42.36,74.3 v2(41.23,73.17)
  BOTTOM w0.102: v3(38.76,69.77) 39.16,69.37 PR1239.2
  BOTTOM w0.254: v2(41.85,71.58) 41.49,71.21 41.02,71.21 PC1211.1 41,70.33 PR1246.1 40.05,69.37 PR1239.2 ; PD1205.1 41.23,73.76 v2(41.23,73.17)
N17509431: length 3
  TOP w0.203: PC947.1 60.65,94.84 PR949.2
  TOP w0.254: PC947.1 61.41,95.68 PR947.1 59.61,95.68 PR935.1
N17509921: length 1.3
  TOP w0.254: PD905.2 28.08,74.64 PR941.2
N17636493: length 2.9
  TOP w0.203: PU602.39 49.51,70.16 49.28,69.92 PR612.2
  TOP w0.254: PR612.2 48.22,69.03 PR614.2
N17637817: length 2.9
  TOP w0.203: PU602.40 49.75,69.76 49.48,69.49 49.48,68.98 48.58,68.08 PR616.2
N17639131: length 3.6
  TOP w0.203: PU602.1 50.76,69.11 50.14,69.11 48.06,67.02 PR620.2
N17853535: length 4.4
  TOP w0.254: v2(59.14,94.39) 59.59,94.84 PR949.1
  IN2 w0.254: v2(59.14,94.39) 59.3,94.55 61.19,94.55 v2(61.61,94.97)
  BOTTOM w0.203: v2(61.61,94.97) 61.77,94.8 PU901.29
N17853651: length 2.4
  TOP w0.254: PR948.1 62.36,94.8 v2(62.17,94.99) 62.17,95.44 PR936.1
  BOTTOM w0.203: PU901.30 v2(62.17,94.99)
N17965667: length 7.7
  TOP w0.254: PQ8.3 29.58,107.98 31.07,106.49 31.87,106.49 PR28.1 31.98,105.66 32.64,105 33.66,105 34.17,105.5 34.17,106.38 PR26.2
N18008238: length 1.6
  TOP w0.254: PQ1208.3 PQ1208.2 43.15,88.89 44.05,88.89 PR1259.1
N18008242: length 3.6
  TOP w0.102: PR1261.1 41.09,88.93 PQ1208.5 ; PR1261.1 39.78,89.78 PR1244.2 ; PR1261.1 40.41,89.78 40.97,90.34 PR1260.2
N18008271: length 6.4
  TOP w0.102: PR1261.2 PR1234.1 40.97,88.03 PQ1208.6 41.67,88.28 42.08,88.69 42.08,89.31 41.81,89.58 41.81,90.58 42.61,91.38 PQ1211.1
N18008295: length 3.6
  TOP w0.102: PQ1211.5 43.26,93.98 43.04,94.19 42.32,94.19 42.15,94.02 PR1233.1 40.72,94.9 PR1242.2
N18008297: length 12.6
  TOP w0.102: PQ1211.2 43.26,90.74 PR1235.1 42.59,90.69 v2(42.21,90.32) ; v2(41.18,96.34) 41.71,96.87 43.19,96.87 43.91,96.14 43.91,95.94 44.27,95.57 PR1257.2
  IN2 w0.102: v2(41.18,96.34) 41.18,93.75 42.21,92.71 v2(42.21,90.32)
N18008327: length 1.2
  TOP w0.102: PQ1210.5 38.48,93.38 37.9,93.96 PR1245.2
N18008396: length 11.7
  TOP w0.102: PQ1211.4 44.01,93.67 44.01,94.71 44.14,94.84 44.64,94.84 46.08,93.4 46.84,93.4 47.12,93.12 48.52,93.12 48.9,92.74 48.9,92.04 PR1230.1 47.59,91.41 47.06,90.88 PQ1207.6 47.06,89.25 PR1258.2
N18008581: length 8
  TOP w0.254: PR1232.1 43.12,87.09 43.26,87.24 43.3,87.24 44.66,88.6 44.66,90.94 44.96,91.24 44.96,91.72 45.23,91.99 45.72,91.99 PQ1207.3 45.79,92.03 45.96,92.2 46.25,92.2 PQ1207.2
N18011421: length 5.9
  TOP w0.254: v2(57.71,95.88) 57.71,96.03 58.05,96.37 58.05,96.73 PR951.2
  BOTTOM w0.203: PR933.2 58.24,96.26 58.24,95.9 58.88,95.27 59.77,95.27 60.57,94.46 PU901.26
  BOTTOM w0.254: PR933.2 57.96,96.46 57.71,96.21 v2(57.71,95.88)
N18029341: length 33.9
  TOP w0.254: PQ1203.1 45.08,76.45 44.5,76.45 44.48,76.42 v2(44.2,76.42)
  TOP w0.381: PQ1202.4 54.25,97.61 54.71,97.16 PR1207.2 54.7,96.66 PC1203.2 54.83,95.79 55.32,96.28 PR1213.1 55.82,96.28 57.29,94.81 v2(57.69,94.81)
  IN1 w0.381: v2(51.11,83.51) 51.11,84.68 51.06,84.72 51.06,87.55 53.3,89.8 54.46,89.8 v2(54.72,89.53)
  IN2 w0.381: v2(54.72,89.53) 54.72,89.75 55.1,90.13 56.49,90.13 57.05,90.7 57.05,94.18 v2(57.69,94.81)
  IN3 w0.381: v2(51.11,83.51) 50.34,83.51 45.06,78.23 45.06,77.01 44.48,76.42 v2(44.2,76.42)
N18150665: length 1.2
  TOP w0.381: PR1216.2 47.55,75.96 47.83,76.24 PU1200.4
N18150669: length 37.8
  TOP w0.254: PQ1201.2 36.62,96.73 36.07,97.28 v2(35.9,97.28) ; v2(39.36,76.61) 39.43,76.61 39.59,76.77 39.95,76.77 41.4,78.23 41.91,78.23 42.6,77.54 42.6,76.63 43.94,75.28 45.65,75.28 45.9,75.52 PR1216.1
  BOTTOM w0.254: v2(39.36,76.61) 39.87,76.61 40.38,77.12 40.38,84.43 39.83,84.98 37.58,84.98 37.53,84.93 37.09,84.93 36.2,85.82 36.2,86.42 v1(35.3,87.32) 35.3,88.91 34.25,89.95 34.25,91.32 33.64,91.94 33.64,94.75 34.48,95.6 34.48,96.13 35.63,97.28 v2(35.9,97.28)
N18150691: length 11
  TOP w0.381: PQ1214.6 v2(44.71,100.78)
  TOP w0.508: v2(39.51,98.86) 39.43,98.86 39.42,98.85 38.76,98.85 PR1252.2
  IN2 w0.508: v2(44.71,100.78) 44.11,100.19 42.5,100.19 41.99,99.68 41.99,97.63 41.32,96.96 40.55,96.96 40.09,97.42 40.09,98.15 39.51,98.74 v2(39.51,98.86)
N18150723: length 11.8
  TOP w0.254: PR1212.2 44.17,103.2 v2(44.6,102.77) ; PQ1201.6 38.91,97.71 39.27,97.71 39.27,97.71 v2(39.5,97.71)
  IN2 w0.254: v2(44.6,102.77) 44.6,102.39 43.65,101.44 42.24,101.44 40.94,100.15 39.56,100.15 38.97,99.55 38.97,98.54 39.5,98.01 v2(39.5,97.71)
N18150740: length 7.4
  TOP w0.102: PR1215.1 48.49,82.59 PR1226.2 48.97,83.94 48.97,84.88 49.79,85.7 PQ1205.1
N18151122: length 5.3
  TOP w0.102: PR1225.1 48.39,84.59 49.18,85.37 49.18,87.6 PQ1205.2
N18151130: length 6
  TOP w0.102: PR1221.2 46.64,84.42 PR1224.1 48.97,85.9 48.97,88.7 PQ1205.3
N18168775: length 1.1
  TOP w0.254: PR23.1 33.56,109.73 PU1.4
N18168791: length 1.3
  TOP w0.254: PU1.1 30,111.03 PR21.2
N18168794: length 3.7
  TOP w0.254: PU1.2 31.45,110.38 32.59,109.24 33.15,109.24 33.87,108.52 PR22.2
N18169269: length 1.1
  TOP w0.254: PR1215.2 48.48,79.54 PU1200.2
N18169272: length 1.1
  TOP w0.102: PR1211.2 49.13,79.3 PU1200.1
N18170358: length 1.1
  TOP w0.254: PU903.2 29.69,72.01 PR942.2
N18184051: length 1.1
  TOP w0.102: PR1241.2 46.41,89.48 PQ1207.5
N18325201: length 2.9
  TOP w0.102: v2(292.64,82) 292.64,82.01 CL16.1
  BOTTOM w0.102: TL1.3 v2(292.64,82) 292.1,82 v3(292.01,81.92)
N18325205: length 2.9
  TOP w0.102: CL17.1 292.7,83.28 v2(292.7,83.27)
  BOTTOM w0.102: v3(292.06,83.27) v2(292.7,83.27) TL1.4
N18325209: length 2.8
  TOP w0.102: v3(293.3,89.62) v2(292.8,89.62) 292.79,89.63 CL20.1
  BOTTOM w0.102: TL1.9 v2(292.8,89.62)
N18325213: length 2.9
  TOP w0.102: v3(293.47,90.89) v2(292.79,90.89) 292.78,90.9 CL21.1
  BOTTOM w0.102: TL1.10 v2(292.79,90.89)
N18364501: length 2.2
  BOTTOM w0.102: RV97.1 109.56,105.7 v3(109.72,105.85) 110.13,106.26 UV7.20
N18366912: length 2.1
  BOTTOM w0.102: UV7.17 111.33,105.03 CV96.1
N18410850: length 21.1
  TOP w0.254: PR635.1 58.64,70.22 59.12,69.74 59.73,69.74 60.21,70.22 PR647.2 61.67,70.22 63.37,71.92 63.37,72.94 63.62,73.2 64.92,73.2 65.89,74.16 65.89,75.44 66.19,75.75 66.19,76.1 66.41,76.32 67.62,76.32 68.16,76.87 71.82,76.87 v1(72.08,76.61) 72.39,76.29 PH603.2
N18490882: length 2.5
  TOP w0.102: RI14.2 293.47,71.62 v3(293,71.15)
  TOP w0.254: RI14.2 293.89,71.61 UI3.16
N18609334: length 8.3
  TOP w0.102: QV7.1 97.19,108.96 98.15,108.96 RV6.1 ; QV7.1 96.26,110.58 QV8.2 ; QV7.1 v3(95.91,108.5)
N18667384: length 2.8
  TOP w0.254: PU903.4 32.89,71.36 33.23,71.7 33.23,73.05 33.6,73.42 PR946.1
N18669063: length 1.2
  TOP w0.254: PQ8.2 31.19,108.46 31.95,108.46 PR29.1
N18670418: length 1.2
  BOTTOM w0.102: PC930.1 v3(65.07,87.2)
N18762046: length 0.9
  TOP w0.102: CA33.1 RA17.2
N18762152: length 1.4
  TOP w0.203: CZ127.1 295.01,20.24 295.05,20.28 UZ5.10
N18762172: length 1.4
  TOP w0.203: UZ5.12 295.85,20.49 295.9,20.44 CZ126.1
N18762349: length 3.9
  TOP w0.203: UA1.27 303.78,31.02 304.58,30.21 v3(304.7,30.21) 305.23,30.21 RA44.1 305.58,29.76 CA51.1
N18762353: length 4.3
  TOP w0.102: CA53.1 293.68,31.63 294.78,31.63 295.16,32.01 295.57,32.01 295.78,32.22 UA1.7
N18762355: length 3.6
  TOP w0.203: CA52.1 303.28,37.44 303.28,37.05 302.96,36.73 v3(302.64,36.73) 302.53,36.73 301.71,35.91 UA1.39
N18762401: length 6.7
  TOP w0.102: RA53.1 303.24,25.19 v3(303.43,25)
  TOP w0.203: RA53.1 301.75,25.19 RA54.1 301.56,25.46 301.39,25.63 301.39,28.28 300.91,28.76 UA1.20
N18762411: length 6.1
  TOP w0.102: v3(307.19,37.98) 307.19,37.28 CA29.1
  TOP w0.203: CA29.1 305.99,36.08 305.17,36.08 304.03,34.94 304.03,34.48 303.77,34.22 UA1.35
N18762416: length 3.5
  TOP w0.203: CA29.2 304.44,35.93 302.71,35.93 302.51,35.72 UA1.37
N18762426: length 2.6
  TOP w0.203: UA1.28 303.88,31.42 303.99,31.31 305.02,31.31 CA35.1
N18762428: length 3.3
  TOP w0.203: CA49.1 304.92,35.4 304.51,34.99 304.51,34.46 v3(304.48,34.43) 303.87,33.82 UA1.34
N18762438: length 2.2
  TOP w0.203: UA1.19 300.51,28.7 300.69,28.52 300.69,27.87 300.67,27.86 CA25.1
N18805219: length 3.2
  TOP w0.102: v1(83.76,86.01) 82.93,86.84 PR624.1
  TOP w0.254: PR624.1 82.4,87.72 v2(82.4,87.89)
  BOTTOM w0.254: PL614.3 v2(82.4,87.89)
N18894766: length 1
  TOP w0.254: PR646.2 53.89,77.22 53.52,77.59 PC640.1
N18894780: length 0.9
  TOP w0.254: PC601.1 55.04,78.02 PR652.2
N18894855: length 3.3
  TOP w0.203: PU602.28 51.59,75.46 51.53,75.52
  TOP w0.254: 51.53,75.52 51.34,75.71 51.34,76.12 51.21,76.24 PC632.1 PR636.1
N18894856: length 0.9
  TOP w0.254: PC632.2 51.23,77.21 51.23,78.02 PR641.1
N18894871: length 0.8
  BOTTOM w0.254: PH604.1 PR642.2
N20151644: length 9
  BOTTOM w0.254: PR909.1 v3(54.99,88.46) 54.45,88.46 53.68,87.69 51.81,87.69 50.88,86.76 50.88,85.9 50.62,85.64 49.89,85.64 49.63,85.9 PR901.2
N20880735: length 1
  BOTTOM w0.102: PC307.2 187.57,99.19 PR308.1
N24606174:
  vias: v2(186.87,100.63) v3(186.26,99.75)
N26506689: length 14.1
  TOP w0.203: v2(49.02,70.45) 49.13,70.56 PU602.38
  BOTTOM w0.102: PR678.2 51.86,64.04 50.6,62.78 48.7,62.78 47.3,64.19 v1(47.3,67.18) 47.3,68.73 v2(49.02,70.45)
N26508248: length 3.6
  TOP w0.203: PU602.34 v2(49.12,72.16)
  BOTTOM w0.254: v2(49.12,72.16) 49.17,72.21 50.01,72.21 PC603.1 49.7,72.83 PR602.1
N26508256: length 3.2
  TOP w0.203: PU602.33 49.38,72.56 v2(49.23,72.71)
  BOTTOM w0.254: v2(49.23,72.71) 49.13,72.71 PC604.1 47.39,73.46 PR603.1
N26509112: length 2.2
  TOP w0.203: PU602.32 49.67,72.96 49.43,73.2 48.53,73.2 PR608.1
N26509117: length 2.4
  TOP w0.203: PU602.31 49.73,73.36 49.58,73.5 49.05,73.5 48.2,74.35 PR611.1
N26518420: length 4.1
  TOP w0.203: PR640.1 57.81,75.55 PC630.1 56.68,75.55 55.39,74.25 55.39,73.56 55.18,73.36 PU602.20
N26519264: length 9.8
  TOP w0.102: PR657.2 78.56,80.24 79.78,80.24 v3(80.14,79.89)
  TOP w0.254: PR657.2 77.54,80.73 v2(77.35,80.92)
  BOTTOM w0.254: v2(77.35,80.92) 78.13,80.13 78.13,79.37 77.04,78.28 PH605.1
N26522108: length 0.9
  TOP w0.254: PC639.2 PR645.1
N26523008: length 0.9
  TOP w0.203: PR650.2 58.84,71.1 PC647.2
N26523611: length 1.1
  BOTTOM w0.254: PC629.2 54.78,72.55 PR639.1
N26526626: length 0.9
  TOP w0.254: PR632.2 53.71,65.35 PC627.1
N26527807: length 2.5
  TOP w0.102: PR628.2 72.24,71.04 v2(72.57,71.04)
  TOP w0.127: v1(73.27,70.4) 73.27,70.72 72.95,71.04 v2(72.57,71.04)
  BOTTOM w0.102: v2(72.57,71.04) 72.34,70.81 PH602.1
N26528911: length 3.3
  TOP w0.203: PU602.8 53.59,68.58 54.13,68.04 54.13,67.53 PC627.2
  TOP w0.254: PR638.2 52.83,67.11 PC627.2
N26532119: length 1.1
  TOP w0.254: PC621.2 46.99,65.75 PR623.1
N26532121: length 6.1
  TOP w0.203: PR621.2 PR622.2 ; 51.84,67.28 52.12,67.57 52.12,68.12 52.39,68.38 PU602.5
  TOP w0.254: PR623.2 49,66.13 49.1,66.24 PR622.2 ; 51.84,67.28 PR621.2
N26533060: length 3
  TOP w0.203: PU602.4 51.99,68.47 51.53,68 v2(51.53,67.82)
  BOTTOM w0.254: PR617.2 PC616.2 51.53,68.41 v2(51.53,67.82)
N26533062: length 1.3
  BOTTOM w0.254: PR617.1 52.71,69.41 PC614.2
N26533293: length 3.1
  TOP w0.203: PU602.3 51.59,68.54 50.86,67.81 50.86,67.39 50.59,67.11 PR610.2
N26533871: length 3.8
  TOP w0.203: v2(50.6,68.29) 50.88,68.29 51.19,68.61 PU602.2
  BOTTOM w0.102: PR613.2 v3(48.48,68.88)
  BOTTOM w0.254: v2(50.6,68.29) 50.34,68.55 PC613.2 PR613.2
N26535263: length 3.9
  TOP w0.254: PR661.1 77.7,82.22 v2(77.33,82.59)
  BOTTOM w0.254: v2(77.33,82.59) 77.23,82.5 77.23,81.62 76.97,81.35 PL610.3
N26554964: length 2.3
  TOP w0.254: v2(50.57,64.69) 50.79,64.9 PR621.1
  BOTTOM w0.102: v3(50.76,63.9) 50.57,64.09 v2(50.57,64.69)
  BOTTOM w0.254: PC617.2 50.57,65.07 v2(50.57,64.69)
N26566701: length 0.9
  BOTTOM w0.254: PC631.1 50.59,73.79 PR630.2
N26570644: length 0.9
  TOP w0.254: PR644.1 57.81,76.46 PC630.2
N27076067: length 2
  BOTTOM w0.102: v3(61.93,97.96) 61.79,97.82 61.79,97.2 PR934.2
  BOTTOM w0.254: PR934.2 61.56,96.97 PC944.1
N27077001: length 208
  TOP w0.254: v2(88.43,95.5) 88.6,95.67 88.6,98.76 93.2,103.36 97.17,103.36 98.25,104.44 99.63,104.44 101.85,106.65 104.99,106.65 107.21,108.87 117.86,108.87 118.32,109.33 126.77,109.33 127.06,109.61 127.06,109.62 128.51,111.06 129.76,111.06 129.97,110.85 131.26,109.56 131.32,109.56 131.35,109.54 133.46,109.54 134.88,110.96 153.58,110.96 157.71,106.83 158.64,106.83 158.94,106.52 158.94,105.35 v1(159.18,105.11) 159.66,104.63 159.66,101.1 160.57,100.19 167.01,100.19 167.66,100.84 169.02,100.84 170.13,99.73 172.9,99.73 174.14,98.49 174.14,93.79 173.93,93.58 173.93,92.24 174.84,91.33 174.84,88.94 175.81,87.97 176.85,87.97 176.97,87.85 179.29,87.85 185.26,81.89 185.26,76.5 186.09,75.67 186.09,73.08 186.97,72.21 186.97,71.42 186.61,71.05 186.61,69.5 194.66,61.44 194.66,55.68 204.14,46.2 204.14,42.76 v2(205.39,41.52)
  BOTTOM w0.254: v2(88.43,95.5) 88.43,95.7 88.72,95.98 89.45,95.98 89.76,95.67 89.76,94.56 89.21,94 85.41,94 85.18,94.23 82.79,94.23 81.8,93.24 81.8,92.57 80.44,91.21 79.09,91.21 78.72,91.59 78.59,91.71 78.59,91.93 78.59,92.46 78.59,92.61 78.48,92.72 78.48,92.73 78.15,93.06 74.55,93.06 74.34,93.27 73,94.61 72.3,94.61 71.53,95.38 70.66,95.38 69.93,96.11 67.52,96.11 67.17,96.45 66.59,96.45 PR937.2 ; v2(205.39,41.52) 204.85,42.05 PR917.2
N28424999: length 23.5
  BOTTOM w0.076: UC1.AW71 104.77,67.63 103.85,67.63 103.55,67.34 103.55,66.77 103.41,66.63 103.41,66.21 101.07,63.87
  BOTTOM w0.102: T113.1 88.19,64.92 91.38,64.92 95.79,60.51 98.98,60.51 100.77,62.31 100.77,63.57 101.07,63.87
N28425002: length 21.1
  BOTTOM w0.076: UC1.AW70 105.35,67.43 104.35,67.43 104.32,67.47 103.91,67.47 103.72,67.27 103.72,66.7 103.58,66.56 103.58,66.06 101.07,63.55
  BOTTOM w0.102: 101.07,63.55 100.98,63.46 100.98,62.22 98.89,60.13 95.8,60.13 91.44,64.48 T114.1
N28489601: length 13
  BOTTOM w0.102: v1(241.33,42.61) 240.76,43.18 240.76,46.7 240.46,47 239.3,47 239.13,46.83 RC222.1 239.33,47.61 240.49,47.61 242.08,49.19 242.08,49.5 SW1.2
N28712229: length 2.3
  TOP w0.127: v1(66.04,76.56) 66.04,76.46 65.15,75.57 65.05,75.57
  BOTTOM w0.203: v2(64.96,75.09) 65.07,75.2 PU612.7
N28712232: length 2
  TOP w0.127: v1(65.46,74.73) 65.46,74.3 65.17,74.01 64.98,74.01
  BOTTOM w0.203: v2(64.91,74.46) 64.97,74.46 65.31,74.8 PU612.6
N28712235: length 1.4
  TOP w0.102: v1(62.82,72.54) 62.82,72.71 62.82,73.89 PR672.1
N28713556: length 1.7
  BOTTOM w0.203: PU612.1 69.62,75.6 69.79,75.76 PR671.1
N28714854: length 3.2
  TOP w0.102: v3(77.64,76.83) 77.33,76.83 PC655.2
  TOP w0.203: PU610.7 75.9,78.26 PC655.2
N28714856: length 2.8
  TOP w0.127: PR660.2 74.42,77.74 74.19,77.51 74.01,77.51 v3(74,77.52)
  TOP w0.203: PR660.2 75.21,78.26 75.5,78.56 PU610.6
N28714858: length 2.3
  TOP w0.102: PR660.1 v3(75.21,75.32)
  TOP w0.254: PC655.1 76.42,76.35 PR660.1
N28714920: length 4.3
  TOP w0.102: v3(79.31,84.26) 79.21,84.36 77.42,84.36 77.13,84.07 PR659.1
  TOP w0.203: PR659.1 77.13,83.13 76.61,82.61 PU610.1
N28716223: length 1.7
  BOTTOM w0.254: PC663.2 56.4,67.2 PU613.7
N28716225: length 1.7
  BOTTOM w0.254: PU613.6 56.57,66.8 PR665.2
N28716227: length 1.2
  BOTTOM w0.254: PR665.1 54.66,66.29 PC663.1
N28716292: length 1.9
  BOTTOM w0.254: PU613.1 61.42,67.6 61.6,67.78 61.6,68.73 PR664.1
N28718522: length 3.1
  TOP w0.508: PC611.2 71.9,90.51 v2(72.1,90.72)
  BOTTOM w0.102: v2(72.1,90.72) 72.1,91.45 v3(72.54,91.89)
  BOTTOM w0.254: PU614.2 v2(72.1,90.72)
N28718526: length 1.5
  TOP w0.127: PC611.1 73.29,91.05 v1(73.12,91.23)
N28769860: length 0.8
  TOP w0.102: v2(184.98,112.3) 185.17,112.49 v3(185.74,112.49)
N28771761: length 3.7
  TOP w0.102: v2(184.27,107.65) v3(183.9,107.28)
  IN2 w0.254: v2(184.27,107.65) 184.62,108.01 v2(186.4,108.01)
  BOTTOM w0.203: PU401.14 186.51,108.12 v2(186.4,108.01)
N28771835: length 4.7
  TOP w0.102: v2(176.81,111.67) 177.04,111.44 v3(177.04,110.97)
  IN2 w0.381: v2(176.81,111.67) 176.65,111.83 v2(174.8,111.83)
  BOTTOM w0.254: PR426.2 176.35,110.94 PR410.2 176.34,111.21 v2(176.81,111.67)
N28810563: length 1.3
  TOP w0.254: UZ2.10 301.84,63.86 CZ110.1
N28811129: length 1.5
  TOP w0.203: CZ114.1 198.13,35.65 198.74,35.65 198.9,35.49 UZ3.10
N28856399: length 20.4
  BOTTOM w0.076: UC1.BA70 105.68,66.45 105.68,65.83 105.52,65.67 103.65,65.67 101.41,63.43 101.41,62.08 101.07,61.74
  BOTTOM w0.102: T16.1 91.92,63.02 95.32,59.62 98.95,59.62 101.07,61.74
N28856402: length 22.9
  BOTTOM w0.076: UC1.BA68 105.86,66.92 105.29,66.92 105.15,66.78 104.58,66.78 104.5,66.7 103.95,66.7 103.74,66.5 103.74,66 101.24,63.49 101.24,62.19 101.07,62.02
  BOTTOM w0.102: 101.07,62.02 98.87,59.82 95.4,59.82 91.7,63.53 89.73,63.53 T17.1
N28857231: length 20.9
  BOTTOM w0.076: 101.18,61.28 101.77,61.86 101.77,63.32 103.79,65.34 105.78,65.34 106.43,65.99 UC1.BB68
  BOTTOM w0.102: 101.18,61.28 98.69,58.78 93.71,58.78 T12.1
N28857234: length 19
  BOTTOM w0.076: 101.07,61.45 101.59,61.97 101.59,63.38 103.72,65.5 105.71,65.5 106,65.79 UC1.BB69
  BOTTOM w0.102: 101.07,61.45 98.74,59.12 95.16,59.12 T13.1
N28857240: length 1.3
  TOP w0.102: v2(138.64,73.79) 138.64,73.83 T15.1
  BOTTOM w0.076: v2(138.64,73.79) 138.66,73.79 138.88,73.56 UC1.AK12
N28861827: length 11.2
  BOTTOM w0.076: UC1.C64 109.21,87.82 109.12,87.91 109.12,89.69 107.05,91.76 106.05,91.76 104.9,92.91 104.9,94.57
  BOTTOM w0.102: RC120.1 105.86,95.38 v3(105.06,95.38)
  BOTTOM w0.112: 104.9,94.57 104.9,95.23 v3(105.06,95.38)
N28938912: length 1
  BOTTOM w0.102: CC8.1 RC29.2
N28938914: length 1.9
  BOTTOM w0.102: CC7.1 159.97,76.81 RC28.2 159.12,75.95 v3(159.04,75.88)
N29207759: length 53.8
  TOP w0.254: v2(70.42,71.28) 70.08,70.94 69.3,70.94 PR631.2 ; v2(49.96,68.27) 49.86,68.27 49,67.4 PR610.1
  IN2 w0.254: v2(70.42,71.28) 70.68,71.02 71.8,71.02 73.08,69.75 74.48,69.75 76.14,68.08 76.14,63.77 72.92,60.55 64.24,60.55 64.06,60.37 58.22,60.37 57.29,61.3 52.62,61.3 51.76,60.44 49.64,60.44 48.18,61.9 48.18,66.48 v2(49.96,68.27)
  BOTTOM w0.254: v2(70.42,71.28) 70.08,70.94 v3(70.07,70.94) 70.07,70.94 69.3,70.94 PH601.2
N29708559: length 11.6
  BOTTOM w0.076: 148.61,64.99 148.5,65.1 147.68,65.1 146.97,65.8 145.66,65.8 145.61,65.85 145.37,65.85 145.18,65.67 144.92,65.67 144.73,65.85 144.73,66.08 144.53,66.29 144.1,66.29 143.92,66.47 143.92,66.98 143.64,67.26 UC1.AY4
  BOTTOM w0.102: 148.61,64.99 149.25,64.35 149.25,62.93 149.56,62.63 150.87,62.63 T126.1
N29708561: length 27.3
  BOTTOM w0.076: UC1.BB3 144.4,65.95 144.85,65.5 145.25,65.5 145.39,65.64 146.82,65.64 148.61,63.85
  BOTTOM w0.102: 148.61,63.85 148.85,63.61 148.85,62.77 149.29,62.32 152.59,62.32 153.39,61.52 157.64,61.52 158.05,61.93 161.29,61.93 161.69,62.32 167.43,62.32 T127.1
N29708599: length 11.5
  BOTTOM w0.076: UC1.AU5 143.27,69.52 143.27,69.98 143.45,70.16 144.92,70.16 145.2,70.44 145.2,70.63 145.85,71.27 147.12,71.27 148.01,70.38 148.96,70.38 149.41,69.93 149.95,69.93
  BOTTOM w0.102: 149.95,69.93 151.83,69.93 T128.1
N29708601: length 11.2
  BOTTOM w0.076: UC1.AT5 142.85,69.86 143.15,70.16 143.15,70.75 143.26,70.86 144,70.86 144.19,71.05 144.19,71.32 144.25,71.38 144.46,71.46 144.59,71.46 144.6,71.46 144.82,71.39 144.95,71.39 145.1,71.45 145.1,71.45 145.17,71.46 arc(145.25,71.45) 145.32,71.44 145.47,71.39 145.6,71.39 145.8,71.47 145.96,71.64 147.22,71.64 148.22,70.63 148.94,70.63 149.44,70.14 149.95,70.14
  BOTTOM w0.102: T129.1 151.36,70.14 149.95,70.14
N29708639: length 33.1
  BOTTOM w0.076: UC1.BB5 143.11,65.99 143.58,65.51 143.77,65.51 144.58,64.71 146.48,64.71 147.57,63.62 147.57,62.59 147.91,62.25
  BOTTOM w0.102: 147.91,62.25 147.91,62.25 147.91,61 148.18,60.74 148.18,60.57 148.39,60.36 149.74,60.36 149.85,60.47 157.59,60.47 158.32,61.21 161.82,61.21 162.33,61.72 168.81,61.72 169.73,62.64 170.54,62.64 T130.1
N30191461: length 3.7
  TOP w0.127: v3(51.13,51.52) 50.94,51.33 PR1322.2
  TOP w0.254: PU1302.5 49.48,49.49 50.01,50.02 50.01,50.53 PR1323.1 50.93,50.54 PR1322.2
N30191517: length 4.1
  TOP w0.254: PR1308.2 PR1311.1 52.9,61.42 51.57,60.09 PU1301.5
N30191539: length 8.3
  TOP w0.102: PR1302.2 45.73,53.24 46.38,52.6 v1(46.42,52.6)
  TOP w0.203: v2(49.69,55.78) 49.69,55.92 50.06,56.29 PU1301.14
  TOP w0.254: v2(46.15,54.7) 46.06,54.7 PR1303.2 PR1302.2
  IN2 w0.254: v2(49.69,55.78) 48.61,54.7 v2(46.15,54.7)
N30191541: length 7.7
  TOP w0.254: v2(45.73,43.64) 45.74,43.64 45.74,42.34 45.37,41.97 PR1313.2 44.93,41.46 45,41.4 v3(45,40.75) 44.08,40.75 PR1314.2
  IN2 w0.254: v2(48.11,45.17) 48.11,44.81 46.94,43.64 v2(45.73,43.64)
N30409911: length 3.4
  TOP w0.102: LV1.1 66.12,115.69 v2(65.92,115.89)
  BOTTOM w0.102: JEDP1.16 66.2,116 66.1,115.89 v2(65.92,115.89)
N32011565:
  vias: v2(73.42,87.02) v2(75.81,86.9)
N32011581: length 5.4
  TOP w0.102: v2(75.84,89.61) v3(76.37,89.61)
  IN2 w0.762: v2(71.15,90) 71.33,89.82 75.71,89.82 75.84,89.69 v2(75.84,89.61)
N32015249: length 1.3
  BOTTOM w0.254: PR679.1 72.1,86.49 PU614.7
N32590572: length 1.4
  TOP w0.203: CZ117.1 289.44,79.17 289.18,78.91 UZ4.12
N32592963: length 3.5
  TOP w0.102: v3(291.78,78.71) 290.39,78.71 CZ118.1
  TOP w0.203: UZ4.10 289.09,78.11 289.16,78.05 289.73,78.05 CZ118.1
N32594166: length 1.4
  TOP w0.254: UZ2.12 301.04,63.7 CZ109.1
N32595008: length 3.4
  TOP w0.102: RZ70.2 301.09,57.89 v3(301.49,57.5)
  TOP w0.203: RZ70.2 301.09,59.29 RZ71.2 301.04,59.34 UZ2.3
N32817808: length 1.4
  TOP w0.203: CZ113.1 198.95,34.63 199.01,34.69 UZ3.12
N32818355: length 4.2
  TOP w0.102: RZ64.2 203.1,35.68 v3(203.46,36.04)
  TOP w0.203: RZ65.2 RZ64.2 202.89,34.96 202.44,34.51 201.93,34.51 201.75,34.69 UZ3.3
N32819772: length 2.9
  TOP w0.102: v3(168.05,70.49) 167.9,70.34 CZ121.1 167.9,69.26 167.11,68.47 UZ8.6
N33199734: length 2.1
  TOP w0.102: T50.1 88.59,23.53 v2(88.4,23.71)
  BOTTOM w0.102: v2(88.4,23.71) 88.57,23.89 JDIMM1.162
N33199744: length 6.6
  TOP w0.102: T51.1 90.67,35 v2(90.79,35.12)
  BOTTOM w0.102: v2(90.79,35.12) 89.55,35.12 89.32,34.9 JDIMM1.165
N33290988: length 6.1
  TOP w0.102: RD31.1 161.9,28.58 v3(161.9,29.98)
  TOP w0.254: CD62.2 163.97,27.04 162.72,27.04 162.37,27.39 RD31.1
N33298469: length 2.8
  TOP w0.102: T54.1 168.94,26.99 168.3,26.99 v2(167.9,26.59)
  BOTTOM w0.102: v2(167.9,26.59) 167.68,26.81 JDIMM2.162
N33298471: length 3
  TOP w0.102: v2(169.24,34.76) 168.71,35.3 168.28,35.3 T55.1
  BOTTOM w0.102: v2(169.24,34.76) 169.03,34.76 168.43,35.37 JDIMM2.165
N33612393: length 2.3
  TOP w0.102: CD31.2 173.81,26.95 173.66,26.79 173.66,26.71 173.61,26.67 v3(173.61,26)
  TOP w0.254: RD18.1 174.73,27.26 CD31.2
N35551572: length 1.9
  BOTTOM w0.254: PR1243.2 42.69,71.51 PC1214.1 43.23,71.47 43.47,71.71 PQ1209.5
N35551576: length 2.7
  BOTTOM w0.102: PR1236.1 v3(45.45,69.04)
  BOTTOM w0.254: PQ1209.2 PQ1209.3 45.45,70.88 PR1236.1
N35551581: length 65.4
  TOP w0.254: PR1229.2 53.97,107.01 53.11,107.87 v2(53.06,107.87)
  BOTTOM w0.254: v2(53.06,107.87) 53.06,108.03 52.17,108.93 47.55,108.93 46.82,109.66 41.19,109.66 41.02,109.49 36.64,109.49 35.6,108.45 35.24,108.45 34.62,107.83 34.62,103.94 36.76,101.8 36.76,96.73 36.17,96.14 35.53,96.14 33.99,94.6 33.99,92.09 35.65,90.43 35.65,88.21 35.94,87.92 35.94,87.28 36.67,86.55 37.42,86.55 37.7,86.27 37.7,86.14 38.49,85.35 40.16,85.35 40.73,84.78 v3(40.73,76.68) 40.73,75.9 42,74.64 42,73.19 42.28,72.92 43.17,72.92 PQ1209.6
N35551584: length 10.3
  TOP w0.254: PU1201.7 39.39,74.68 PR1240.2 39.94,75.32 PR1238.2 39.89,76.26 39.37,75.73 v2(39.37,75.5)
  BOTTOM w0.102: v2(39.37,75.5) v3(39.92,75.5)
  BOTTOM w0.254: v2(39.37,75.5) 39.37,74.57 PD1205.2 39.92,72.66 40.62,72.66 40.95,72.33 PC1213.1 41.17,72.31 PR1243.1
N35551592: length 4.5
  TOP w0.254: v2(39.07,72.74) 39.55,72.74 40.04,73.23 PU1201.6
  BOTTOM w0.254: PR1237.2 38.03,72.13 PC1212.1 38.3,72.12 PR1247.1 39.16,72.64 v2(39.07,72.74)
N35551616: length 4.4
  TOP w0.254: v2(44.96,72.74) 44.85,72.85 PQ1212.2
  BOTTOM w0.254: v2(44.96,72.74) 44.86,72.84 44.09,72.84 PR1248.1 ; PR1248.1 42.68,73.44 PR1249.1 ; PR1248.1 PR1250.1
N35551655: length 4.3
  TOP w0.254: PR1208.2 PR1217.1 PC1205.1 38.41,68.32 39.09,68.32 39.39,68.61 PU1201.2
N35551785: length 2.9
  TOP w0.508: PQ1203.2 46.12,79.16 46.75,79.78 PR1202.2 46.75,81.28 PR1209.1
N35551806: length 1.1
  TOP w0.381: PQ1204.3 45.74,81.37 PR1209.2
N35551822: length 52.2
  TOP w0.254: PQ1201.3 36.55,96.08 35.91,96.73 v2(35.88,96.73) ; v2(55.76,98.62) 55.49,98.36 55.49,97.37 PR1213.2
  BOTTOM w0.254: v2(35.88,96.73) 36.05,96.73 36.41,97.08 36.41,101.56 33.78,104.18 33.78,107.94 36.1,110.25 v3(36.54,110.25) 40.01,110.25 40.12,110.37 47.12,110.37 47.71,109.77 53.01,109.77 54.99,107.79 55.35,107.79 58.62,104.52 58.62,102.4 59.36,101.66 59.36,100.72 57.67,99.03 56.16,99.03 v2(55.76,98.62)
N36255106: length 1.1
  TOP w0.254: PQ1201.5 39.29,96.73 PR1220.2
N36307052: length 9.9
  TOP w0.076: UT5.F10 28.01,59.06 28.01,57.97 27.68,57.65
  TOP w0.102: v1(29.48,52.99) 28.07,52.99 27.48,53.57 RT97.2
  TOP w0.112: RT98.1 26.44,53.42 27.28,53.42 RT97.2 RT99.1 27.48,54.53 27.28,54.73 27.28,57.24 27.68,57.65
N36307117: length 5.4
  TOP w0.076: UT5.G4 27.76,62.71 v2(27.68,62.79)
  BOTTOM w0.102: RT85.1 v3(25.15,65.2) 25.15,64.79 26.72,63.21 27.26,63.21 v2(27.68,62.79)
N36307119: length 5.3
  TOP w0.076: UT5.F4 v2(28.26,62.79)
  BOTTOM w0.102: v2(28.26,62.79) 27.37,63.68 v3(26.71,63.68) 26.04,64.36 RT84.1
N36307669: length 3
  TOP w0.076: 28.55,64.84 28.55,64.69 28.46,64.6 28.46,64.01 UT5.F1
  TOP w0.102: 28.55,64.91 28.55,64.84
  TOP w0.112: 28.55,64.91 28.55,65.73 28.87,66.05 28.87,66.16 RT63.1
N36307918: length 3.2
  TOP w0.076: UT5.K10 26.01,59.06 25.65,59.06 24.78,58.19 24.73,58.19
  TOP w0.102: 24.73,58.19 24.69,58.15
  TOP w0.112: RT105.1 24.35,57.82 24.69,58.15
N36307920: length 3
  TOP w0.076: 24.83,59.1 25.18,59.45 25.46,59.45 25.56,59.56 26.01,59.56 UT5.K9
  TOP w0.112: 24.83,59.1 23.84,59.1 RT104.1
N36307926: length 3.1
  TOP w0.076: 24.76,57.89 25.67,58.81 UT5.L11
  TOP w0.102: 24.76,57.89 24.71,57.84
  TOP w0.112: 24.71,57.84 24.28,57.42 24.28,57.12 24.11,56.94 RT103.1
N36626863: length 2.5
  TOP w0.102: RT111.2 20.06,95.14 20.06,95.8
  TOP w0.104: RT111.2 19.84,93.91 CT90.1 ; UT7.3 20.06,95.8
N36736352: length 1.1
  BOTTOM w0.102: T220.1 25.15,67.74 RT85.2
N36736355: length 0.9
  BOTTOM w0.102: RT84.2 26.04,68.13 T219.1
N36827741: length 54.5
  TOP w0.102: UZ34.4 189.06,50.73 190.27,49.51 v1(190.27,45.09) 190.27,41.72 189.29,40.74 188.02,40.74 187.66,40.37 187.66,39.28 188.29,38.65 188.29,37.61 191.48,34.42 191.48,33.68 191.81,33.34 v2(191.81,31.46) ; RZ120.2 181.42,47.26 181.42,43.95 UZ26.4 181.92,43.53 182.79,42.66 182.79,37.06 184.26,35.6 184.26,29.73 v2(183.67,29.14)
  IN1 w0.102: v2(183.67,29.14) 183.73,29.08 190.76,29.08 191.81,30.13 v2(191.81,31.46)
N38312012: length 2.2
  TOP w0.076: v2(26.79,61.07) 27,61.07 UT5.H7
  BOTTOM w0.102: v3(27.38,60.66) 26.98,61.07 v2(26.79,61.07)
  BOTTOM w0.112: v2(26.79,61.07) 26.29,61.07 CT87.1
N38327809: length 4.4
  TOP w0.076: UT5.D6 29.6,61.65 v2(29.73,61.65)
  BOTTOM w0.102: RT101.1 32.79,61.03 v1(31.94,61.03) 30.36,61.03 v2(29.73,61.65)
N39317125: length 3.5
  BOTTOM w0.102: PR423.1 167.86,110.1 v3(167.71,110.25)
  BOTTOM w0.254: PR423.1 168.7,110.12 PR424.1 169.99,110.12 170.5,110.62 PU402.5
N40478997: length 1.6
  TOP w0.102: QV4.2 18.03,71.47 RV18.2
N41228182: length 2.9
  TOP w0.102: v2(267.9,67.34) 267.97,67.26 RZ326.1
  BOTTOM w0.102: v2(267.9,67.34) 267.95,67.28 JNGFF2.17
N41307615: length 2
  BOTTOM w0.102: CZ38.2 305.05,42.69 RZ334.1 305.44,43.58 v3(305.92,43.1)
N44311288: length 3.5
  BOTTOM w0.102: v3(239.96,35.21) 240.17,35.42 RE70.1 241.09,36.24 RE90.2 241.84,36.23 QE11.3
N44311298: length 2.5
  BOTTOM w0.102: v3(238.15,37.65) 239.04,37.65 QE4.2 239.35,36.33 RE70.2
N44311418: length 58.9
  TOP w0.102: QE13.1 v2(255.93,83.18) ; v2(243.27,44.96) 242.58,44.96 242.11,44.49 242.11,40.14 241.89,39.91 UE7.3 240.7,39.91 240.63,39.85 RE348.1 239.31,39.85 RE34.2 239.16,39.69 v3(238.27,39.69) 238.05,39.91 RE537.2 RE536.1
  IN3 w0.102: v2(243.27,44.96) 243.69,44.54 244.07,44.54 252.86,53.33 252.86,53.65 v2(255.73,56.52)
  BOTTOM w0.102: v2(255.73,56.52) 255.73,61.05 257.88,63.2 257.88,75.33 255.93,77.27 v2(255.93,83.18)
N44311425: length 2.3
  TOP w0.102: v3(245.87,40.28) 245.51,39.91 CE5.1 244.94,39.91 UE7.4
N44321668: length 7.2
  TOP w0.102: 261.98,32.42 261.8,32.24 RE57.1 261.37,33.09 260.94,33.52 RE58.1
  TOP w0.107: UE1.B1 263.22,36.68 262.25,35.71 262.25,32.69 261.98,32.42
N44321726: length 10.3
  TOP w0.102: RE318.1 267.64,28.36 267.64,30.35 267.88,30.59 267.88,31.36 267.82,31.43 267.82,31.84 268.23,32.25 v3(268.23,32.33) 268.23,32.35 267.67,32.91 267.67,34.49 267.37,34.79 267.37,35.63 267.62,35.87 267.62,37.19 UE1.G2
N44321827: length 5.8
  TOP w0.107: UE1.N4 272.07,39.23 277.79,39.23 RE349.2
N44321953: length 3.1
  TOP w0.102: CE57.1 253.07,39.25 RE350.2 254.49,39.73 v3(254.49,41.17)
N44683730: length 2.2
  TOP w0.102: UZ8.3 167.11,64.63 CZ197.1 167.26,63.62 RZ345.2
N44957960: length 3.3
  TOP w0.102: T225.1 279.67,63.71 v2(279.31,64.07)
  BOTTOM w0.102: JNGFF2.59 278.45,64.46 278.84,64.07 v2(279.31,64.07)
N45096894: length 2.3
  BOTTOM w0.102: v3(226.01,37.19) RE375.1 226.91,37.22 JESPI.8
N45586607: length 3.3
  TOP w0.102: QZ3.1 311.82,7.49 RZ25.1 310.44,7.49 v3(309.84,6.89)
N45640623: length 1
  TOP w0.102: RE14.1 v3(279.77,56.57)
N45640625: length 3.5
  TOP w0.254: RE15.2 RE16.1 v3(277.57,57.88) 277.4,57.71 UE2.2
N45640715: length 4
  TOP w0.254: UE2.3 277.01,58.21 277.41,58.6 277.41,59.19 v3(277.5,59.28) 277.93,59.71 RE17.2 278.51,60.57 RE18.1
N46646690: length 1
  BOTTOM w0.102: RZ63.1 174.89,87.53 CZ56.1
N46646814: length 2.5
  BOTTOM w0.102: UZ12.29 169.36,81.06 169.04,80.74 RZ112.2 RZ362.2
N46646843: length 3.4
  BOTTOM w0.102: v3(172.38,80.68) 172.29,80.77 171.68,80.77 171.22,80.31 RZ62.1 170.36,80.83 UZ12.27
N46647029: length 3.5
  BOTTOM w0.102: RZ113.2 162.23,84.8 QZ9.2 v3(160.63,83.43)
N46748110: length 11.2
  TOP w0.102: v3(274.17,65.89) 274.13,65.84 RZ131.2 274.43,64.85 v2(274.84,64.44)
  IN1 w0.102: v2(274.84,64.44) 275.02,64.62 275.02,71.55 v2(275.34,71.87)
  BOTTOM w0.102: v2(275.34,71.87) 275.7,72.23 JNGFF2.48
N46748113: length 11.6
  TOP w0.102: v2(275.4,64.39) 275.63,64.16 RZ132.2 276.3,64.36 v3(277.33,64.36)
  IN1 w0.102: v2(275.4,64.39) 275.22,64.57 275.22,71.19 v2(275.89,71.86)
  BOTTOM w0.102: JNGFF2.50 276.2,72.16 v2(275.89,71.86)
N46916972: length 2.9
  TOP w0.102: QE12.1 255.01,38 v3(255.84,38.83) 255.84,39.55 RE94.1
N47676492: length 4
  TOP w0.102: v3(255.43,85.08) QE13.6 258.3,83.78 QE13.3
N119328643: length 5.6
  BOTTOM w0.203: PU901.25 60.17,94.23 59.46,94.94 v1(58.24,94.94) 57.94,95.24 57.01,95.24 PR931.2
  BOTTOM w0.254: PR930.1 56.94,96.2 PC938.1 56.95,95.3 PR931.2
N131988242: length 3.3
  TOP w0.254: v2(58.39,92.57) 58.39,92.88 58.12,93.16 57.47,93.16 57,92.69 PR920.2
  BOTTOM w0.203: v2(58.39,92.57) 58.73,92.57 59.08,92.22 PU901.21
N131988252: length 3
  TOP w0.254: v2(57.67,93.69) 57.55,93.57 PR922.2
  BOTTOM w0.203: v2(57.67,93.69) 57.67,93.68 v3(58.24,93.11) 58.62,93.11 59.12,92.62 PU901.22
N132000604: length 2.4
  BOTTOM w0.102: v3(66.74,88.08) 67.03,88.37 67.03,89.33 66.88,89.48 PR921.2
N132005053: length 202.2
  TOP w0.254: v2(89.15,95.48) 89.02,95.6 89.02,98.39 93.42,102.79 97.1,102.79 98.4,104.08 99.78,104.08 101.99,106.3 105.14,106.3 106.32,107.47 117.79,107.47 119.19,108.87 126.82,108.87 127.41,109.47 127.41,109.47 128.65,110.71 129.61,110.71 131.11,109.21 131.17,109.21 131.2,109.18 133.61,109.18 135.03,110.6 153.36,110.6 158.55,105.41 158.55,101.16 159.88,99.84 167.16,99.84 167.64,100.32 168.98,100.32 169.92,99.38 170.59,99.38 171.36,99.38 v1(171.83,98.9) 173.79,96.95 173.79,93.94 173.57,93.72 173.57,89.71 175.67,87.61 176.71,87.61 176.82,87.5 179.14,87.5 184.27,82.37 184.27,74.56 185.15,73.68 185.15,72.03 186.25,70.93 186.25,69.35 194.28,61.32 194.28,55.56 203.79,46.05 203.79,42.38 v2(204.68,41.49)
  BOTTOM w0.254: v2(204.68,41.49) 204.85,41.32 PR917.3 ; v2(89.15,95.48) 89.15,94.65 88.86,94.36 85.56,94.36 85.33,94.59 82.64,94.59 81.44,93.39 81.44,92.72 80.29,91.57 79.24,91.57 79.07,91.73 78.95,91.86 78.95,92.08 78.95,92.76 78.84,92.87 78.84,92.88 78.3,93.41 78.01,93.41 74.7,93.41 73.15,94.96 72.45,94.96 71.66,95.76 70.78,95.76 70.08,96.46 67.67,96.46 66.85,97.28 PR938.2
N482247290: length 3.2
  BOTTOM w0.203: PR932.1 58.93,96 59.34,95.6 59.87,95.6 60.97,94.5 PU901.27

## Copper pours and planes (outline as drawn)
1.8V_PRIM_PWRGD on BOTTOM (solid shape): 169.2,101.68 169.2,101.09 169.11,101 168.45,101 168.35,101.1 167.36,101.1 167.22,101.24 167.22,101.69 167.35,101.82 169.06,101.82
2.5VSP on TOP (solid shape): 196.02,26.39 196.02,24.02 195.82,23.82 195.75,23.83 195.26,23.83 195.21,23.82 195.15,23.81 195.1,23.81 194.52,23.23 194.45,23.23 194.43,23.21 192.74,23.21 192.74,23.21 192.74,25.23 192.81,25.3 193.17,25.3 193.2,25.27 193.2,24.76 193.22,24.74 193.62,24.74 193.65,24.76 193.65,25.3 194.23,25.3 194.74,25.8 194.74,26.46 194.9,26.62 195.78,26.62
3V_SN on TOP (solid shape): 232.67,25.98 232.67,24.22 232.16,23.72 230.46,23.72 229.69,24.48 229.69,26.33 229.77,26.41 232.23,26.41
3V_VIN on BOTTOM (solid shape): 236.89,31.35 236.89,30.81 236.9,30.8 237.37,30.8 237.4,30.83 237.4,31.34 237.42,31.36 238.11,31.36 238.48,30.99 238.48,30.49 238.72,30.25 240.34,30.25 240.43,30.16 240.43,28.73 240.24,28.54 238.83,28.54 238.68,28.39 236.19,28.39 235.83,28.03 235.79,28.02 235.76,28.01 235.68,28.01 235.67,27.99 234.13,27.99 234.04,28.08 234.04,31.12 234.28,31.36 236.05,31.36 236.09,31.33 236.09,30.82 236.11,30.79 236.56,30.79 236.6,30.83 236.6,31.34 236.62,31.37 236.87,31.37
5V_SN on TOP (solid shape): 37.36,47.96 37.36,46.98 37.16,46.79 34.55,46.79 34.29,47.04 34.29,48.06 34.42,48.19 37.13,48.19
5V_VIN on TOP (solid shape): 38.5,45.69 38.5,44.54 38.92,44.12 39.02,44.02 39.02,41.79 38.95,41.73 36.66,41.73 36.58,41.81 36.58,43.41 36.74,43.58 36.74,44.81 37.77,45.84 38.35,45.84
5V_VIN on BOTTOM (solid shape): 37.72,46.21 38.38,46.21 38.5,46.09 38.5,44.98 39.53,43.94 39.53,43.6 39,43.6 39,43.09 39.53,43.09 39.53,42.8 39,42.8 39,42.29 39.53,42.29 39.53,41.91 39.45,41.83 37.17,41.83 36.69,41.83 36.64,41.87 36.64,43.38 36.92,43.65 36.92,44.31 36.64,44.59 36.32,44.9 36.32,46.5 36.41,46.58 37.35,46.58
+0.6V_DDR_VTT on TOP (solid shape): 121.73,29.8 121.73,27.16 121.16,26.59 116.59,26.59 115.78,27.4 115.78,30.17 115.9,30.3 121.24,30.3
+0.6V_DDR_VTT on TOP (solid shape): 192.85,29.83 192.85,26.21 192.44,25.79 190.96,25.79 190.74,26.01 190.74,26.77 191.48,27.51 191.48,28.01 191.48,28.01 191.48,28.82 191.51,28.87 191.53,28.92 191.73,29.13 191.73,29.31 192.35,29.92 192.37,29.91 192.49,29.91 192.61,29.95 192.62,29.95 192.73,29.95
+0.6V_DDR_VTT on BOTTOM (solid shape): 118.65,28.07 118.65,27.46 113.95,22.76 112.59,22.76 112.41,22.94 112.41,25.7 112.5,25.79 112.64,25.79 112.73,25.71 112.73,23.87 112.83,23.76 113.27,23.76 117.74,28.23 118.49,28.23
+0.6V_DDR_VTT on BOTTOM (solid shape): 40.15,36.7 40.15,34.81 40.08,34.75 39.35,34.75 39.28,34.81 39.28,36.03 39.28,36.03 38.89,36.03 38.71,36.21 38.71,36.64 38.82,36.75 38.84,36.74 38.89,36.73 38.94,36.73 39.12,36.73 39.28,36.82 40.02,36.82
+0.6V_DDR_VTT on IN1 (solid shape): 119.16,28.13 119.16,27.28 119.08,27.2 117.56,27.2 117.41,27.36 117.41,28.13 117.58,28.3 118.98,28.3
+0.6V_DDR_VTT on IN1 (solid shape): 191.83,27.46 191.83,26.49 191.69,26.35 190.8,26.35 189.81,27.34 184.05,27.34 183.96,27.44 183.96,28.37 184.13,28.54 190.75,28.54
+0.6V_DDR_VTT on IN3 (solid shape): 119.16,28.4 119.16,27.23 118.87,26.94 117.02,26.94 116.8,27.16 116.8,28.52 117,28.72 118.85,28.72
+0.6V_DDR_VTT on IN3 (solid shape): 38.81,37.36 39.03,36.72 39.25,37.36 39.7,37.36 39.7,37.36 40.52,37.36 41.02,36.85 41.02,34.51 40.69,34.18 40.28,34.18 38.33,36.13 38.33,37.07 38.63,37.36
+0.6VSP on BOTTOM (solid shape): 39.14,35.84 39.14,35.57 38.6,35.57 38.6,35.13 39.14,35.13 39.14,34.7 38.57,34.13 38.57,33.22 38.53,33.18 37.62,33.18 37.54,33.26 37.54,33.98 37.31,34.2 36.57,34.2 36.51,34.26 36.51,34.84 36.58,34.91 38.04,34.91 38.23,35.1 38.23,35.83 38.25,35.86 39.12,35.86
+0.9V_LAN on TOP (solid shape): 271.02,92.8 271.02,92.68 270.89,92.55 270.26,92.55 270,92.3 270,91.79 269.75,91.53 267.85,91.53 267.72,91.66 267.72,92.55 268.17,93 270.82,93
+0.9V_LAN on TOP (solid shape): 275.72,90.03 275.75,90.08 275.81,90.07 276.35,89.53 276.33,89.49 276.3,89.34 276.35,89.19 276.35,89.17 276.35,89.07 276.34,89.07 276.34,88.52 276.44,88.52 276.58,88.37 276.58,87.77 276.51,87.66 276.48,87.53 276.48,87.02 276.37,86.91 276.37,85.71 276.25,85.59 275.55,85.59 275.23,85.9 275.23,89.53 275.72,90.01
+0.9V_LAN on BOTTOM (solid shape): outline of 404 points within 267.59,87.98 281.18,98.01
+0.9V_TBT_CIO on TOP (solid shape): 30.53,86.37 30.53,85.21 30.7,85.05 30.72,85.02 30.79,84.96 30.79,84.74 30.74,84.71 30.7,84.67 30.67,84.63 30.66,84.56 30.63,84.54 30.47,84.53 30.33,84.44 30.28,84.4 30.18,84.4 30.1,84.48 30.1,84.53 30.12,84.59 30.16,84.65 30.24,84.86 30.16,85.07 30.13,85.11 29.71,85.53 29.71,85.64 29.81,85.83 29.71,86.02 29.67,86.06 29.67,86.25 29.71,86.29 29.76,86.34 29.81,86.46 29.96,86.6 30.3,86.6
+0.9V_TBT_DP on TOP (solid shape): 29.35,84.55 29.35,84.53 29.39,84.4 29.5,84.32 29.52,84.31 29.52,84.13 29.42,84.04 29.4,84.02 29.08,83.7 28.94,83.7 28.74,83.89 28.47,83.89 28.32,83.74 28.24,83.74 28.19,83.79 28.15,83.82 27.92,84.05 27.92,84.38 28.18,84.64 29.26,84.64
+0.9V_TBT_DP on TOP (solid shape): 31.6,87.24 31.64,87.21 31.68,87.08 31.61,87.02 31.53,86.94 31.53,86.81 31.53,86.69 31.64,86.55 31.55,86.46 31.43,86.17 31.54,85.86 31.55,85.83 31.54,85.8 31.51,85.77 31.48,85.75 31.44,85.76 31.16,85.85 30.92,85.68 30.91,85.66 30.79,85.66 30.66,85.78 30.66,86.6 30.98,86.92 30.99,86.93 31.04,86.97 31.09,87.03 31.09,87.04 31.13,87.07 31.3,87.07 31.46,87.24
+0.9V_TBT_DP on BOTTOM (solid shape): 33.71,87.92 33.71,86.61 33.43,86.33 32.87,86.33 32.67,86.53 31.63,86.53 31.47,86.38 31.47,86.05 31.35,85.92 30.99,85.92 30.86,86.05 30.86,86.94 31.09,87.17 31.36,87.17 31.54,87.34 31.54,87.74 31.55,87.75 32.74,87.75 32.97,87.98 33.64,87.98
+0.9V_TBT_DP on IN1 (solid shape): outline of 439 points within 27.42,83.31 31.54,87.87
+0.9V_TBT_LVR_OUT on TOP (solid shape): 22.14,92.55 24.5,92.55 24.62,92.43 24.66,92.4 24.77,92.3 24.77,92.04 24.64,91.92 23.88,91.92 23.64,91.68 23.19,91.68 23.05,91.81 22.47,91.81 22.33,91.68 21.73,91.68 20.96,92.45 20.96,92.92 21.09,93.05 21.64,93.05
+0.9V_TBT_LVR_OUT on TOP (solid shape): 27.44,86.35 27.63,86.25 27.82,86.35 28.06,86.35 28.18,86.23 28.18,86.04 28.12,85.99 28.07,85.93 27.98,85.84 27.96,85.84 27.82,85.81 27.7,85.72 27.58,85.6 27.58,85.46 27.42,85.29 27.24,85.29 27.06,85.47 27.06,85.63 26.85,85.85 26.85,86.1 27,86.25 27.06,86.27 27.12,86.3 27.17,86.35
+0.9V_TBT_LVR_OUT on BOTTOM (solid shape): 24.8,92.43 24.8,92.12 25.27,91.64 25.27,91.08 25.16,90.96 24.85,90.96 23.6,92.22 23.6,92.57 23.94,92.91 24.33,92.91
+0.9V_TBT_LVR_OUT on IN3 (solid shape): outline of 677 points within 23.62,84.93 30.61,93.06
+0.9V_TBT_PCIE on TOP (solid shape): 29.67,89.82 29.71,89.79 29.71,89.02 29.65,88.96 29.14,88.45 29.14,87.76 29.11,87.75 28.93,87.46 29.09,87.17 29.1,87.11 29.07,87.05 29.01,86.99 28.61,86.99 28.54,87.02 28.51,87.09 28.5,87.21 28.44,87.3 28.44,87.61 28.51,87.78 28.44,87.95 28.44,88 28.37,88.07 28.34,88.15 28.39,88.23 28.5,88.37 28.48,88.55 28.43,88.61 28.35,88.65 28.29,88.71 28.27,88.87 28.18,89 28.18,89.16 28.29,89.41 28.18,89.65 28.18,89.81 28.22,89.85 28.33,89.85 28.38,89.79 28.45,89.74 28.55,89.65 28.68,89.65 28.84,89.49 29.03,89.49 29.18,89.63 29.3,89.64 29.33,89.64 29.56,89.87 29.63,89.87
+0.9V_TBT_PCIE on BOTTOM (solid shape): 29.84,91.9 29.84,90.45 29.72,90.33 29.68,90.29 29.55,90.15 29.55,88.96 28.94,88.36 28.94,87.56 28.93,87.47 28.93,87.39 28.94,87.36 28.81,87.23 28.43,87.23 28.33,87.33 28.33,89.5 28.51,89.68 28.83,89.68 29.02,89.87 29.02,90.25 28.83,90.44 28.4,90.44 28.33,90.5 28.33,91.93 28.34,91.94 29.8,91.94
+0.9V_TBT_PCIE on IN1 (solid shape): 30.04,92.3 30.24,92.08 30.54,92.1 30.57,92.12 30.73,91.96 30.73,91.12 30.7,91.04 30.61,91.02 30.25,90.84 30.33,90.45 30.36,90.37 30.33,90.3 30.31,90.27 30.23,90.24 30.16,90.27 29.58,90.06 30.16,89.84 30.23,89.87 30.31,89.84 30.45,89.74 30.61,89.73 30.69,89.71 30.73,89.63 30.73,89.18 30.69,89.1 30.61,89.08 30.45,89.07 30.31,88.97 30.23,88.94 30.16,88.97 29.61,88.9 29.88,88.43 29.97,88.36 29.94,88.25 29.43,87.74 29.4,87.75 29.02,87.69 28.96,87.32 28.97,87.28 28.95,87.26 28.95,87.22 28.37,87.22 28.29,87.26 28.27,87.35 28.28,87.54 28.18,87.7 28.14,87.78 28.29,88.11 28.14,88.43 28.29,88.76 28.14,89.08 28.29,89.41 28.14,89.73 28.18,89.81 28.21,89.84 28.28,89.87 28.36,89.84 28.94,90.06 28.36,90.27 28.28,90.24 28.21,90.27 28.03,90.38 27.82,90.36 27.73,90.37 27.68,90.45 27.68,91.33 28.7,92.34 30.03,92.34
+0.9V_TBT_SVR on TOP (solid shape): 28.16,85.62 28.2,85.55 28.33,85.55 28.5,85.73 28.72,85.73 28.83,85.63 28.96,85.6 28.99,85.61 29.07,85.53 29.07,85.08 29.01,85.02 27.61,85.02 27.51,85.12 27.51,85.22 27.69,85.4 27.69,85.55 27.84,85.7 27.9,85.73 27.96,85.73 28.03,85.73 28.04,85.74
+0.9V_TBT_SVR on TOP (solid shape): 26.14,88.3 26.22,88.23 26.32,88.2 26.34,88.2 26.53,88 26.53,85.85 26.45,85.76 26.4,85.72 26.26,85.72 26.13,85.81 25.97,85.83 25.95,85.83 25.91,85.86 25.9,85.91 25.89,85.94 25.81,86.02 25.7,86.06 25.68,86.06 25.52,86.23 25.52,86.51 25.69,86.78 25.56,87.07 25.56,87.18 25.62,87.23 25.67,87.3 25.7,87.34 25.7,87.46 25.92,87.68 25.92,87.89 25.78,88.03 25.78,88.22 25.83,88.25 25.89,88.32 26.13,88.32
+0.9V_TBT_SVR on TOP (solid shape): outline of 90 points within 15.72,75.91 20.34,78.98
+0.9V_TBT_SVR on BOTTOM (solid shape): outline of 173 points within 17.27,76.14 27.05,88.33
+0.9V_TBT_SVR on IN2 (solid shape): 18.92,79 18.97,79.01 19,78.97 19,77.02 17.98,76 17.73,76 17.38,76.34 17.38,76.88 17.41,76.89 17.62,77.2 17.41,77.5 17.38,77.52 17.38,78.24 17.41,78.26 17.57,78.42 17.59,78.64 17.59,78.67 17.86,78.94 18.86,78.94
+0.9V_TBT_SVR on IN2 (solid shape): outline of 527 points within 19.13,76 28.84,89.4
+1.0V_APLL on IN1 (solid shape): outline of 305 points within 137.34,79.17 143.76,81.97
+1.0V_CLK2 on TOP (solid shape): 135.85,86.54 135.85,86.44 135.82,86.39 135.67,86.14 135.77,85.87 135.8,85.8 135.77,85.72 135.67,85.47 135.79,85.22 135.83,85.16 135.81,85.09 135.8,85.07 135.75,84.86 135.85,84.66 135.85,84.49 135.67,84.19 135.85,83.9 135.85,83.76 135.38,83.28 135.26,83.28 135.26,83.28 134.9,83.28 134.75,83.43 134.75,83.72 134.75,83.72 134.56,83.91 134.56,83.98 134.75,84.17 134.75,84.11 134.94,83.92 134.97,83.92 135,83.91 135.41,84.04 135.36,84.46 135.32,84.54 135.36,84.61 135.46,84.87 135.32,85.12 135.28,85.2 135.31,85.28 135.4,85.53 135.26,85.77 135.22,85.84 135.26,85.92 135.02,86.5 134.84,85.9 134.88,85.83 134.84,85.75 134.74,85.48 134.88,85.23 134.92,85.16 134.89,85.08 134.85,85.02 134.82,84.95 134.75,84.88 134.66,84.9 134.62,84.92 134.58,84.95 134.58,85.06 134.46,85.18 134.43,85.25 134.47,85.33 134.57,85.66 134.32,85.9 134.28,85.91 134.28,86.54 134.47,86.73 135.66,86.73
+1.0V_CLK4 on IN1 (solid shape): outline of 216 points within 132.63,80.87 137.14,83.9
+1.0V_MPHYAON on TOP (solid shape): outline of 668 points within 137.35,83.31 140.36,100.75
+1.0V_MPHYAON on BOTTOM (solid shape): 140.36,101.01 140.36,100.13 140.24,100.01 139.56,100.01 139.22,99.66 137.6,99.66 137.47,99.79 137.47,100.59 137.72,100.84 138.08,100.84 138.39,101.14 140.23,101.14
+1.0V_MPHYGT on TOP (solid shape): 144.81,100.45 146.94,100.45 147.17,100.22 147.2,100.18 147.24,100.15 147.45,99.94 147.45,99.03 147.39,98.97 145.16,98.97 144.88,98.7 144.88,97.86 144.71,97.68 143.37,97.68 143.12,97.93 143.12,100.27 143.31,100.46 144.8,100.46
+1.0V_MPHYGT on TOP (solid shape): 167.06,90.24 167.06,89.42 167.35,89.13 167.35,88.16 167.27,88.08 166.15,88.08 165.99,88.25 165.99,89.34 165.96,89.37 165.96,90.34 165.66,90.64 164.57,90.64 164.29,90.92 164.29,91.3 164.47,91.48 165.82,91.48
+1.0V_MPHYGT on TOP (solid shape): 137.97,82.17 137.97,81.48 137.92,81.39 137.82,81.39 137.42,81.33 137.36,80.94 137.36,80.84 137.27,80.79 136.95,80.79 136.82,80.67 136.82,80.16 136.69,80.03 136.19,80.03 136.13,80.09 136.13,81.26 136.38,81.51 136.58,81.51 136.8,81.72 136.8,82.11 136.97,82.29 137.86,82.29
+1.0V_MPHYGT on BOTTOM (solid shape): 145.9,104.86 145.9,101.96 145.24,101.3 145.24,99.46 144.96,99.19 144.96,98.94 144.94,98.93 144.94,97.87 144.79,97.72 143.15,97.72 143.06,97.8 143.06,98.12 143.13,98.18 143.13,98.18 143.13,100.32 143.27,100.46 143.27,104.79 143.44,104.96 145.8,104.96
+1.0V_MPHYGT on BOTTOM (solid shape): 150.12,90.05 150.12,88.34 149.87,88.09 146.67,88.09 145.88,88.88 145.88,89.3 145.75,89.43 145.75,89.76 145.84,89.85 146.04,89.85 146.05,89.85 146.28,89.85 146.47,89.96 146.75,90.24 149.93,90.24
+1.0V_MPHYGT on IN2 (solid shape): outline of 314 points within 148.98,83.47 166.46,91.27
+1.0V_MPHYGT on IN2 (solid shape): outline of 2140 points within 135.91,79.32 146.89,98.8
+1.0V_PRIM on TOP (solid shape): outline of 408 points within 129.57,93.19 152.02,105.06
+1.0V_PRIM on BOTTOM (solid shape): 180.15,97.05 180.15,96.08 179.62,96.08 179.62,95.38 180.15,95.38 180.15,94.88 179.62,94.88 179.62,94.18 180.15,94.18 180.15,93.62 180.08,93.55 177.54,93.55 177.22,93.87 177.22,97.07 177.4,97.25 179.95,97.25
+1.0V_PRIM on BOTTOM (solid shape): outline of 120 points within 128.65,99.67 142.57,107.92
+1.0V_PRIM on IN1 (solid shape): outline of 147 points within 133.03,73.3 136.04,78.89
+1.0V_PRIM on IN3 (solid shape): 150.22,95.42 150.22,94.65 149.69,94.12 148.68,94.12 148.51,94.28 148.51,95.67 148.64,95.8 149.84,95.8
+1.0V_PRIM on IN3 (solid shape): outline of 147 points within 133.4,76.65 136.42,79.21
+1.0V_PRIM on VCC: 132.46,101.21 136.25,105 146.33,105 147.72,103.6 149.71,103.6 150.37,104.26 150.37,107.03 161.31,107.03 166.9,101.44 171.43,101.44 172.09,102.1 172.09,104.47 169.67,106.88 169.67,108.55 177.04,108.55 177.04,99.18 179.2,97.02 179.2,94.18 177.57,92.55 146.71,92.55 139.45,85.29 139.45,84.53 137.54,82.62 137.54,75.64 137.31,75.41 135.53,75.41 134.24,74.11 134.24,73.48 134.14,73.37 132.46,73.37
+1.0V_PRIM_CORE on BOTTOM (solid shape): 133.2,80.08 133.2,79.78 133.25,79.72 133.26,79.72 133.31,79.64 133.38,79.59 133.39,79.59 133.49,79.49 133.48,79.46 133.68,79.1 134.07,79.21 134.18,79.21 134.31,79.08 134.31,78.83 134.23,78.75 134.18,78.69 133.95,78.45 133.34,78.45 133.1,78.21 132.61,78.21 132.52,78.28 132.52,80.07 132.7,80.25 133.02,80.25
+1.0V_PRIM_CORE on BOTTOM (solid shape): 174.56,102.93 175.06,102.93 175.06,103.46 175.36,103.46 175.36,102.93 175.86,102.93 175.86,103.46 176.22,103.46 176.43,103.25 176.43,101.43 176.43,95.45 175.46,94.48 172.63,94.48 172.6,94.46 172.6,94.46 172.1,93.96 170.13,93.96 169.64,93.47 169.06,93.47 169.05,93.46 168.85,93.46 166.93,91.54 163.38,91.54 163.37,91.53 163.34,91.53 163.12,91.51 162.96,91.35 162.95,91.34 162.38,90.77 161.44,90.77 161,91.21 161,92.6 161.05,92.64 161.39,92.64 161.88,93.14 164.58,93.14 164.82,93.21 164.98,93.4 165.45,93.87 166.1,93.87 166.11,93.87 166.35,94 166.48,94.25 166.48,94.27 167.3,95.09 168.75,95.09 170.24,96.59 171.43,96.59 171.43,96.54 171.56,96.33 171.88,96.24 171.92,96.18 172.37,95.92 172.51,96.43 172.5,96.53 172.59,96.59 173.07,96.59 174.18,97.69 174.18,97.88 174.18,97.89 174.18,100.43 173.83,100.78 173.83,102.8 173.84,102.81 173.84,103.23 174.07,103.46 174.56,103.46
+1.0V_PRIM_CORE on IN2 (solid shape): outline of 1908 points within 130.64,78.18 163.1,103.06
+1.0V_PRIM_CORE on IN3 (solid shape): 132.67,80.1 133.23,80.1 133.3,80.03 133.3,79.59 133.39,79.49 133.39,79.32 133.3,79.22 133.3,78.16 133.2,78.06 133.18,78.06 132.83,77.78 133.07,77.41 133.11,77.4 133.11,76.99 133.62,76.49 135.17,76.49 135.4,76.26 135.4,76.02 134.14,76.02 134.14,76.07 133.81,76.38 133.48,76.07 133.48,76.02 132.73,76.02 132.37,76.37 132.37,76.39 132.32,76.53 132.23,76.65 132.23,80.13 132.37,80.27 132.5,80.27
+1.0V_PRIM_COREP on BOTTOM (solid shape): 174.5,109.7 174.5,105.29 174.93,104.86 176.24,104.86 176.39,104.7 176.39,103.75 176.24,103.6 175.73,103.6 175.73,103.06 175.49,103.06 175.49,103.59 174.94,103.59 174.94,103.06 174.69,103.06 174.69,103.6 171.41,103.6 170.83,104.18 170.83,106.64 171.33,107.13 173.27,107.13 173.78,107.64 173.78,108.77 173.05,109.49 173.05,110.15 173.17,110.27 173.93,110.27
+1.0V_SRAM on TOP (solid shape): 147.54,98.13 147.54,97.01 147.32,96.79 146.64,96.79 146.64,96.79 146.31,96.79 146.23,96.87 146.23,97.15 146.43,97.35 146.43,98.11 146.56,98.23 147.44,98.23
+1.0V_SRAM on IN2 (solid shape): outline of 1536 points within 133.57,75.36 148.81,97.5
+1.0V_VCCST on BOTTOM (solid shape): 108.27,97.87 108.27,96.81 108.05,96.59 108.05,96.07 107.9,95.92 107.37,95.92 107.28,95.83 107.28,94.13 107.15,94 105.74,94 105.69,93.95 105.26,93.95 105.16,94.05 105.16,94.58 105.37,94.8 106.4,94.8 106.5,94.9 106.5,96.56 106.73,96.79 106.73,97.76 106.96,97.99 108.16,97.99
+1.0V_VCCST on BOTTOM (solid shape): 130.23,110.47 130.23,109.22 129.95,108.93 129.14,108.93 129.08,108.98 129.08,109.49 129.03,109.54 128.63,109.54 128.6,109.52 128.6,109.01 128.55,108.96 128.12,108.96 127.89,109.19 127.89,109.98 127.9,109.99 127.9,110.33 128.17,110.61 130.09,110.61
+1.0V_VCCST on IN3 (solid shape): 129.92,110.33 129.92,109.89 129.73,109.7 128.53,109.7 128.4,109.82 128.4,110.33 128.53,110.46 129.8,110.46
+1.0V_VCCST_C on BOTTOM (solid shape): 128.93,109.34 128.93,108.86 128.96,108.83 129.26,108.83 129.42,108.68 129.42,108.04 129.16,107.79 129.16,106.01 128.91,105.76 128.27,105.76 128.15,105.89 127.76,105.89 127.51,106.14 127.51,107.79 127.76,108.04 127.76,108.68 127.89,108.81 128.68,108.81 128.75,108.88 128.75,109.34 128.78,109.37 128.91,109.37
+1.0V_VCCSTG on BOTTOM (solid shape): 133.48,97.54 133.48,95.72 132.47,94.71 132.47,93.13 131,91.66 130.19,91.66 129.61,92.25 129.61,95.65 130.38,96.42 130.38,97.99 130.38,97.99 133.03,97.99
