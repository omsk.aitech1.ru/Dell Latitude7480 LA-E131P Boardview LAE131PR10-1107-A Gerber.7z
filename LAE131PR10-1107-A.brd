# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N3_R: length 20.4
  BOTTOM w0.104: LI4.2 24.9,34.31 25.01,34.42 25.38,34.42 25.63,34.66 25.63,35.75 23.84,37.54 23.57,37.54 23.29,37.82 DI3.3 23.13,38.27 22.23,37.37 21.76,37.37 21.27,37.86 21.27,37.89 20.87,38.29 20.84,38.29 20.44,38.69 v4(20.44,39.78) 20.44,41.07 19.58,41.93 18.11,41.93 17.36,42.68 17.36,44.78 16.85,45.29 16.06,45.29 15.95,45.4 JUSB3.2
USB20_N4: length 151.3
  TOP w0.104: v2(263.48,57.07) 263.23,56.82 263.12,56.82 262.9,57.05 262.9,57.5 263.42,58.02 263.42,58.26 263.45,58.29 263.45,59.07 264.12,59.74 LI8.4 264.12,60.52 RI48.1
  IN1 w0.076: 149.91,72.74 149.89,72.74 149.87,72.71 148.93,72.71 148.3,72.09 145.82,72.09 143.51,74.4 143.44,74.4 140.55,74.4 140.13,74.82 140.13,75.75 140.27,75.89 v2(140.44,75.89)
  IN1 w0.119: v2(263.48,57.07) 263.48,57.02 263.29,56.83 262.9,56.83 262.66,56.58 262.66,55.44 262.23,55.01 260.68,55.01 260.14,55.56 259.43,55.56 258.74,54.87 252.15,54.87 244.66,47.38 242.31,47.38 241.05,46.12 232.01,46.12 231.82,46.32 230.72,46.32 227.31,46.32 208.39,46.32 206.62,48.09 205.35,48.09 199.01,54.43 198.62,54.43 193.22,59.83 191.15,59.83 188.88,62.09 182.24,62.09 181.59,61.45 181.31,61.45 181.3,61.46 180.73,61.46 180.72,61.45 178.58,61.45 178.1,61.93 177.29,61.93 176.72,61.36 175.39,61.36 174.09,62.66 174.09,65.23 169.67,69.65 167.51,69.65 165.26,71.9 163.83,71.9 163.48,72.26 160.61,72.26 159.86,71.51 159.25,71.51 158.92,71.84 154,71.84 153.19,72.65 153.12,72.65 153.03,72.74 149.91,72.74
  BOTTOM w0.076: UC1.AD9 140.44,75.97 v2(140.44,75.89)
USB20_N4_L: length 4.7
  TOP w0.104: RI48.2 264.16,61.94 LI8.3 264.12,62.37 263.78,62.71 263.78,63.07 v2(263.99,63.28)
  BOTTOM w0.104: v2(263.99,63.28) 263.8,63.47 263.8,64.78 263.95,64.93 JNGFF2.9
USB20_N5: length 166.1
  IN1 w0.076: v2(147.05,72.54) 146.9,72.69 146.9,73.38 147.3,73.78 149.73,73.78 149.78,73.83 149.88,73.83 149.9,73.81 149.91,73.81
  IN1 w0.119: v2(47.55,112.91) 47.43,112.79 47.43,112.62 47.55,112.5 53.76,112.5 56.01,114.75 70.61,114.75 72.8,112.57 89.02,112.57 91.25,114.79 103.44,114.79 104.79,116.14 124.22,116.14 126.04,114.33 143.56,114.33 157.08,100.81 157.08,95.56 160.13,92.51 160.13,87.29 159.05,86.21 159.05,77.97 156.75,75.67 155.92,75.67 154.06,73.81 149.91,73.81
  BOTTOM w0.076: v2(147.05,72.54) 147.05,72.64 146.79,72.91 146.32,72.91 146.09,73.13 145.71,73.13 145.68,73.1 145.59,73.1 UC1.AJ1
  BOTTOM w0.104: LZ1.4 50.63,111.92 50.48,111.78 50.48,111.62 50.39,111.52 48.19,111.52 47.3,112.41 47.3,112.66 v2(47.55,112.91)
USB20_N5_R: length 13.8
  BOTTOM w0.104: JEDP1.7 61.7,116.53 61.76,116.48 61.93,116.48 62,116.41 62,116.1 61.96,116.06 61.96,115.32 61.14,114.5 57.77,114.5 56.96,113.7 55.65,113.7 53.66,111.71 53.4,111.71 DV8.1 52.96,111.71 52.76,111.71 52.55,111.92 LZ1.3
USB20_N7: length 187.4
  IN3 w0.135: v2(152.06,72.04) 151.83,72.26 151.83,72.78 151.96,72.91 155.15,72.91 156.19,73.95 156.19,74.4 156.39,74.61 158.85,74.61 163.09,70.37 164.45,70.37 166.78,68.03 168.84,68.03 170.78,66.09 170.78,63.6 179.41,54.97 179.41,54.61 182.35,51.67 182.86,51.67 186.67,47.86 186.67,46.3 194.55,38.41 194.55,36.47 196.92,34.11 196.92,33.49 202.16,28.25 207.3,28.25 208.06,29.01 213.52,29.01 214.05,29.54 221,29.54 221.77,30.31 231.8,30.31 235.04,27.07 235.04,26.61 238.41,23.23 247.95,23.23 248.38,23.66 249.08,23.66 249.46,23.28 251.84,23.28 252.09,23.03 253.61,23.03 254.14,22.5 257,22.5 257.71,23.2 257.71,24.24 258.03,24.56 259.28,24.56 260.69,23.15 260.99,23.15 261.31,22.84 269.05,22.84 269.52,22.37 271.53,22.37 272.34,23.19 275.03,23.19 275.48,23.64 279.99,23.64 282.38,26.02 284.27,26.02 285.35,27.11 285.35,28.68 287.05,30.37 288.43,30.37 288.71,30.65 288.71,30.93 v2(288.95,31.17)
  BOTTOM w0.076: UC1.AH1 145.16,73.86 145.16,73.94 145.29,74.07 148.09,74.07 148.94,73.21 148.94,72.03 149.55,71.43 149.95,71.43 149.96,71.42
  BOTTOM w0.104: v2(288.95,31.17) 288.73,31.39 288.73,31.58 288.84,31.68 290.3,31.68 290.79,32.17 290.79,32.5 LI9.1 RI50.1 ; v2(152.06,72.04) 151.88,72.04 151.69,71.84 151.69,71.67 151.43,71.42 149.96,71.42
USB20_N7_L: length 4
  BOTTOM w0.104: JNGFF1.5 290.08,36.3 v4(290.51,35.87) 290.87,35.51 290.87,35.08 291.14,34.82 LI9.2 RI50.2
USB20_N8: length 122.2
  TOP w0.104: v2(91.49,113.26) 91.31,113.07 91.27,113.07 91.11,112.92 91.11,112.54 v4(90.75,112.17) 90.7,112.17 90.25,111.72 89.77,111.72 89.64,111.59 89.64,111.05 89.61,111.02 89.61,110.41 89.82,110.2 90.15,110.2 LV27.3
  IN1 w0.076: 149.91,74.46 149.61,74.46 149.44,74.29 148.79,74.29 148.74,74.24 148.3,74.24 148.25,74.29 145.7,74.29 144.71,75.28 141.14,75.28 141.01,75.14 141.01,75.08 v2(141.24,74.86)
  IN1 w0.119: v2(91.49,113.26) 91.29,113.05 91.29,112.9 91.48,112.71 91.78,112.71 93.2,114.13 103.81,114.13 105.18,115.5 123.85,115.5 125.76,113.59 143.39,113.59 156.44,100.54 156.44,94.61 159.49,91.56 159.49,87.55 157.5,85.56 157.5,77.32 156.5,76.33 155.66,76.33 153.79,74.46 149.91,74.46
  BOTTOM w0.076: UC1.AF8 141.49,75.1 v2(141.24,74.86)
USB20_N8_R: length 14.7
  TOP w0.104: LV27.4 91.25,109.1 91.25,108.81 91.69,108.37 92.17,108.37 v4(93.17,109.37) 93.34,109.54 93.34,111.28 93.23,111.39 DV4.2 92.27,111.97 v2(92.74,112.44)
  BOTTOM w0.104: v2(92.74,112.44) 92.96,112.23 92.96,112.05 93.25,111.76 93.91,111.76 94.22,112.07 94.22,114.51 93.85,114.88 93.85,116.09 94.04,116.28 JTS1.2
USB20_N10: length 164.5
  IN3 w0.135: v2(142.41,73.78) 142.37,73.81 142.37,74.03 142.5,74.16 144.42,74.16 144.97,73.6 153.95,73.6 155.64,75.29 159.13,75.29 163.37,71.05 164.86,71.05 167.2,68.71 169.12,68.71 171.46,66.37 171.46,63.89 180.09,55.27 180.09,54.91 182.64,52.35 183.14,52.35 187.38,48.12 187.38,46.79 187.38,46.59 195.28,38.69 195.28,36.71 197.6,34.39 197.6,33.97 202.62,28.95 206.92,28.95 207.65,29.69 213.24,29.69 213.78,30.23 220.69,30.23 221.46,31 232.16,31 235.87,27.28 235.87,27.01 238.15,24.72 249.18,24.72 249.69,24.22 253.5,24.22 254.53,23.18 255.7,23.18 256.84,24.31 256.84,24.43 257.66,25.26 259.59,25.26 260.81,24.03 268.99,24.03 269.96,23.05 271.25,23.05 271.52,23.32 271.52,23.49 v2(271.72,23.69)
  BOTTOM w0.076: v2(142.41,73.78) 142.19,73.78 142.13,73.87 142.13,74.22 UC1.AH7
  BOTTOM w0.104: JUSH1.8 271.65,25.08 271.5,24.93 271.5,23.92 v2(271.72,23.69)
USB20_P1: length 231.2
  TOP w0.104: v2(297.42,64.96) 297.32,64.86 297.32,64.84 297.2,64.71 297.07,64.71 296.84,64.49 296.84,64.01 296.57,63.75 295.26,63.75 293.76,65.25 292.29,65.25 292.26,65.28 291.69,65.28 291.66,65.25 291.33,65.25 290.96,65.63 290.96,67.94 291.28,68.26 292.14,68.26 292.47,68.58 292.55,68.58 292.78,68.35 UI3.3
  IN3 w0.135: v2(297.42,64.96) 297.32,64.86 296.79,64.86 296.56,64.62 296.56,63.6 296.96,63.19 296.96,60.35 297.38,59.93 297.38,56.61 296.53,55.76 296.53,54.4 294.63,52.5 293.66,52.5 285.17,44 285.17,31.35 283.13,29.31 283.13,28.38 282.54,27.79 281.85,27.79 278.85,24.79 269.56,24.79 269.4,24.95 261.19,24.95 259.97,26.18 254.97,26.18 254.61,25.82 247.31,25.82 246.8,26.33 241.56,26.33 240.41,27.48 237.44,27.48 232.24,32.68 220.62,32.68 219.96,32.02 214.82,32.02 214.54,32.3 201.59,32.3 199.94,33.95 199.94,35.34 189.07,46.21 189.07,47.73 184.41,52.39 184.41,52.76 182.88,54.29 182.37,54.29 172.39,64.27 172.39,67.59 166.51,73.47 166.51,75.41 165.17,76.75 164.5,76.75 162.85,78.4 155.45,78.4 154.94,77.89 149.19,77.89 148.64,77.34 147.29,77.34 147.09,77.14 146.12,77.14 145.91,77.35 142.58,77.35 142.38,77.35 142.15,77.58 141.92,77.68 141.53,77.68 141.31,77.9 140.8,77.9 140.5,77.6 v2(140.5,76.98)
  BOTTOM w0.076: UC1.AB10 v2(140.5,76.98)
USB20_P1_R: length 32.7
  TOP w0.104: LI7.3 299.88,68.21 300.14,68.47 300.75,68.47 301.8,69.52 v4(301.8,72.85) 301.8,74.03 303.1,75.33 304.02,75.33 DI5.3 304.99,74.53 304.99,75.46 305.12,75.59 305.4,75.59 305.69,75.3 305.75,75.3 305.85,75.2 305.85,72.67 304.47,71.3 304.47,67.49 304.78,67.18 305.11,67.18 v2(305.39,66.9)
  IN3 w0.135: v2(305.39,66.9) 305.28,66.9 305.04,67.14 304.85,67.14 304.65,66.95 304.65,66.15 306.29,64.51 306.29,64.06 308.64,61.72 309.58,61.72 JUSB1.3
USB20_P2: length 286.2
  IN1 w0.076: v2(141.78,75.89) 141.81,75.86 141.99,75.86 142.15,76.01 142.15,76.34 142.39,76.59 145.69,76.59 146.46,75.82 147.45,75.82 148.08,76.45 149.16,76.45 149.68,76.97 149.68,77 149.7,77.01
  IN1 w0.119: v2(22.93,19.16) 22.93,19.42 23.12,19.61 23.36,19.61 23.49,19.49 23.49,18.83 23.31,18.65 22.68,18.65 22.43,18.9 22.43,19.52 23.68,20.77 23.68,35.01 22.64,36.05 22.64,42.7 25.18,45.25 25.18,45.47 27.26,47.54 38.65,47.54 41.35,50.24 41.35,63.94 40.62,64.67 39.57,64.67 37.22,67.02 36.24,67.02 35.36,67.89 35.36,76.7 36.14,77.48 37.18,77.48 37.67,77.97 37.67,78.83 37.84,79 37.84,81.58 38.37,82.11 38.37,86.26 39.84,87.73 39.84,89.44 39.6,89.68 39.6,89.96 39.24,90.32 39.24,92.08 38.04,93.28 38.04,94.13 36.52,95.65 36.52,106.43 36.25,106.69 36.25,107.5 36.58,107.83 37.13,107.83 39.9,110.6 39.9,111.05 40.5,111.64 54.12,111.64 55.72,113.25 70.74,113.25 72.32,111.66 93.92,111.66 95.53,113.27 104.18,113.27 105.54,114.62 123.35,114.62 125.29,112.68 143.07,112.68 155.58,100.17 155.58,94.04 158.63,91 158.63,87.91 155.55,84.83 155.55,77.81 154.88,77.14 149.83,77.14 149.7,77.01
  BOTTOM w0.076: v2(141.78,75.89) 141.78,75.99 142.14,76.34 UC1.AD7
  BOTTOM w0.104: v2(22.93,19.16) 23.14,19.37 23.14,19.58 22.92,19.79 LI3.4
USB20_P2_R: length 13.4
  BOTTOM w0.104: 22.9,23.4 DI2.2 ; 22.9,23.4 22.9,23.96 23.03,24.09 23.31,24.09 23.82,23.58 23.82,22.54 23.13,21.85 23.13,21.4 LI3.3 ; 22.9,23.4 22.4,23.9 21.29,23.9 21.15,24.04 21.11,24.04 20.71,24.44 20.71,24.48 v4(19.98,25.21) 19.64,25.55 16.13,25.55 15.95,25.37 JUSB2.3
USB20_P3: length 278.8
  IN1 w0.076: v2(147.65,72.55) 147.85,72.75 147.93,72.75 148.02,72.84 148.02,73.38 148.25,73.61 149.29,73.61 149.53,73.37 149.87,73.37 149.89,73.39 149.91,73.39
  IN1 w0.119: 149.91,73.39 153.34,73.39 153.44,73.29 154.84,73.29 156.57,75.02 156.71,75.02 159.48,77.8 159.48,86.04 160.55,87.11 160.55,92.97 157.51,96.01 157.51,101.03 143.76,114.77 126.31,114.77 124.48,116.6 99.55,116.6 98.21,115.26 91.06,115.26 89.71,113.91 78.36,113.91 78.17,113.73 72.31,113.73 70.85,115.19 55.21,115.19 53.1,113.08 48.29,113.08 47.8,113.57 46.49,113.57 45.67,112.76 40.64,112.76 39.24,111.35 39.24,110.92 36.8,108.48 36.06,108.48 34.87,107.29 34.87,104.22 35.17,103.92 35.17,98.33 35.44,98.06 35.44,94.77 35.72,94.48 36.16,94.48 37.39,93.25 37.39,92.9 37.78,92.51 37.78,90.77 37.78,89.91 37.94,89.75 37.94,87.5 36.8,86.36 36.8,84.89 37.73,83.96 37.73,82.38 36.83,81.48 36.83,81.07 37.17,80.74 37.17,79.3 36.82,78.96 36.5,78.96 34.67,77.12 34.67,73.83 33.62,72.78 33.62,68.73 34.52,67.83 34.52,67.23 36.19,65.55 37.72,65.55 39.4,63.87 39.98,63.87 40.7,63.14 40.7,50.75 38.14,48.19 25.91,48.19 24.54,46.82 24.54,45.51 21.4,42.38 21.4,35.06 21.68,34.79 22.37,34.79 22.52,34.93 22.52,35.11 22.35,35.28 v2(22.16,35.28)
  BOTTOM w0.076: UC1.AJ3 144.18,73.17 144.02,73.33 144.02,73.36 143.98,73.4 143.98,73.46 144.02,73.5 144.17,73.5 144.42,73.39 144.58,73.39 144.59,73.4 144.65,73.4 144.81,73.45 144.9,73.45 145.12,73.39 145.3,73.39 145.33,73.41 145.41,73.44 147.46,73.44 147.81,73.09 147.81,72.7 147.65,72.55 v2(147.65,72.55)
  BOTTOM w0.104: LI4.4 22.3,34.91 22.16,35.05 v2(22.16,35.28)
USB20_P3_R: length 20.4
  BOTTOM w0.104: JUSB3.3 15.95,44.99 16.05,45.09 16.77,45.09 17.16,44.7 17.16,42.6 18.03,41.73 19.5,41.73 20.24,40.98 20.24,40.1 20.21,40.07 20.21,39.5 20.24,39.47 20.24,38.61 20.91,37.94 v4(20.91,37.93) 20.92,37.93 21.68,37.17 22.46,37.17 DI3.2 23.29,37.3 23.33,37.34 23.75,37.34 25.42,35.67 25.42,34.74 25.3,34.62 25.11,34.62 25.02,34.71 25.02,34.86 24.96,34.91 LI4.3
USB20_P4: length 151.4
  TOP w0.104: RI47.1 263.22,60.5 LI8.1 v4(263.22,58.58) 263.22,58.11 262.7,57.59 262.7,56.96 263.04,56.62 263.34,56.62 v2(263.48,56.49)
  IN1 w0.076: v2(139.8,75.92) 139.96,75.76 139.96,74.75 140.48,74.23 143.44,74.23 145.75,71.91 148.37,71.91 149,72.54 149.87,72.54 149.89,72.52 149.91,72.52
  IN1 w0.119: v2(263.48,56.49) 263.35,56.61 262.99,56.61 262.87,56.49 262.87,55.35 262.32,54.8 260.59,54.8 260.05,55.34 259.52,55.34 258.83,54.65 252.24,54.65 244.75,47.16 242.4,47.16 241.14,45.9 231.92,45.9 231.73,46.1 230.63,46.1 227.22,46.1 227.22,46.1 226.25,46.1 208.3,46.1 206.53,47.87 205.26,47.87 198.92,54.21 198.53,54.21 193.13,59.61 191.06,59.61 188.79,61.87 182.33,61.87 181.68,61.23 181.22,61.23 181.21,61.24 180.82,61.24 180.81,61.23 180.63,61.23 178.49,61.23 178.01,61.71 177.38,61.71 176.81,61.14 175.3,61.14 173.88,62.57 173.88,65.14 169.58,69.44 167.41,69.44 165.17,71.68 163.74,71.68 163.39,72.04 160.7,72.04 159.95,71.29 159.15,71.29 158.83,71.62 153.91,71.62 153.1,72.43 153.03,72.43 152.94,72.52 149.91,72.52
  BOTTOM w0.076: v2(139.8,75.92) 139.8,75.99 UC1.AD10
USB20_P4_L: length 4.7
  TOP w0.104: v2(263.41,63.28) 263.52,63.17 263.52,63.16 263.58,63.1 263.58,62.76 263.22,62.4 LI8.2 263.22,61.54 RI47.2
  BOTTOM w0.104: v2(263.41,63.28) 263.6,63.47 263.6,64.78 263.45,64.93 JNGFF2.7
USB20_P5: length 166
  IN1 w0.076: 149.91,74.03 149.73,74.03 149.65,73.95 147.23,73.95 146.73,73.45 146.73,72.8 v2(146.47,72.54)
  IN1 w0.119: v2(46.99,112.88) 47.21,112.66 47.21,112.53 47.46,112.28 53.85,112.28 56.11,114.54 70.52,114.54 72.71,112.35 89.12,112.35 91.34,114.57 103.53,114.57 104.89,115.93 124.13,115.93 125.95,114.11 143.47,114.11 156.86,100.72 156.86,95.46 159.91,92.42 159.91,87.38 158.84,86.3 158.84,78.07 156.66,75.89 155.83,75.89 153.97,74.03 149.91,74.03
  BOTTOM w0.076: v2(146.47,72.54) 146.45,72.54 146.02,72.96 145.78,72.96 145.72,72.9 145.36,72.9 UC1.AJ2
  BOTTOM w0.104: LZ1.1 48.11,111.32 47.1,112.32 47.1,112.77 v2(46.99,112.88)
USB20_P5_R: length 13.9
  BOTTOM w0.104: LZ1.2 52.52,111.32 52.71,111.51 52.92,111.51 DV7.1 53.43,111.51 53.74,111.51 55.73,113.5 57.04,113.5 57.85,114.3 61.22,114.3 62.16,115.24 62.16,115.98 62.2,116.02 JEDP1.8
USB20_P7: length 187.4
  IN3 w0.135: v2(151.38,72.06) 151.59,72.27 151.59,72.88 151.86,73.15 155.05,73.15 155.95,74.05 155.95,74.51 156.29,74.85 158.95,74.85 163.19,70.61 164.55,70.61 166.88,68.28 168.94,68.28 171.03,66.19 171.03,63.7 179.65,55.07 179.65,54.71 182.45,51.91 182.96,51.91 186.91,47.96 186.91,46.4 194.79,38.51 194.79,36.57 197.16,34.21 197.16,33.59 202.26,28.49 207.2,28.49 207.96,29.25 213.42,29.25 213.95,29.78 220.9,29.78 221.67,30.55 231.9,30.55 235.28,27.17 235.28,26.71 238.51,23.48 247.85,23.48 248.28,23.91 249.18,23.91 249.56,23.52 251.94,23.52 252.19,23.27 253.71,23.27 254.24,22.74 256.9,22.74 257.47,23.3 257.47,24.34 257.93,24.8 259.38,24.8 260.79,23.39 261.09,23.39 261.41,23.08 269.15,23.08 269.62,22.61 271.43,22.61 272.24,23.43 274.93,23.43 275.38,23.88 279.89,23.88 282.28,26.26 284.17,26.26 285.11,27.21 285.11,28.78 286.95,30.61 288.33,30.61 288.47,30.75 288.47,31 v2(288.31,31.15)
  BOTTOM w0.076: 149.96,71.63 149.93,71.6 149.62,71.6 149.11,72.11 149.11,73.29 148.16,74.24 145.24,74.24 144.56,73.9 UC1.AH2
  BOTTOM w0.104: RI49.1 290.24,33.35 LI9.4 290.59,32.5 290.59,32.25 290.22,31.88 288.75,31.88 288.53,31.66 288.53,31.36 v2(288.31,31.15) ; v2(151.38,72.06) 151.49,71.95 151.49,71.76 151.36,71.63 149.96,71.63
USB20_P7_L: length 4
  BOTTOM w0.104: JNGFF1.3 289.44,35.8 289.52,35.88 289.52,36.02 289.6,36.1 290,36.1 290.17,35.93 290.17,35.92 290.67,35.42 290.67,35.24 290.24,34.81 LI9.3 290.25,34.69 RI49.2
USB20_P8: length 122.1
  TOP w0.104: LV27.2 89.66,109.84 89.66,110.08 89.41,110.33 v4(89.41,111.35) 89.41,111.64 89.68,111.92 90.17,111.92 90.91,112.66 v2(90.91,113.26)
  IN1 w0.076: 149.91,74.67 149.89,74.65 149.83,74.65 149.8,74.63 149.53,74.63 149.36,74.46 148.71,74.46 148.66,74.42 148.37,74.42 148.32,74.46 145.77,74.46 144.78,75.45 141.07,75.45 140.83,75.22 140.83,75.08 v2(140.6,74.86)
  IN1 w0.119: 149.91,74.67 153.7,74.67 155.57,76.54 156.41,76.54 157.28,77.41 157.28,85.65 159.27,87.64 159.27,91.47 156.22,94.52 156.22,100.45 143.3,113.37 125.67,113.37 123.76,115.28 105.27,115.28 103.9,113.91 93.29,113.91 91.87,112.49 91.39,112.49 91.07,112.81 91.07,113.1 v2(90.91,113.26)
  BOTTOM w0.076: v2(140.6,74.86) 140.83,75.09 UC1.AF9
USB20_P8_R: length 14.8
  TOP w0.104: v2(93.62,112.43) 94.09,112.43 94.2,112.33 DV4.3 93.66,111.39 93.54,111.26 93.54,109.45 93.15,109.06 93.14,109.06 92.25,108.17 v4(91.95,108.17) 91.61,108.17 91.09,108.68 90.83,108.68 LV27.1
  BOTTOM w0.104: v2(93.62,112.43) 93.29,112.42 93.17,112.29 93.17,112.13 93.34,111.96 93.83,111.96 94.02,112.15 94.02,114.43 93.65,114.8 93.65,115.87 93.24,116.28 JTS1.3
USB20_P10: length 164.5
  IN3 w0.135: v2(141.77,73.78) 141.77,73.78 142.12,74.13 142.13,74.13 142.4,74.4 144.52,74.4 145.07,73.84 153.85,73.84 155.54,75.54 159.23,75.54 163.47,71.29 164.96,71.29 167.3,68.96 169.22,68.96 171.71,66.47 171.71,63.99 180.33,55.37 180.33,55.01 182.74,52.59 183.24,52.59 187.62,48.22 187.62,46.69 195.52,38.79 195.52,36.81 197.84,34.49 197.84,34.07 202.72,29.2 206.81,29.2 207.55,29.93 213.14,29.93 213.68,30.48 220.59,30.48 221.36,31.24 232.26,31.24 236.11,27.38 236.11,27.11 238.25,24.97 249.28,24.97 249.79,24.46 253.6,24.46 254.63,23.42 255.6,23.42 256.6,24.41 256.6,24.53 257.56,25.5 259.69,25.5 260.91,24.27 269.09,24.27 270.06,23.3 271.15,23.3 271.27,23.42 271.27,23.56 v2(271.14,23.69)
  BOTTOM w0.076: UC1.AH8 v2(141.77,73.78)
  BOTTOM w0.104: JUSH1.9 271.15,26.61 271.45,26.31 271.45,25.17 271.3,25.01 271.3,23.85 v2(271.14,23.69)
USB_OC0#: length 223.4
  TOP w0.102: UI3.13 295.39,72.26 295.53,72.4 295.53,73.37 295.05,73.86 v2(294.74,73.86)
  IN1 w0.102: v2(165.48,87.6) 165.48,87.57 164.62,86.71 164.62,84.33 165.04,83.91 171.53,83.91 172.4,84.79 174.06,84.79 174.3,84.55 174.3,84.29 176.03,82.56 176.87,82.56 177.09,82.34 177.09,78.12 175.88,76.92 175.88,74.1 175.42,73.64 175.42,70.32 176.31,69.43 176.31,68.16 179.63,64.84 190,64.84 190.97,63.87 194.29,63.87 207.34,50.82 207.76,50.82 209.24,49.34 240.08,49.34 241.92,51.17 244.5,51.17 254.01,60.68 264.13,60.68 264.95,59.86 266.64,59.86 268.04,58.45 268.38,58.45 v2(268.89,58.97)
  IN3 w0.076: 141.18,88.21 141.6,87.78 141.89,87.78
  IN3 w0.102: v2(140.85,89.18) 140.85,88.54 141.18,88.21 ; 141.89,87.78 147.74,87.78 148.31,87.22 152.22,87.22 153.72,85.72 160.19,85.72 161.51,87.04 165.18,87.04 165.48,87.34 v2(165.48,87.6) ; v2(268.89,58.97) 270.02,60.1 272.21,60.1 273.37,61.25 287,61.25 287.81,60.45 291.11,60.45 291.81,61.15 291.81,70.48 294.74,73.41 v2(294.74,73.86)
  BOTTOM w0.076: 142.47,93.97 142.13,93.62 142.13,90.96 140.85,89.68 v2(140.85,89.18) 140.86,89.16 UC1.A9
  BOTTOM w0.102: 142.47,93.97 v3(142.95,94.45) 143.97,95.47 144.96,95.47 146.21,96.73 146.21,99.3 146.04,99.47 RPC3.3
USB_OC1#: length 236.7
  IN1 w0.102: v2(24.99,33.18) 24.99,34.28 23.05,36.23 23.05,42 23.1,42.06 23.1,42.14 23.33,42.36 23.47,42.36 26.88,45.77 30.27,45.77 30.84,46.34 33.4,46.34 33.98,46.92 38.91,46.92 41.97,49.98 41.97,64.2 40.84,65.33 39.79,65.33 37.41,67.71 37.41,70.7 35.98,72.13 35.98,74.92 37,75.94 37,76.43 38.31,77.73 38.31,78.58 38.46,78.73 38.46,81.32 38.99,81.86 38.99,82.45 39.48,82.95 39.48,82.95 39.74,83.21 39.74,86.3 40.73,87.28 40.73,89.85 40.64,89.93 40.64,91.84 40.11,92.37 39.84,92.37 38.66,93.56 38.66,94.39 37.14,95.9 37.14,106.82 41.35,111.02 59.89,111.02 60.83,111.96 69.96,111.96 71.51,110.41 95.05,110.41 95.55,110.9 106.6,110.9 107.11,111.42 122.87,111.42 124.39,109.89 127.18,109.89 128.32,111.04 134.25,111.04 140.32,104.96 140.32,97.89 141.77,96.44 141.77,95.95 142.71,95.01 142.85,95.01 v2(143.52,94.34)
  BOTTOM w0.076: 142.81,93.63 142.39,93.2 142.39,90.98 141.24,89.83 141.24,87.91 140.86,87.54 UC1.C9
  BOTTOM w0.102: 142.81,93.63 v2(143.52,94.34) 144.35,95.16 145.03,95.16 145.66,95.79 147.08,95.79 147.56,96.27 147.56,97.24 146.54,98.25 RPC3.2 ; UI1.3 v3(25.19,32.23) 25.19,32.83 24.99,33.03 v2(24.99,33.18)
USB_OC2#: length 220
  TOP w0.102: v2(30.15,46.19) 30.16,46.19 30.67,45.68 UI2.3
  IN1 w0.102: v2(144.14,94.29) 144.14,94.46 143.37,95.23 142.78,95.23 141.98,96.03 141.98,96.53 140.53,97.98 140.53,105.05 134.34,111.24 128.24,111.24 127.09,110.09 124.48,110.09 122.95,111.62 107.03,111.62 106.51,111.11 95.46,111.11 94.97,110.61 71.6,110.61 70.04,112.17 60.75,112.17 59.81,111.23 41.26,111.23 36.94,106.9 36.94,95.82 38.45,94.3 38.45,93.47 39.66,92.27 39.66,90.49 40.02,90.13 40.02,89.85 40.53,89.34 40.53,87.8 38.79,86.06 38.79,81.94 38.25,81.41 38.25,78.82 38.1,78.67 38.1,77.81 37.36,77.06 36.69,77.06 36.2,76.57 36.2,75.46 35.78,75.05 35.78,71.48 36.41,70.84 36.41,70.17 36.1,69.86 36.1,67.75 36.41,67.43 37.39,67.43 39.71,65.12 40.76,65.12 41.76,64.12 41.76,50.06 38.82,47.13 31.08,47.13 30.15,46.2 v2(30.15,46.19)
  BOTTOM w0.076: 143.25,93.19 142.57,92.5 142.57,90.93 141.42,89.79 141.42,88.07 141.72,87.78 141.72,87.52 141.55,87.35 141.31,87.35 140.86,86.9 UC1.D9
  BOTTOM w0.102: 143.25,93.19 144.14,94.07 v2(144.14,94.29) 144.63,94.78 144.93,94.78 145.74,95.59 147.16,95.59 147.76,96.18 147.76,97.32 147.04,98.04 v3(147.04,98.27) RPC3.1
USB_OC3#: length 15.3
  BOTTOM w0.076: UC1.B9 140.45,88.37 140.45,89.52 141.84,90.9 v3(141.84,92.3) 141.84,94.03 142.12,94.31
  BOTTOM w0.112: 142.12,94.31 143.54,95.73 144.92,95.73 146.01,96.81 146.01,99.05 145.54,99.51 RPC3.4
USB_PWR_EN1#: length 302
  TOP w0.102: RPE11.3 268.76,31.21 269.25,31.69 v2(269.36,31.69)
  TOP w0.107: 269.62,38.39 269.62,38.34 269.99,37.97 269.99,37.95 v2(270.01,37.93)
  IN1 w0.102: v2(269.36,31.69) 269.88,31.17 271.65,31.17 272.37,30.45 274.99,30.45 275.68,31.14 277.68,31.14 278.29,30.53 280.25,30.53 v2(280.27,30.56)
  IN2 w0.102: v2(26.73,30.74) 26.36,30.36 26.36,26.78 33.43,19.7 42.36,19.7 47.29,24.63 80.96,24.63 83.11,22.48 113.88,22.48 116.03,24.63 158.56,24.63 159.98,26.05 164.6,26.05 164.84,25.81 166.81,25.81 167.4,25.22 183.29,25.22 185.77,27.7 193.24,27.7 193.86,27.07 195.04,27.07 195.52,26.59 198.93,26.59 199.4,27.06 208.15,27.06 208.46,26.76 209.79,26.76 209.94,26.9 214,26.9 214.87,26.03 221.03,26.03 222.02,27.02 222.02,27.08 223.47,28.53 231.32,28.53 234.91,24.93 234.91,24.73 234.91,24.22 236.13,23 236.64,23 239.68,23 240.05,22.62 243.02,22.62 244.17,21.48 259.93,21.48 v2(260.55,22.09)
  BOTTOM w0.102: v2(26.73,30.74) 26.89,30.89 UI1.4 ; v2(260.55,22.09) 260.57,22.07 266.18,22.07 266.47,22.35 269.63,22.35 270.25,21.73 274.27,21.73 275.4,22.86 275.4,24.45 277.37,26.42 279.8,26.42 v3(280.54,27.16) 280.7,27.31 280.7,28.29 280.26,28.72 280.26,30.55 v2(280.27,30.56) ; v2(269.36,31.69) 269.36,32.21 268.91,32.66 268.91,34.39 269.61,35.09 269.61,36.12 270.51,37.02 270.51,37.31 270.01,37.8 v2(270.01,37.93)
USB_PWR_EN2#: length 303.7
  TOP w0.102: v2(29.4,46.83) 29.4,47.14 29.72,47.46 UI2.4 ; v2(268.2,31.63) 268.2,31.59 268.26,31.52 RPE11.4 268.26,30.66 267.87,30.27 267.87,28.98 268.25,28.6 268.25,25.93 268.48,25.7 268.48,23.61 268.05,23.17 267.91,23.17 v1(267.32,22.59) v2(266.68,21.94)
  TOP w0.107: v2(266.82,39.59) 266.86,39.62 266.86,39.62 UE1.G5
  IN2 w0.102: v2(29.4,46.83) 29.11,47.12 26.9,47.12 24.89,45.12 24.89,39.2 27.87,36.22 27.87,25.55 33.41,20.01 42.31,20.01 47.18,24.88 81,24.88 83.19,22.69 113.8,22.69 115.99,24.88 158.52,24.88 159.9,26.25 164.68,26.25 164.93,26.01 166.9,26.01 167.48,25.42 183.21,25.42 185.68,27.9 193.32,27.9 193.95,27.27 194.57,27.27 194.9,27.6 198.61,27.6 198.95,27.26 201.79,27.26 202.26,27.73 208.03,27.73 208.8,26.96 209.71,26.96 209.9,27.15 214.04,27.15 214.96,26.23 220.88,26.23 223.39,28.73 231.4,28.73 235.12,25.02 235.12,24.65 235.12,24.65 235.12,24.3 236.22,23.2 236.55,23.2 239.76,23.2 240.13,22.83 243.1,22.83 244.24,21.69 259.51,21.69 260.29,22.47 260.7,22.47 261.38,21.8 266.54,21.8 v2(266.68,21.94)
  BOTTOM w0.102: v2(268.2,31.63) 267.98,31.41 266.98,31.41 266.75,31.64 266.75,33.71 268.24,35.19 268.24,37.04 267.96,37.32 267.96,38.29 266.82,39.43 v2(266.82,39.59)
USB_PWR_SHR_LFT_EN#: length 72.7
  TOP w0.102: v2(299.31,64.95) v3(298.92,65.34) 298.68,65.57 294.7,65.57 294.39,65.88 UI3.6 ; v2(270.31,31.69) 269.93,31.69 269.26,31.03 RPE11.2
  TOP w0.107: v2(269.22,37.99) UE1.J3
  IN1 w0.102: v2(269.22,37.99) 269.7,37.51 272.97,37.51 274.2,36.28 274.2,35.82 274.81,35.21 275.42,35.21 276.22,36.01 278.94,36.01 281.21,38.27 282.68,38.27 282.87,38.08 286.29,38.08 289.6,41.39 290.46,41.39 292.13,43.06 292.13,44.23 292.79,44.89 292.79,46.58 295.28,49.07 295.28,49.46 295.94,50.13 295.94,51.73 297.7,53.49 297.7,56.38 297.9,56.57 298.28,56.57 299.1,57.39 299.1,58.09 298.86,58.32 298.86,58.89 299.19,59.21 300.15,59.21 300.37,59.43 300.37,60.86 299.24,62 299.24,64.87 v2(299.31,64.95)
  BOTTOM w0.102: v2(269.22,37.99) 269.55,38.31 269.86,38.31 269.87,38.31 270.18,38.31 270.18,38.31 270.3,38.31 270.4,38.21 270.4,37.79 270.85,37.34 270.85,35.29 270.26,34.7 269.51,34.7 269.12,34.31 269.12,32.88 v2(270.31,31.69)
USB_PWR_SHR_VBUS_EN: length 74.2
  TOP w0.102: UI3.5 293.89,65.8 294.59,65.11 v1(295.38,65.11) 296.43,65.11 296.7,65.37 297.75,65.37 298.63,64.49 299.41,64.49 300.13,65.22 v2(300.13,65.65) ; UE1.J2 269.19,37.21 269.19,36.61 270.68,35.13 270.68,33.2 270.9,32.98 270.9,31.71 v2(270.89,31.71) 270.89,31.62 270.51,31.25 269.89,31.25 269.76,31.12 RPE11.1
  IN1 w0.102: v2(270.89,31.71) 271.05,31.86 273.3,31.86 273.67,31.49 273.67,31.04 274.01,30.7 274.96,30.7 275.6,31.34 276.33,31.34 277.19,32.2 277.55,32.2 277.8,32.46 280.23,32.46 281.25,31.44 284.46,31.44 290.75,37.73 290.75,38.8 290.61,38.94 290.61,40.38 292.94,42.72 292.94,43.87 293.6,44.53 293.6,46.24 296.09,48.73 296.09,49.12 297.47,50.5 297.47,52.11 298.58,53.22 298.58,55.32 300.78,57.52 300.78,61.05 300.13,61.69 v2(300.13,65.65)
USBCOMP: length 1.6
  TOP w0.112: RC44.1 142.69,77.55 142.46,77.78 v2(142.46,78.06)
  BOTTOM w0.076: UC1.AB6 142.79,77.73 v2(142.46,78.06)
USH_DET#: length 35
  TOP w0.102: RE526.2 257.23,49.09 258.21,49.09 259.2,48.1 v2(259.59,48.1)
  TOP w0.107: v2(259.59,48.1) 259.93,47.77 262.98,47.77 264.02,46.72 UE1.C13
  BOTTOM w0.102: v2(259.59,48.1) 259.67,48.1 260.2,47.56 260.2,40.91 258.98,39.68 257.49,39.68 256.8,38.99 256.8,37.13 256.54,36.87 256.54,35.01 256.86,34.69 256.86,29.81 256.54,29.49 256.54,28.13 v3(256.83,27.84) 257.51,27.16 RZ87.1 258.07,26.43 DZ7.2
USH_DET#_R: length 6
  TOP w0.102: v2(262.17,27.45) 261.68,27.45 v3(260.44,26.22) 259.92,26.22 v2(259.49,26.65)
  BOTTOM w0.102: v2(262.17,27.45) 262.52,27.45 262.65,27.32 JUSH1.26 ; DZ7.1 259.13,26.36 258.98,26.51 RZ87.2 v2(259.49,26.65)
USH_PWR_STATE#: length 77.9
  TOP w0.102: v2(260.11,26.61) 260.25,26.61 261.21,27.57 v3(261.26,27.57) 261.27,27.57 261.58,27.88 v2(261.58,27.93) ; UE2.9 273.83,61.68 274.1,61.95 275.45,61.95 277.17,60.24 277.23,60.18 v2(277.23,60.19)
  IN2 w0.102: v2(277.23,60.19) 277.23,60.17 276.94,59.89 276.94,56.24 277.32,55.86 277.32,53.95 278.26,53 279.48,53 280.55,51.94 283.18,51.94 283.89,51.23 286.37,51.23 287.01,50.59 287.01,48.27 286.74,48.01 286.74,47.66 283.78,44.71 283.78,44.02 282.91,43.15 282.22,43.15 281.37,42.29 281.37,33.63 282.76,32.24 282.76,31.31 280.99,29.54 280.19,29.54 278.06,27.41 266.97,27.41 266.58,27.02 261.91,27.02 261.58,27.35 v2(261.58,27.93)
  BOTTOM w0.102: RZ10.2 258.99,27.9 260.11,26.78 v2(260.11,26.61) ; v2(261.58,27.93) 261.58,27.99 262,28.4 264.28,28.4 264.65,28.03 JUSH1.22
USH_RST#_R: length 9.8
  TOP w0.102: v3(261.3,24.96) 261.94,25.6 RZ114.2 262.46,25.62 v2(262.46,26.23)
  BOTTOM w0.102: v2(262.46,26.23) 261.58,27.11 261.58,27.39 261.2,27.77 261.2,28.09 261.72,28.61 264.56,28.61 265.15,28.01 JUSH1.21
USH_SMBCLK: length 41.5
  TOP w0.112: v2(270.36,25.98) 270.22,26.11 270.22,26.49 CZ62.1 ; UE1.B3 v2(262.8,37.97)
  IN3 w0.135: v2(270.36,25.98) 270.25,25.88 270.25,25.7 270.39,25.57 277.59,25.57 278.54,26.52 279.27,26.52 280.67,27.92 280.67,28.5 280.96,28.78 281.4,28.78 v2(281.55,28.94)
  BOTTOM w0.112: v2(281.55,28.94) RZ8.2 ; v2(262.8,37.97) 262.97,37.8 262.97,37.57 261.92,36.52 261.92,34.75 260.97,33.81 260.97,31.39 259.92,30.33 259.92,28.28 261.01,27.19 261.01,26.43 262.41,25.03 269.9,25.03 270.21,25.33 270.21,25.83 v2(270.36,25.98) 270.12,26.22 270.12,26.59 270.15,26.62 JUSH1.11
USH_SMBDAT: length 45.1
  TOP w0.112: CZ63.1 269.98,26.51 269.98,26.19 v2(269.77,25.98) 269.77,25.33 v3(269.72,25.28) ; UE1.E5 v2(265.22,39.59)
  IN3 w0.135: v2(281.55,28.36) 281.39,28.52 281.07,28.52 280.93,28.39 280.93,27.81 279.38,26.26 278.65,26.26 277.7,25.31 270.28,25.31 269.99,25.6 269.99,25.76 v2(269.77,25.98)
  BOTTOM w0.112: JUSH1.12 269.65,26.75 269.88,26.52 269.88,26.09 v2(269.77,25.98) 269.97,25.78 269.97,25.43 269.8,25.27 262.51,25.27 261.25,26.53 261.25,27.29 260.16,28.38 260.16,30.23 261.21,31.29 261.21,33.71 262.16,34.65 262.16,36.42 263.21,37.47 263.21,38.23 263.35,38.37 264.67,38.37 264.81,38.51 264.81,39.19 265.21,39.59 v2(265.22,39.59) ; RZ9.2 282.37,29.02 282.18,29.02 281.55,28.39 v2(281.55,28.36)
VCI_IN1#: length 4.6
  TOP w0.102: RE507.1 259.79,38.97 v3(260.24,38.97) 260.34,38.97 260.68,39.31 261.81,39.31 262.01,39.52 262.52,39.52 262.99,39.99 UE1.B5
VCI_IN2#: length 12.7
  TOP w0.102: UE1.D4 v2(264.42,38.79) ; RE508.1 v2(259.01,31.41)
  BOTTOM w0.102: v2(264.42,38.79) 264.42,38.81 264.07,39.17 262.31,39.17 260.71,37.56 260.71,35.93 260.49,35.71 260.49,32.64 259.26,31.41 v2(259.01,31.41)
VCT_LAN_R1: length 7.6
  TOP w0.102: v3(274.12,84.78) 274.12,86.09 273.62,86.58 RL3.1
  TOP w0.203: UL1.6 275.1,90.66 274,89.56 274,87.02 RL3.1
VGA_ID: length 6.1
  TOP w0.102: v2(267.52,48.42) 267.52,48.65 RE84.1 RE85.1
  TOP w0.107: v2(268.42,45.19) UE1.H11
  IN2 w0.102: v2(267.52,48.42) 267.52,48.42 268.42,47.52 v2(268.42,45.19)
VID0_EOPIO_VR: length 4.9
  TOP w0.127: v3(43.88,50.53) 43.94,50.46 PR1321.1
  TOP w0.254: PU1302.9 46.79,48.31 46.53,48.56 46.53,49.79 PR1318.2 45.02,50.44 PR1321.1
VID0_PRIM_CORE: length 5.2
  BOTTOM w0.102: PR408.2 v3(171.96,116.92)
  BOTTOM w0.254: PR408.2 PR420.1 171.03,115.12 PR418.2 171.69,114.46 PU402.9
VID0_VCCIO: length 4.4
  BOTTOM w0.254: PR416.1 PR414.2 190.32,113.32 v3(188.89,111.88) 188.17,111.16 PU401.9
VID1_EDRAM_VR: length 2.6
  TOP w0.254: PU1301.8 49.56,60.9 49.2,61.26 PR1306.2 49.23,61.6 PR1309.1
VID1_EOPIO_VR: length 2.4
  TOP w0.254: PU1302.8 47.98,50.15 PR1320.1 47.64,50.44 PR1317.2
VID1_PRIM_CORE: length 5.4
  TOP w0.102: v2(169.72,113.55) v3(169.72,114.12)
  TOP w0.254: v2(169.72,113.55) 169.61,113.44 PR419.1
  BOTTOM w0.254: PR417.2 170.27,113.55 v2(169.72,113.55) 169.61,113.44 PR419.1 170.19,112.12 PU402.8
VID1_VCCIO: length 4.7
  BOTTOM w0.102: v3(188.29,115.26) 188.29,113.75 PR413.2
  BOTTOM w0.254: PU401.8 187.01,112.47 PR415.1 PR413.2
VIDALERT_N: length 93.5
  TOP w0.112: v2(46.54,71.67) 46.6,71.74 PR625.1
  IN3 w0.135: v2(106.55,92.61) 106.55,92.9 106.35,93.1 102.28,93.1 101.91,93.48 100.19,93.48 98.62,95.04 98.14,95.04 96.83,96.35 83.87,96.35 83.26,96.96 82.02,96.96 81.72,97.27 78.82,97.27 78.14,97.95 71.13,97.95 70.17,96.99 67.24,96.99 65.83,95.58 65.57,95.32 65.57,93.48 68.01,91.04 68.01,87.27 67.96,87.22 67.7,86.97 67.7,83.32 67.7,82.08 64.96,79.33 62.7,79.33 61.76,78.39 60.82,78.39 60.13,77.7 54.66,77.7 53.06,79.29 51.86,79.29 51.12,80.02 49.53,80.02 48.91,79.4 48.91,75.87 47.8,74.76 47.8,72.44 47.03,71.67 v2(46.54,71.67)
  BOTTOM w0.076: v2(106.55,92.61) 106.55,93.12 RC152.1 106.9,93.48 RC153.2
  BOTTOM w0.112: PR604.2 v2(46.54,71.67)
VIDALERT_N_B: length 2.1
  TOP w0.102: 48.79,71.36 48.58,71.36 PR625.2
  TOP w0.112: PU602.36 48.79,71.36
VIDSCLK: length 101.6
  TOP w0.112: PR618.1 46.98,70.55 v2(46.55,70.55)
  IN3 w0.135: v2(46.55,70.55) 46.55,70.56 46,71.1 46,71.79 46.34,72.13 46.87,72.13 47.36,72.62 47.36,74.96 48.47,76.07 48.47,79.58 49.34,80.46 51.31,80.46 52.04,79.73 53.24,79.73 54.84,78.14 59.95,78.14 60.64,78.83 61.57,78.83 62.51,79.77 64.77,79.77 67.27,82.26 67.27,83.51 67.26,83.51 67.26,87.14 67.27,87.15 67.57,87.45 67.57,90.86 65.13,93.3 65.13,95.51 65.65,96.02 67.06,97.43 67.42,97.43 69.99,97.43 70.95,98.39 78.35,98.39 79.03,97.71 81.9,97.71 82.2,97.4 83.44,97.4 84.05,96.79 97.01,96.79 98.32,95.48 98.8,95.48 100.37,93.91 102.09,93.91 102.46,93.54 106.75,93.54 v2(107.69,92.61)
  BOTTOM w0.076: CC321.1 108.73,92.98 108.41,92.67 107.75,92.67 v2(107.69,92.61) 107.95,92.34 108.11,92.34 108.82,91.64 108.82,91.28 109.06,91.04 109.41,91.04 109.71,90.75 109.71,90.34 109.6,90.24 109.6,90.17 109.75,90.02 109.75,88.63 UC1.A63
  BOTTOM w0.112: v2(46.55,70.55) 47.07,70.55 PR601.2
VIDSCLK_B: length 2
  TOP w0.102: PR618.2 48.3,70.96 PU602.37
VIDSOUT: length 103.4
  TOP w0.112: PR626.1 46.61,72.64 v2(46.56,72.59)
  IN3 w0.135: v2(46.56,72.59) 46.17,72.59 45.49,71.91 45.49,70.99 46.36,70.12 47.29,70.12 48.24,71.06 48.24,74.58 49.34,75.69 49.34,79.22 49.71,79.58 50.94,79.58 51.67,78.85 52.88,78.85 54.48,77.25 60.31,77.25 61,77.94 61.94,77.94 62.88,78.89 65.14,78.89 65.56,79.31 68.14,81.9 68.14,83.51 68.14,86.78 68.45,87.09 68.45,90.53 68.45,90.53 68.45,91.23 66.01,93.66 66.01,95.14 67.42,96.55 70.39,96.55 71.35,97.51 77.96,97.51 78.64,96.83 81.53,96.83 81.84,96.52 83.08,96.52 83.69,95.91 96.65,95.91 97.96,94.6 98.44,94.6 100.01,93.04 101.73,93.04 102.1,92.66 105.99,92.66 v2(106,92.67)
  BOTTOM w0.076: RC157.1 v2(106,92.67) 106,92.6 106.53,92.07 106.98,92.07 109.29,89.76 109.29,87.98 109.51,87.76 109.51,87.52 109.21,87.23 UC1.D64
  BOTTOM w0.112: PR605.2 46.59,72.56 v2(46.56,72.59)
VIDSOUT_B: length 2.4
  TOP w0.112: PR626.2 48.64,72.19 48.64,71.93 48.81,71.76 PU602.35
VRALERT#: length 33.4
  TOP w0.102: v2(163.35,68.22) 163.35,68.81 163.84,69.3 163.94,69.3 164.41,69.77 RC73.1
  IN3 w0.076: v2(138.74,71.9) 138.82,71.9 139.22,72.3 142.65,72.3 144.34,70.61
  IN3 w0.102: 144.34,70.61 145.26,70.61 145.55,70.32 148.81,70.32 149.28,69.85 152.03,69.85 153.55,71.38 155.95,71.38 156.59,72.02 156.59,72.42 156.85,72.67 157.94,72.67 160.23,70.38 160.23,69.08 161.42,67.89 163.02,67.89 v2(163.35,68.22)
  BOTTOM w0.076: UC1.AM11 v2(138.74,71.9)
  BOTTOM w0.102: v2(163.35,68.22) v3(163,68.57)
VSA_SEN+: length 135.1
  TOP w0.254: v2(134.23,84.27) 133.88,84.27 133.73,84.42 v3(133.56,84.42) 133.46,84.51 132.74,84.51 132.39,84.16 RC168.2 ; v2(52.4,75.91) 52.4,76.65 PR649.2 52.35,76.7 52.35,77.58 PC640.2
  IN2 w0.254: v2(52.4,75.91) 52.47,75.91 52.58,76.03 52.58,76.67 52.04,77.21 49.69,77.21 47.96,78.94 47.96,84.79 48.74,85.57 48.74,88.29 47.89,89.14 47.89,91.53 53.11,96.75 53.11,98.19 54.51,99.59 59.39,99.59 59.79,99.99 66.89,99.99 67.47,99.41 78.4,99.41 78.53,99.54 98.4,99.54 99.46,98.48 105.54,98.48 107.54,100.48 112.1,100.48 112.51,100.89 119.8,100.89 120.84,101.92 123.23,101.92 123.75,101.4 128.4,101.4 129.76,100.04 129.76,94.46 128.32,93.03 128.32,90.73 130.51,88.55 132.68,88.55 133.75,87.48 133.75,84.67 134.15,84.27 v2(134.23,84.27)
  BOTTOM w0.254: v2(134.23,84.27) 134.23,84.19 134.48,83.94 UC1.H20 ; v2(52.4,75.91) 52.4,76.61 PC650.1 PC652.1
VSA_SEN-: length 133.7
  TOP w0.203: PU602.26 52.39,75.32 v2(52.43,75.36)
  TOP w0.254: RC166.1 133.38,83.52 133.2,83.7 v2(133.2,84.04)
  IN2 w0.254: v2(52.43,75.36) 52.63,75.36 53.09,75.82 53.09,76.88 52.25,77.72 49.9,77.72 48.47,79.15 48.47,84.58 49.25,85.36 49.25,88.5 48.4,89.35 48.4,91.32 53.62,96.54 53.62,97.98 54.72,99.08 59.6,99.08 60,99.49 66.68,99.49 67.26,98.9 78.62,98.9 78.74,99.03 98.19,99.03 99.25,97.97 105.75,97.97 107.75,99.97 112.31,99.97 112.72,100.38 120.02,100.38 121.05,101.42 123.02,101.42 123.54,100.89 128.19,100.89 129.25,99.83 129.25,94.67 127.82,93.24 127.82,90.52 130.29,88.04 132.47,88.04 133.24,87.27 133.24,86.88 132.81,86.44 132.81,84.44 v2(133.2,84.04)
  BOTTOM w0.254: PC649.1 54.21,76.7 PC650.2 53.41,76.49 52.86,75.95 v3(52.86,75.66) 52.55,75.36 v2(52.43,75.36) ; v2(133.2,84.04) 133.3,83.94 UC1.H21
VSET_5105: length 12.2
  TOP w0.102: v2(262.7,51.09) 262.7,51.5 263.01,51.81 RE77.1 262.56,52.3 262.54,52.28 CE38.1 261.77,52.28 v3(261.1,51.61)
  TOP w0.107: UE1.C9 v2(263.61,43.6)
  BOTTOM w0.102: v2(263.61,43.6) 263.18,44.03 263.18,45.5 263.49,45.8 263.49,49.68 262.7,50.46 v2(262.7,51.09)
WIGIG_32KHZ: length 6.2
  TOP w0.112: v3(284.23,46.89) 284.07,47.05 v2(282.64,47.05) 282.49,47.05 282.4,46.97 280.6,46.97 280.29,47.28 RZ56.1
  BOTTOM w0.112: v2(282.64,47.05) 282.14,47.55 JNGFF1.50
WLAN_COEX1: length 28.8
  BOTTOM w0.102: JNGFF1.48 280.17,47.05 279.21,48.01 279.21,50.75 277.22,52.74 277.22,55.38 279.16,57.32 279.16,60.37 v3(282.4,63.6) 282.71,63.91 282.71,68.05 283.73,69.08 283.73,70.61 283.44,70.9 RZ130.2
WLAN_COEX2: length 28.4
  BOTTOM w0.102: JNGFF1.46 280.38,46.55 279.01,47.92 279.01,50.67 277.02,52.66 277.02,55.68 278.92,57.58 278.92,60.68 v3(280.9,62.67) 282.5,64.27 282.5,68.26 283.38,69.14 RZ129.2
WLAN_COEX3: length 27.6
  BOTTOM w0.102: JNGFF1.44 280.42,46.05 278.81,47.67 278.81,50.58 276.81,52.57 276.81,57.31 278.6,59.1 278.6,60.91 v3(279.37,61.67) 282.3,64.6 282.3,68.66 RZ128.2
WLAN_WIGIG60GHZ_DIS#: length 56.8
  TOP w0.102: DZ1.1 279.94,49.6 279.62,49.91 v2(279.62,49.91) ; v3(257,34.73) RE8.1 v2(257,36.52) ; UE1.L13 270.42,46.54 271.64,47.76 v2(271.64,49.23)
  IN1 w0.102: v2(279.62,49.91) 279.62,49.91 279.38,50.15 277.1,50.15 276.33,50.92 274.9,50.92 273.53,49.55 271.96,49.55 v2(271.64,49.23)
  IN2 w0.102: v2(257,36.52) 257.23,36.29 259.43,36.29 259.85,35.87 259.85,35.06 261.04,33.88 262.47,33.88 263.12,33.22 263.12,32.87 264.38,31.61 264.92,31.61 265.37,31.16 266.38,31.16 267.27,30.27 268.01,30.27 268.39,30.65 271.52,30.65 275.99,35.12 275.99,39.96 277.53,41.5 277.53,44.09 280.51,47.07 280.51,49.02 279.62,49.91 v2(279.62,49.91)
WLAN_WIGIG60GHZ_DIS#_R: length 3.4
  TOP w0.102: v2(283.15,49.27) 282.43,49.27 282.12,49.58 DZ1.2
  BOTTOM w0.102: JNGFF1.56 282.93,49.05 v2(283.15,49.27)
WRST#: length 5.6
  TOP w0.254: CE500.1 279.37,62.38 RE6.2 278.19,61.2 277.74,61.2 v3(277.47,60.93) 277.47,60.59 277.68,60.38 277.68,60 277.05,59.37 277.05,58.96 276.8,58.71 UE2.4
WWAN_COEX1: length 8.7
  BOTTOM w0.102: v3(283.1,71.98) 282.79,71.67 RZ130.1 281.86,69.96 280.13,69.96 277.7,72.4 JNGFF2.56
WWAN_COEX2: length 7.9
  BOTTOM w0.102: JNGFF2.54 277.2,72.61 280.22,69.59 281.94,69.59 282.65,70.3 RZ129.1
WWAN_COEX3: length 8.7
  BOTTOM w0.102: RZ128.1 282.5,69.7 282.19,69.39 279.2,69.39 276.7,71.89 JNGFF2.52
WWAN_PWR_EN: length 3.6
  TOP w0.102: v3(263.98,74.43) v2(263.41,74.43) 263.37,74.4 RZ43.1 263.41,73.44 264.19,73.44 CZ198.1
  BOTTOM w0.102: JNGFF2.6 263.2,74.23 v2(263.41,74.43)
WWAN_RADIO_DIS#: length 89.2
  TOP w0.102: UE1.M2 271.55,37.26 272.75,37.26 273.74,36.27 273.74,35.64 v2(274.09,35.29) 274.15,35.23 274.93,35.23 RE10.1 ; v2(269.99,72.19) 270.58,72.77 282.13,72.77 288.34,66.56 288.35,66.56 288.69,66.21 288.69,66.21 291.01,63.89 291.01,62.66 293.75,59.91 297.12,59.91 v3(297.78,59.25) 298.1,58.93 299.07,58.93 v2(299.26,58.74) ; DZ5.1 v2(263.85,70.41)
  IN1 w0.102: v2(274.09,35.29) 274.39,35.29 274.68,35 275.65,35 276.42,35.78 279.69,35.78 281.98,38.07 282.59,38.07 282.79,37.87 286.37,37.87 287.87,39.38 288.73,39.38 292.33,42.97 292.33,44.15 292.99,44.81 292.99,46.49 295.48,48.98 295.48,49.38 296.15,50.04 296.15,51.65 297.97,53.47 297.97,55.58 299.3,56.91 299.3,58.7 v2(299.26,58.74)
  IN2 w0.102: v2(263.85,70.41) 268.22,70.41 v2(269.99,72.19)
WWAN_RADIO_DIS#_R: length 2.8
  TOP w0.102: v3(264.23,71.49) 263.96,71.49 263.64,71.81 v2(263.64,71.81) DZ5.2
  BOTTOM w0.102: JNGFF2.8 263.7,71.87 v2(263.64,71.81)
WWAN_WAKE#: length 26.1
  TOP w0.102: v2(272.51,55.24) 271.47,55.24 270.29,54.06 v1(270.29,53.31) 270.29,52.02 270.92,51.4 270.92,50.93 271.84,50.01 271.84,49.74 272.33,49.26 RE38.1
  TOP w0.107: RE38.1 272.33,48.15 271.22,47.05 UE1.M13
  BOTTOM w0.102: v2(272.51,55.24) 271.92,55.83 270.58,55.83 266.95,59.46 266.95,62.11 266.28,62.77 266.28,64.09 267.45,65.26 JNGFF2.15
XCLK_BIASREF: length 18.6
  TOP w0.112: v2(131.87,80.37) 131.97,80.47 132.47,80.47 RC324.1 132.65,80.64 133.49,80.64 133.8,80.94 RC52.1
  IN1 w0.076: v2(122.27,86.13) 122.67,85.73 122.67,84.53 122.93,84.27 128.05,84.27 128.97,83.34 128.97,79.95 129.33,79.59 131.45,79.59 131.87,80.01 v2(131.87,80.37)
  BOTTOM w0.076: UC1.E42 122.04,85.89 v2(122.27,86.13)
XDP_DBRESET#: length 108.2
  IN1 w0.119: v2(126.36,111.27) 126.36,111.28 127.34,112.25 140.77,112.25 143.86,109.16 145.7,109.16 150.08,104.78 150.08,104.18 151.79,102.46 v2(151.79,99.93)
  IN2 w0.124: v2(98.49,105.08) 98.73,105.31 101.38,105.31 101.68,105.01 v2(101.68,104.76)
  BOTTOM w0.112: v2(101.68,104.76) 101.68,104.23 102.39,103.52 103,103.52 106.93,99.6 110.94,99.6 112.19,100.86 115.39,100.86 CC32.1 RC137.1 118.35,100.6 119.28,101.54 119.28,101.85 122.73,105.3 124.3,105.3 125.27,106.28 125.27,109.06 126.36,110.14 v2(126.36,111.27) ; JXDP1.48 74.71,105.47 75.1,105.86 75.1,107.53 77.19,109.63 90.3,109.63 95.38,104.55 v1(96.65,104.55) 97.97,104.55 v2(98.49,105.08) ; RC290.1 152.94,97.6 153.28,97.94 153.28,98.92 152.27,99.93 v2(151.79,99.93) 151.54,100.18 148.72,100.18 148.43,100.47 UC12.1
XDP_JTAGX: length 8.9
  BOTTOM w0.076: UC1.A59 112.26,88.8 112.23,88.83 112.23,91.1 111.5,91.83 111.22,91.83 111.04,92.01 111.04,92.4 v3(110.97,92.46) 110.97,92.92 111.41,93.36 111.41,94.24 111.03,94.62 RC328.2 110.96,94.62 110.88,94.69 RC87.1 110.88,96.35 CC305.1
XDP_OBS0: length 1.9
  BOTTOM w0.112: RC239.2 82.66,100.12 82.66,101.11 82.81,101.27 JXDP1.21
XDP_OBS0_R: length 42.2
  IN3 w0.076: v2(113.93,90.42) 113.93,89.76 113.03,88.86 112.84,88.86
  IN3 w0.135: 112.84,88.86 110.3,88.86 109.86,89.3 109.86,90.66 109.6,90.92 109.6,92.44 109.19,92.85 109.19,93.61 107.28,95.52 106.21,95.52 105.71,96.03 103.49,96.03 102.3,97.21 99.38,97.21 98.03,97.21 97.77,97.47 97.57,97.67 84.42,97.67 83.81,98.28 v2(82.71,98.28)
  BOTTOM w0.076: v2(113.93,90.42) 113.93,90.17 114.3,89.8 114.3,87.77 UC1.C55
  BOTTOM w0.112: v2(82.71,98.28) 82.54,98.45 RC239.1
XDP_OBS1: length 2
  BOTTOM w0.112: RC240.2 82.21,100.56 JXDP1.23
XDP_OBS1_R: length 48.9
  IN3 w0.076: 112.64,88.41 112.95,88.41 114.43,89.9 114.43,90.65 113.22,91.86 v2(113.12,91.86)
  IN3 w0.135: v2(82.02,98.25) 82.43,97.84 83.62,97.84 84.23,97.23 97.39,97.23 97.85,96.78 98.21,96.78 98.21,96.77 99.57,96.77 99.57,96.78 101.8,96.78 102.41,96.16 102.41,95.6 102.67,95.35 105.76,95.35 106.03,95.08 107.09,95.08 108.79,93.38 108.79,91.05 109.42,90.43 109.42,89.05 110.06,88.41 112.64,88.41
  BOTTOM w0.076: UC1.D55 114.17,87.18 114.49,87.51 114.49,87.77 114.47,87.8 114.47,89.89 114.3,90.05 114.3,91 114.07,91.23 v3(113.74,91.23) v2(113.12,91.86)
  BOTTOM w0.112: RC240.1 81.65,98.62 v2(82.02,98.25)
XDP_OBS2_R: length 6.1
  BOTTOM w0.076: UC1.B54 115.06,88.29 115.06,88.68 114.99,88.75 114.99,88.76 114.84,88.91 114.83,88.91 114.8,88.94 114.8,90.27 115.32,90.79 115.32,91.73 115.7,92.11 116.11,92.11 T10.1
XDP_PRSNT_PIN1: length 12.7
  TOP w0.102: v2(88.45,100.8) v1(85.28,97.64) 84.14,96.5 84.14,95.56 v2(84.22,95.47)
  BOTTOM w0.102: v2(88.45,100.8) 88.45,100.92 88.81,101.28 JXDP1.1 ; v2(84.22,95.47) 84.22,97.55 83.43,98.35 RC122.1 RC121.1
XDP_TMS: length 24.8
  TOP w0.102: v2(60.89,105.23) 60.89,102.68 60.47,102.26 60.39,102.26 60.37,102.24 60.03,102.24 60.01,102.26 59.69,102.26 59.06,101.63 59.06,100.17 59.56,99.66 60.26,99.66 60.71,99.22 RC228.1 61.46,98.41 62.37,98.41 62.69,98.72 62.69,99.18 62.62,99.25 UC8.9
  IN2 w0.102: v2(60.89,105.23) 60.89,105.38 62.08,106.57 69.1,106.57 v2(69.79,105.88)
  BOTTOM w0.102: v2(69.79,105.88) 70.24,106.32 71.34,106.32 71.71,105.95 JXDP1.58
XTAL24_IN: length 16.6
  BOTTOM w0.076: RC46.2 123.96,95.27 v3(124.56,94.67) 124.77,94.46 124.77,90.69 124.45,90.37 124.45,89.07 124.21,88.83 124.21,88.21 123.8,87.8 123.8,87.52 124.01,87.32 124.15,87.32 124.37,87.1 124.37,86.51 124.57,86.31 UC1.E37
  BOTTOM w0.102: RC46.2 123.99,95.68 CC21.1
  BOTTOM w0.112: CC21.1 126.01,97.7 126.01,99.24 125.22,100.03 YC1.3
XTAL24_OUT: length 11.9
  BOTTOM w0.076: UC1.E35 125.16,85.89 125.03,86.02 125.03,87.51 124.9,87.64 124.5,87.64 124.37,87.76 124.37,88.76 124.61,89 124.61,90.3 124.94,90.63 124.94,92.35 125.08,92.49 v3(125.08,93.29) 125.08,93.55 124.94,93.7 124.94,95.62 RC46.1
  BOTTOM w0.102: RC46.1 RC295.1
XTAL24_OUT_R: length 3.7
  BOTTOM w0.102: RC295.2 126.66,95.75 126.11,96.3 126.02,96.3 CC22.1
  BOTTOM w0.112: YC1.1 127.3,98.22 125.74,96.66 CC22.1
XTAL_25_IN: length 6.8
  TOP w0.076: UT1.D22 25.09,91.25 25.09,91.25 25.02,91.31 25.02,92.25 24.73,92.54
  TOP w0.102: CT21.1 21.39,93.59 21.5,93.48
  TOP w0.112: CT21.1 21.39,94.12 21.67,94.4 YT1.1 ; 24.73,92.54 24.55,92.73 22.25,92.73 21.5,93.48
XTAL_25_OUT: length 4.5
  TOP w0.076: 24.91,92.65 25.25,92.31 25.25,91.54 UT1.D23
  TOP w0.112: 24.91,92.65 24.56,93 22.61,93 22.21,93.39 RT40.1
XTAL_25_OUT_R: length 4.7
  TOP w0.102: RT40.2 23.13,93.68 22.86,93.95 22.79,93.95
  TOP w0.112: 22.79,93.95 22.68,94.05 22.68,95.6 23.72,96.64 YT1.3 ; CT20.1 RT40.2
XTALI: length 7.3
  TOP w0.112: YL1.1 279.78,86.23 279.16,86.85 CL14.1 279.08,87.19 279.08,88.3 278.83,88.55 278.83,88.56 RL11.2 278.46,89.37 278.3,89.53 277.79,89.53 v3(277.17,90.14) 276.7,90.62 UL1.10
XTALO: length 3.9
  TOP w0.112: UL1.9 276.3,90.43 277.55,89.19 RL11.1 RL34.2
XTALO_R: length 4.8
  TOP w0.112: YL1.3 278.64,84.95 278.64,86.45 278.3,86.8 CL13.1 278.3,87.93 278.41,88.04 RL34.1
Z2805: length 3.4
  TOP w0.102: RL18.1 v3(303.19,80.88)
  TOP w0.508: RL18.1 302.33,82.01 v2(302.32,82)
  BOTTOM w0.508: TL1.22 v2(302.32,82)
Z2806: length 3.4
  TOP w0.102: RL16.1 v3(303.15,88.36)
  TOP w0.508: RL16.1 302.45,89.5 v2(302.32,89.62)
  BOTTOM w0.508: TL1.16 v2(302.32,89.62)
Z2807: length 3.4
  TOP w0.102: RL17.1 v3(303.19,84.44)
  TOP w0.508: v2(302.32,83.27) 302.34,83.25 RL17.1
  BOTTOM w0.508: TL1.21 v2(302.32,83.27)
Z2808: length 3.2
  TOP w0.102: RL15.1 v3(303.15,91.8)
  TOP w0.508: RL15.1 302.42,90.8 v2(302.32,90.9)
  BOTTOM w0.508: TL1.15 302.33,90.89 v2(302.32,90.9)
N04748: length 2.2
  BOTTOM w0.203: 64.92,92.55 64.85,92.62 PU901.3 ; 64.92,92.55 PR929.1 ; 64.92,92.55 PC939.1
N40459: length 2
  TOP w0.102: RV5.2 58.65,103.94 QV2.1
N16399089: length 24
  TOP w0.254: PR916.2 59.55,90.01 59.93,90.4 59.93,93.44 60.19,93.69 62.66,93.69 62.92,93.95 62.92,95.17 64.62,96.87 68.63,96.87 69.29,97.53 69.29,100.83 v2(69.22,100.91)
  BOTTOM w0.102: v3(63.98,103.54) 64.99,102.53 PD904.1
  BOTTOM w0.254: PD901.1 68.48,101.64 v2(69.22,100.91)
N16400770: length 11.1
  BOTTOM w0.254: PR901.3 49.63,84.87 50.05,85.29 50.77,85.29 51.23,85.75 51.23,86.58 51.99,87.34 53.83,87.34 54.09,87.6 v3(55.96,87.6) 58.6,87.6 PR910.1
N16404606: length 4.2
  TOP w0.254: PR939.2 28.74,72.68 PD905.3 29.08,73.89 29.08,74.81 PR950.1
N16404788: length 1.3
  TOP w0.254: PD905.1 30.69,73.28 PU903.1
N16775301: length 3.3
  BOTTOM w0.254: PR206.1 32.86,37.6 PR204.2 32.86,35.9 PC208.2 33.1,35.86 33.74,35.22 PU200.16
N16775385: length 4.6
  TOP w0.102: PC218.1 37.44,33.27 v3(37.02,32.85)
  TOP w0.254: v2(37.86,35.4) 38.15,35.11 PC218.1
  BOTTOM w0.254: v2(37.86,35.4) 37.59,35.67 PU200.3
N16775433: length 2.5
  BOTTOM w0.102: PC204.1 v3(29.14,26.46)
  BOTTOM w0.508: PC204.1 30.56,26.71 PR202.2
N16775513: length 1.5
  BOTTOM w0.102: PC205.1 29.77,31.73 v3(29.34,32.16)
N16775517: length 0.9
  TOP w0.102: v1(34.48,32.86) 33.72,32.86 v2(33.59,32.99)
N16776853: length 1.6
  BOTTOM w0.102: PC207.1 32.81,34.97 33.23,34.54 33.54,34.54 33.76,34.32 PU200.14
N16783095: length 2.2
  BOTTOM w0.102: v3(236.39,20.98) 236.05,21.33 236.05,21.82 PC113.2
  BOTTOM w0.254: PC113.2 235.82,22.03 PR108.1
N16783126: length 3.1
  BOTTOM w0.102: 232.32,21.71 PC111.1 232.67,21.71 233.64,20.74 v3(235.02,20.74)
N16783134: length 2.2
  BOTTOM w0.102: PC127.2 31.29,45.85 30.36,45.85 v3(30.19,45.69)
  BOTTOM w0.254: PR117.1 31.5,46.06 PC127.2
N16783223: length 2.5
  BOTTOM w0.102: PC119.1 32.13,49.18 30.74,50.58 30.74,50.72 v3(30.55,50.91)
N16784595:
  vias: v3(229.2,29.55)
N16784799: length 1.2
  BOTTOM w0.102: PC114.1 v3(39.54,49.22)
N17185089: length 1
  TOP w0.381: PQ1204.5 44.11,84.13 PR1218.1
N17185092: length 1.9
  TOP w0.102: PR1214.2 PR1218.2 43.13,83.6 PQ1204.6
N17185371: length 1
  TOP w0.102: PQ1204.2 44.16,81.32 PR1223.1
N17370862: length 1
  BOTTOM w0.102: v3(45.12,88.16) 45.52,88.16 45.53,88.14 46.13,88.14
N17370885: length 30.4
  TOP w0.254: v2(35.46,107.18) 36.01,107.73 36.01,109.57 PR15.1
  BOTTOM w0.254: v2(35.46,107.18) 35.41,107.13 35.41,104.16 37.47,102.1 37.47,94.92 35.35,92.79 35.35,92.24 36.04,91.55 v3(36.26,91.55) 36.27,91.53 36.98,91.53 37.33,91.19 38.57,91.19 40.01,89.76 PR10.2 42.8,89.15 PQ5.2
N17370921: length 5.2
  TOP w0.254: PQ1.6 37.94,105.38 37.16,106.16 37.16,109.32 PR15.2
N17370927: length 2
  BOTTOM w0.254: PR16.2 46.48,85.16 PQ7.1
N17370961: length 33.1
  TOP w0.102: v2(35.9,105.12) 34.97,104.18 33.76,104.18 32.36,102.79 32.36,101.34 32.85,100.85 PQ2.1 34.04,99.98 PR6.2 34.62,98.85 34.62,98.32 34.42,98.11 33.63,98.11 33.27,98.48 PR3.1
  BOTTOM w0.102: PL3.1 50.75,107.09 50.44,107.4 49.42,107.4 48.98,106.96 48.98,106.68 48.4,106.09 47.96,106.09 47.4,106.64 47.4,108.18 46.56,109.02 41.45,109.02 41.29,108.86 37.26,108.86 v3(36.65,108.25) 36.03,107.63 36.03,105.25 v2(35.9,105.12)
N17370983: length 2.3
  TOP w0.102: PR3.2 31.31,98.48 PR5.1 31.31,99.66 PQ2.3
N17370995: length 9.5
  TOP w0.102: PR8.2 29.25,105.26 PQ3.2 29.96,103.77 30.19,103.54 30.82,103.54 32.13,102.23 32.13,100.42 PR6.1
N17370999: length 3.2
  TOP w0.102: PR7.2 29.31,101.63 PQ3.1 30.23,102.66 PQ2.2
N17371029: length 6
  BOTTOM w0.102: v3(56.52,103.38) 56.67,103.23 PR12.2
  BOTTOM w0.381: PQ9.4 54.71,99.21 55.09,99.59 56.06,99.59 PR18.1
  BOTTOM w0.508: PR12.2 56.9,102.23 PC6.1 56.9,100.72 56.14,99.96 PR18.1
N17371043: length 2.2
  BOTTOM w0.254: PQ6.1 58.65,100.85 v3(57.93,100.12) 57.47,99.66 PR18.2
N17371125: length 3.9
  BOTTOM w0.254: PR20.1 47.94,83.35 47.94,85 47.57,85.37 47.09,85.37 46.62,85.84 PQ7.2
N17371182: length 28.2
  TOP w0.254: v2(35.46,108.96) 35.05,109.37 PR23.2
  BOTTOM w0.254: v2(35.46,108.96) 36.37,109.87 v3(38.52,109.87) 40.26,109.87 40.4,110.01 46.97,110.01 47.65,109.33 52.76,109.33 54.33,107.77 54.33,106.04 55.18,105.19 56.5,105.19 58,103.69 PQ6.2
N17371207: length 9.1
  TOP w0.254: PR22.1 34.78,107.88 PR27.1 34.72,106.68 34.72,105.53 33.78,104.59 31.65,104.59 30.23,106.01 PQ8.1
N17372063: length 2.2
  TOP w0.254: PQ1.3 39.98,107.77 PR17.2 40.87,107.82 PR19.2
N17372074: length 5.6
  TOP w0.254: PR25.1 37.54,109.87 37.54,106.28 37.8,106.03 PQ1.5
N17372283: length 1.5
  TOP w0.254: PR19.1 41,106.88 40.15,106.03 PQ1.2
N17372833: length 9.8
  TOP w0.254: v2(40.13,66.36) 40.13,66.43 PC1206.1 39.62,66.95 PR1219.1 ; PR1219.1 40.04,68.22 PU1201.3 ; PR1219.1 38.81,67.8 PR1201.2
  BOTTOM w0.254: v2(40.13,66.36) 39.22,67.28 37.98,67.28 v3(37.42,67.83) PR1203.1
N17377163: length 1
  TOP w0.102: 192.79,22.57 192.47,22.57 v1(191.96,23.08)
