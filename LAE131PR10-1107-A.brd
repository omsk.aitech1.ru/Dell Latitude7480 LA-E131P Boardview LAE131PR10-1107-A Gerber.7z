# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKRUN#_EC: length 6.7
  TOP w0.102: RE337.2 271.5,33.2 272.04,33.74 272.04,34.7 v3(272.1,34.77) 272.13,34.79 272.13,36.14 271.61,36.65 271.61,36.9 271.34,37.18 270.83,37.18 UE1.L2
CMOUT: length 67.3
  TOP w0.254: PQ1210.2 PQ1210.3 40.21,94.46 39.27,94.46 38.65,95.08 36.9,95.08 36.74,94.91 v2(35.87,94.91) ; PR951.1 57.28,97.34 57.56,97.62 57.56,98.08 55.55,100.09 55.55,101.68 53.85,103.39 53.85,104.02 54.5,104.67 54.5,107.8 53.93,108.37 52.85,108.37 52.48,108 v2(52.48,107.87)
  BOTTOM w0.254: PQ1216.2 40.02,86.88 39.56,86.42 v3(39.49,86.42) 38.56,86.42 37.39,87.59 37.39,88.28 37.05,88.61 36.62,88.61 36.36,88.87 36.36,90.72 34.7,92.38 34.7,93.83 35.78,94.91 v2(35.87,94.91) 36.08,94.91 37.12,95.95 37.12,101.95 35,104.06 35,107.41 35.38,107.79 35.59,107.79 36.93,109.14 41.17,109.14 41.34,109.3 46.67,109.3 47.45,108.53 51.83,108.53 v2(52.48,107.87)
COMP_IA: length 3.8
  TOP w0.203: PU602.16 56.26,71.76 v2(56.38,71.63)
  BOTTOM w0.102: v2(56.38,71.63) 56.9,71.63 v3(57,71.74)
  BOTTOM w0.254: v2(56.38,71.63) 55.92,72.09 PR639.2 PC636.2
COMP_ISL88738: length 3.2
  BOTTOM w0.203: PU901.28 61.37,94.55 61.04,94.89 v3(61.04,95.17) 61.04,95.53 PR934.1
  BOTTOM w0.254: PR934.1 60.72,96.06 PC943.1
COMP_VSA: length 4.8
  TOP w0.203: PU602.24 53.19,74.85 53.46,75.11 v2(53.46,75.32)
  BOTTOM w0.102: v2(53.46,75.32) 53.86,75.72 54.28,75.72 v3(54.4,75.72)
  BOTTOM w0.254: v2(53.46,75.32) 53.24,75.1 52.86,75.1 PC628.1 52.33,74.67 PR630.1
CONTACTLESS_DET#: length 167.6
  TOP w0.102: v2(139.8,78.94) v1(139.8,79.56)
  IN1 w0.076: 149.91,81.36 148.49,79.94 145.24,79.94 143.93,78.62 140.18,78.62 139.87,78.94 v2(139.8,78.94)
  IN1 w0.102: 149.91,81.36 150.09,81.54 150.83,81.54 151.21,81.92 v2(151.43,81.92)
  IN2 w0.102: v2(262.16,28.02) 261.77,28.41 259.34,28.41 257.91,29.84 254.27,29.84 253.34,30.77 253.34,32.77 253.05,33.05 249.76,33.05 248.97,33.84 248.21,33.84 246.12,35.93 243.62,35.93 243.22,36.32 232.15,36.32 231.34,37.14 220.77,37.14 220.09,37.81 212.59,37.81 211.07,39.34 205.72,39.34 203.56,41.5 203.56,42.22 191.23,54.55 190.11,54.55 178.81,65.86 177.6,65.86 174.64,68.82 174.19,68.82 173.6,69.41 173.6,70.08 169,74.68 169,76.12 167.97,77.15 164.93,77.15 163.27,78.81 153.76,78.81 153.56,78.61 153.56,77.79 152.79,77.02 151.11,77.02 149.4,78.73 146.67,78.73 146.32,79.08 146.32,79.71 146.81,80.2 148.53,80.2 149.71,81.37 150.88,81.37 v2(151.43,81.92)
  BOTTOM w0.076: v2(139.8,78.94) 139.53,78.67 UC1.W11
  BOTTOM w0.102: v2(151.43,81.92) 151.43,82.11 152.21,82.89 RC278.1 ; v2(262.16,28.02) 262.27,28.14 263.93,28.14 264.15,27.92 JUSH1.23
CORE_SNUB: length 1.5
  TOP w0.127: v3(71,83.84) 70.75,84.08 PC662.1
CORE_SW:
  vias: v1(75.27,86.16) v2(72.11,84.44) v2(72.43,83.94) v2(72.69,85.64) v2(72.66,85.04) v2(72.71,84.44) v2(72.9,83.4) v2(73.06,83.96) v2(73.24,85.04) v2(73.27,85.64) v2(73.33,84.46) v2(73.46,83.46) v2(73.71,83.97) v2(73.79,85.38) v2(73.79,84.79) v2(74.06,83.46) v2(74.4,85.34) v2(74.36,84.73) v2(74.37,84.12) v2(74.65,83.43) v2(74.83,85.72) v2(74.9,84.52) v2(74.91,83.94) v2(75.11,85.06) v2(75.38,85.56) v2(75.47,84.52) v2(75.77,85.16) v2(75.98,85.72) v2(76.05,84.52) v2(76.41,85.16) v2(76.56,85.73)
CORE_VID0: length 92.3
  TOP w0.254: v2(167.79,96.54) 168.23,96.54 168.61,96.15 168.61,95.43 167.93,94.75 167.93,89.73 168.29,89.37 168.29,86.83 167.63,86.17 167.63,82.45 169.38,80.7 169.38,80.03 170.6,78.81 v3(170.6,73.99) 170.6,71.77 169.91,71.08 169.91,67.88 168.61,66.57 v2(168.27,66.57)
  IN1 w0.203: v2(167.79,96.54) 166.83,96.54 165.95,97.42 165.95,100.43 167.37,101.85 167.37,106.67 166.92,107.12 v2(166.36,107.12) ; v2(139.69,71.39) 139.71,71.37 139.89,71.37 141.12,72.61 142.68,72.61 143.77,71.51 143.77,71.17 145.23,69.71 149.09,69.71 149.68,69.12 151.49,69.12 152.42,70.05 157.12,70.05 157.78,69.39 160.38,69.39 161.4,70.41 162.74,70.41 163.04,70.1 164.48,70.1 168.02,66.57 v2(168.27,66.57)
  BOTTOM w0.254: v2(166.36,107.12) 166.36,112.35 167.53,113.51 167.53,114.33 PR408.1 ; UC1.AN11 139.51,71.39 139.69,71.39 v2(139.69,71.39)
CORE_VID1: length 114.1
  IN1 w0.102: v2(166.85,106.54) 167.12,106.27 167.12,101.96 164.48,99.31 164.48,97.19 165.52,96.15 169.06,96.15 173.38,91.83 178.54,91.83 182.83,87.54 182.83,87.4 182.88,87.35 182.88,75.24 v2(182.38,74.74)
  IN2 w0.102: v2(164.65,74.89) 164.64,74.89 164.64,75.06 163.65,76.06 163.08,76.06 162.01,74.99 158.48,74.99 157.9,74.41 157.9,72.25 157.29,71.65 153.75,71.65 152.64,72.75 149.79,72.75 149.63,72.75 149.59,72.78 148.91,72.1 145.61,72.1 144.79,72.92 140.34,72.92 140.31,72.89 139.64,72.89 139.16,72.41 138.4,72.41 138.28,72.29 138.28,71.74 137.94,71.39 v2(137.88,71.39)
  BOTTOM w0.102: v2(164.65,74.89) 164.75,74.89 165.4,75.53 166.08,75.53 166.37,75.24 168.13,75.24 169.54,73.83 169.54,72.75 169.27,72.48 169.27,70.72 171.52,68.47 174.97,68.47 175.64,69.13 179.6,69.13 181.03,70.57 181.03,72.66 181.3,72.93 181.7,72.93 181.93,73.15 181.93,74.29 v2(182.38,74.74) ; v2(166.85,106.54) 167.19,106.88 v1(167.19,108.85) 167.19,110.4 167.5,110.71 167.5,111.28 167.32,111.45 167.32,112.02 168.01,112.71 PR411.1
  BOTTOM w0.254: v2(137.88,71.39) 138.02,71.39 138.28,71.65 UC1.AN13
CPU_B+: length 30.6
  TOP w0.102: v2(77.92,92.42) v1(77.92,92.96)
  IN3 w0.254: v2(44.99,73.6) 44.5,73.11 44.5,70.21 45.53,69.18 47.12,69.18 47.55,68.75 54.97,68.75 55.38,69.16 55.38,74.16 55.76,74.54 57.08,74.54 57.08,74.54 57.48,74.54 57.9,74.96 61.18,74.96 v2(61.95,75.74)
  BOTTOM w0.254: PR603.2 47.02,74.33 46.59,73.89 45.81,73.89 45.52,73.6 v2(44.99,73.6)
  vias: v2(62.56,77.95) v2(63.12,77.95) v2(63.68,77.95) v2(64.26,77.95) v2(68.65,82.64) v2(68.58,82.07) v2(68.58,81.5) v2(76.65,92.42) v2(77.28,92.42)
CPU_DP1_AUXN: length 107.6
  TOP w0.104: CT19.1 38.88,81.9 39,82.03 39.72,82.03 40.39,82.7 41.29,82.7 41.49,82.49 v2(41.49,82.45)
  IN1 w0.076: v2(116.79,84.85) 116.92,84.98 117,84.98 117.02,84.98 117.02,84.98 117.17,84.98 117.35,85.16 117.35,88.09 116.75,88.69 115.32,88.69 115.3,88.71 115.28,88.71
  IN1 w0.119: 115.28,88.71 114.99,88.71 114.64,89.06 114.64,90.65 114.31,90.99 114.31,92.17 114.07,92.42 113.86,92.42 113.78,92.5 113.76,92.5 113.59,92.67 v2(113.59,92.67)
  IN3 w0.076: v2(113.59,92.67) 113.77,92.49 113.83,92.49 113.96,92.61 113.96,93.28 113.61,93.62 113.61,94.53 113.36,94.78 113.36,95.78 113.35,95.78 113.33,95.79
  IN3 w0.135: 113.33,95.79 112.39,96.73 112.39,97.62 110.45,99.56 107.09,99.56 105.15,101.5 104.27,102.39 98.34,102.39 98.05,102.67 74.01,102.67 73.57,102.24 64.11,102.24 60.25,98.38 60.25,93.74 59.97,93.46 59.97,90.35 58.17,88.55 57.22,88.55 56.28,87.61 51.67,87.61 47.99,83.93 47.16,83.93 44.82,81.59 43.16,81.59 42.03,82.72 41.73,82.72 41.49,82.48 v2(41.49,82.45)
  BOTTOM w0.076: UC1.G50 v2(116.79,84.85)
CPU_DP1_AUXN_C: length 9.2
  TOP w0.094: UT1.W11 v2(31.86,85.51)
  TOP w0.104: CT19.2 38.05,82.08 38.04,82.08 37.91,82.22 36.94,82.22 36.72,82.44 v2(36.2,82.44)
  IN1 w0.119: v2(36.2,82.44) 36.07,82.57 34.77,82.57 34.09,83.25 34.09,84.35 33.67,84.76 32.32,84.76 31.99,85.09 31.99,85.37 v2(31.86,85.51)
CPU_DP1_AUXP: length 107.6
  TOP w0.104: CT18.1 39.06,82.23 39.64,82.23 40.31,82.9 41.35,82.9 v2(41.49,83.04)
  IN1 w0.076: 115.28,88.49 115.3,88.49 115.32,88.51 116.68,88.51 117.18,88.02 117.18,85.24 117.1,85.16 116.99,85.16 116.94,85.21 116.88,85.21 116.79,85.3 v2(116.79,85.49)
  IN1 w0.119: 115.28,88.49 114.9,88.49 114.43,88.97 114.43,90.56 114.1,90.9 114.1,92.08 113.98,92.2 113.71,92.2 v2(113.62,92.11)
  IN3 w0.076: 113.51,95.96 113.52,95.95 113.52,95.91 113.55,95.88 113.55,94.85 113.79,94.61 113.79,93.7 114.14,93.35 114.14,92.54 113.91,92.3 113.75,92.3 113.62,92.18 v2(113.62,92.11)
  IN3 w0.135: v2(41.49,83.04) 41.57,82.96 42.13,82.96 43.26,81.83 44.72,81.83 47.06,84.17 47.89,84.17 51.57,87.85 56.18,87.85 57.12,88.79 58.07,88.79 59.73,90.45 59.73,93.56 60.01,93.84 60.01,98.48 64.01,102.48 73.47,102.48 73.91,102.92 98.15,102.92 98.44,102.63 104.37,102.63 104.95,102.05 107.19,99.8 110.55,99.8 112.64,97.72 112.64,96.83 113.51,95.96
  BOTTOM w0.076: UC1.F50 116.8,85.47 v2(116.79,85.49)
CPU_DP1_AUXP_C: length 9.2
  TOP w0.094: UT1.Y11 32.67,85.83 32.51,85.67 v2(32.51,85.51)
  TOP w0.104: CT18.2 37.03,82.42 36.8,82.64 36.54,82.64 36.41,82.77 36.41,82.81 v2(36.2,83.03)
  IN1 w0.119: v2(32.51,85.51) 32.38,85.51 32.21,85.34 32.21,85.18 32.41,84.98 33.76,84.98 34.31,84.44 34.31,83.35 34.87,82.79 36.01,82.79 36.2,82.97 v2(36.2,83.03)
CPU_DP1_CTRL_CLK: length 194.5
  TOP w0.112: v2(148.15,80.9) 147.98,80.73 147.98,80.59 147.98,80.58 147.98,80.38 147.71,80.11 147.24,80.11 147.02,79.89 146.46,79.89 RC175.1 ; RT341.1 38.94,79.01 v2(39.3,79.01)
  IN3 w0.076: v2(148.15,80.9) 147.97,80.72 147.97,80.4 147.63,80.06 146.1,80.06 144.56,81.6 138.98,81.6 138.78,81.8 138.78,81.94 v2(138.53,82.18) 138.78,82.43 138.78,82.66 138.22,83.23 135.59,83.23 135.38,83.03 134.64,83.03 134.33,83.33 132.92,83.33 132.01,84.25 130.98,84.25 129.95,85.28 129.95,85.81 129.92,85.84 129.92,85.86
  IN3 w0.135: 129.92,85.86 129.92,86.43 128.54,87.81 124.89,87.81 124.15,88.56 122.7,88.56 122.05,89.21 122.05,93.96 123.82,95.73 123.82,100.83 124.7,101.7 125.18,101.7 125.63,102.15 125.63,103.03 124.69,103.97 123.16,103.97 120.04,107.08 106.08,107.08 105.65,107.52 101.51,107.52 100.09,108.94 95.26,108.94 95,108.68 94.66,108.68 94.53,108.54 v2(94.53,108.54)
  BOTTOM w0.076: UC1.L13 138.23,82.56 v2(138.53,82.18)
  BOTTOM w0.112: v2(94.53,108.54) 94.7,108.71 94.9,108.71 95.15,108.97 95.15,109.42 94.5,110.07 93.66,110.07 91.65,112.08 69.3,112.08 65.42,108.2 63.15,108.2 60.23,111.13 60.23,112.06 59.65,112.64 55.56,112.64 55.08,112.16 55.08,111.34 54.08,110.34 47.99,110.34 47.4,110.93 41.45,110.93 40.82,111.56 v4(38.55,111.56) 33.56,111.56 32.81,110.81 32.81,110.46 32.52,110.16 31.71,110.16 29.89,108.34 29.89,100.88 31.31,99.46 31.31,94.92 33.07,93.15 33.07,91.71 33.69,91.09 33.69,89.72 34.7,88.71 34.7,87.06 35.09,86.67 35.09,86.1 36.92,84.28 37.27,84.28 39.79,81.75 39.79,79.19 39.62,79.01 v2(39.3,79.01)
CPU_DP1_CTRL_DATA: length 193.2
  TOP w0.112: RC178.1 146.19,80.25 146.31,80.13 146.92,80.13 147.14,80.35 147.61,80.35 147.74,80.48 147.74,80.66 v2(147.57,80.83)
  IN3 w0.076: v2(147.57,80.83) 147.77,80.63 147.77,80.49 147.54,80.26 146.19,80.26 144.64,81.81 139.06,81.81 138.98,81.88 138.98,81.94 v2(139.23,82.18) 138.98,82.43 138.98,82.75 138.3,83.43 135.5,83.43 135.3,83.23 134.72,83.23 134.42,83.53 133,83.53 132.09,84.45 131.07,84.45 130.15,85.37 130.15,85.81 130.18,85.84 130.18,85.86
  IN3 w0.135: 130.18,85.86 130.18,86.54 128.64,88.08 125,88.08 124.26,88.82 122.81,88.82 122.31,89.32 122.31,93.85 124.08,95.62 124.08,100.72 124.81,101.44 125.29,101.44 125.89,102.04 125.89,103.14 124.8,104.23 123.27,104.23 120.15,107.35 106.19,107.35 105.76,107.78 101.62,107.78 100.2,109.2 95.15,109.2 94.89,108.94 94.71,108.94 v2(94.53,109.13)
  BOTTOM w0.076: UC1.L12 v2(139.23,82.18)
  BOTTOM w0.112: v2(94.53,109.13) 94.7,108.95 94.8,108.95 94.91,109.07 94.91,109.32 94.4,109.84 93.56,109.84 91.55,111.84 69.4,111.84 65.52,107.96 63.06,107.96 59.99,111.03 59.99,111.96 59.55,112.4 55.66,112.4 55.32,112.06 55.32,111.25 54.16,110.08 47.91,110.08 47.3,110.69 41.35,110.69 40.72,111.32 33.66,111.32 33.05,110.71 33.05,110.36 32.62,109.92 31.81,109.92 30.13,108.24 30.13,100.98 31.55,99.56 31.55,95.01 33.31,93.25 33.31,91.81 33.93,91.19 33.93,89.82 34.94,88.81 34.94,87.16 35.33,86.77 35.33,86.2 37.01,84.51 37.37,84.51 40.03,81.85 40.03,79.09 39.47,78.53 38.74,78.53 RT342.1
CPU_DP1_HPD: length 221.5
  TOP w0.076: UT1.AA2 33.3,81.66 33.3,81.18 33.63,80.84 33.63,80.59 33.86,80.36 34.05,80.36
  TOP w0.112: RT24.1 37.96,78.16 37.26,78.16 v2(37.03,78.39) 35.83,79.6 35.12,79.6 34.36,80.36 34.05,80.36
  IN1 w0.076: 141.75,82.79 v2(141.14,82.18)
  IN1 w0.102: 141.75,82.79 141.96,83 141.96,88.19 143.26,89.49 143.26,91.03 145.38,93.16 145.38,94.66 144.1,95.95 144.1,96.5 145.38,97.79 145.38,100.74 142.81,103.31 142.81,104.86 v2(140,107.66)
  IN2 w0.102: v2(159.45,106.14) 159.02,106.14 158.61,106.56 158.02,106.56 151.12,113.46 123.17,113.46 120.67,110.95 117.48,110.95 117.31,111.13 102.86,111.13 102.57,110.84 92.54,110.84 92.26,110.56 78.56,110.56 76.87,112.25 71.48,112.25 70.69,113.04 62.71,113.04 58.43,108.76 41.21,108.76 37.44,104.99 37.44,104.58 31.7,98.84 31.7,95.05 34.39,92.36 34.39,88.51 35.23,87.68 35.23,85.35 37.75,82.83 37.75,79.1 v2(37.03,78.39)
  BOTTOM w0.076: UC1.L9 140.84,82.64 v2(141.14,82.18)
  BOTTOM w0.102: v2(159.45,106.14) 159.45,106.52 158.3,107.66 v1(147.89,107.66) v2(140,107.66)
CPU_DP1_N0: length 122.6
  TOP w0.104: v2(39.36,84.52) 39.2,84.36 36.96,84.36 CT11.1
  IN3 w0.076: v2(114.05,86.11) 114.08,86.09 114.08,85.95 114,85.87 113.81,85.87 113.68,86 113.68,86.35 114.84,87.51 118.21,87.51 119.2,88.5 119.2,94.89 119.94,95.64 120.24,95.64 120.54,95.93 120.54,96.13 120.57,96.16 120.57,96.17
  IN3 w0.135: 120.57,96.17 120.57,100.57 120.26,100.88 120.26,102.28 119.01,103.53 106.68,103.53 104.79,105.42 100.61,105.42 100.28,105.75 93.39,105.75 93.01,105.36 69.94,105.36 69.4,104.82 59.79,104.82 57.9,102.93 57.9,101.94 56.41,100.46 56.41,98.24 55.95,97.77 55.95,94.95 55.76,94.76 55.76,92.35 54.68,91.27 51.65,91.27 50.38,90 49.24,90 46.5,87.25 46.5,87.25 45.82,86.57 45.81,86.57 44.53,85.29 43.72,85.29 42.4,86.61 41.31,86.61 40.29,85.59 40.29,85.23 39.58,84.52 v2(39.36,84.52)
  BOTTOM w0.076: UC1.E55 v2(114.05,86.11)
CPU_DP1_N0_C: length 3.1
  TOP w0.076: UT1.AC7 33.86,84.18 33.78,84.27 33.78,84.34 33.85,84.42 34.16,84.42 34.46,84.12 34.6,84.12 34.77,84.3 34.92,84.3
  TOP w0.104: 34.92,84.3 36.08,84.3 CT11.2
CPU_DP1_N1: length 118.8
  TOP w0.104: v2(41.44,84.24) 41.27,84.06 40.69,84.06 39.62,85.13 38.57,85.13 CT13.1
  IN3 w0.076: 119.05,96.17 119.05,96.08 119.03,96.05 119.03,95.95 118.5,95.41 118.5,88.92 117.97,88.39 114.26,88.39 113.41,87.53 112.78,87.53 111.8,86.56 111.8,85.9 111.92,85.78 112.02,85.78 112.07,85.84 112.22,85.84 112.3,85.91 112.3,86.04 v2(112.22,86.11)
  IN3 w0.135: v2(41.44,84.24) 42.37,84.24 43.24,83.37 45.18,83.37 46.93,85.12 47.7,85.12 51.19,88.61 55.85,88.61 56.83,89.59 57.03,89.59 57.13,89.59 57.79,89.59 58.96,90.77 58.96,93.58 58.39,94.16 58.39,97.32 58.26,97.45 58.26,98.3 59.48,99.52 59.78,99.52 63.49,103.23 72.89,103.23 73.45,103.79 100.26,103.79 100.63,103.43 104.63,103.43 106.05,102.02 118.36,102.02 118.73,101.64 118.73,100.25 119.05,99.93 119.05,96.17
  BOTTOM w0.076: UC1.E58 v2(112.22,86.11)
CPU_DP1_N1_C: length 4.5
  TOP w0.076: 34.92,85.08 34.83,85.08 34.8,85.05 34.37,85.05 34.31,85.11 34.31,85.23 34.21,85.33 33.95,85.33 33.9,85.29 33.9,85.19 UT1.AC9
  TOP w0.104: CT13.2 37.65,85.08 34.92,85.08
CPU_DP1_N2: length 123.6
  TOP w0.104: CT15.1 36.76,85.87 37.02,85.87 v2(37.22,86.07)
  IN3 w0.076: 121.34,96.17 121.34,96.15 121.31,96.12 121.31,96 119.54,94.24 119.54,88.36 117.78,86.59 115.5,86.59 114.59,85.69 114.59,85.24 114.68,85.15 114.77,85.15 114.82,85.2 114.94,85.2 115.01,85.28 115.01,85.43 v2(114.96,85.48)
  IN3 w0.135: v2(37.22,86.07) 37.25,86.04 39.65,86.04 41.07,87.46 44.52,87.46 44.78,87.2 45.37,87.2 45.5,87.33 45.51,87.33 45.74,87.56 45.74,87.57 48.48,90.31 48.93,90.76 50.07,90.76 50.81,91.5 50.81,100.65 52.4,102.23 52.6,102.23 52.6,102.23 54.41,102.23 57.67,105.49 57.67,105.76 58.45,106.53 61.86,106.53 62.15,106.24 69.16,106.24 69.45,106.53 100.58,106.53 100.93,106.18 105.1,106.18 106.99,104.29 119.38,104.29 121.03,102.64 121.03,101.19 121.33,100.89 121.33,96.18 121.34,96.17
  BOTTOM w0.076: UC1.F53 v2(114.96,85.48)
CPU_DP1_N2_C: length 2.9
  TOP w0.076: UT1.AC11 33.85,86.02 33.78,86.09 33.78,86.2 33.83,86.25 34.27,86.25 34.39,86.13 34.89,86.13 34.9,86.15 34.92,86.15
  TOP w0.104: 34.92,86.15 35.16,86.15 35.46,85.85 35.82,85.85 CT15.2
CPU_DP1_N3: length 119.6
  TOP w0.104: v2(41.5,85.84) 41.31,85.65 40.11,85.65 39.74,86.02 39.74,86.16 39.1,86.8 38.87,86.8 CT17.1
  IN3 w0.076: v2(113.14,85.48) 113.14,85.31 113.02,85.2 112.99,85.2 112.92,85.13 112.84,85.13 112.76,85.22 112.76,86.41 112.87,86.52 113.17,86.52 114.55,87.9 118.1,87.9 118.85,88.65 118.85,95.15 119.78,96.08 119.78,96.13 119.81,96.16 119.81,96.17
  IN3 w0.135: 119.81,96.17 119.81,100.25 119.5,100.57 119.5,101.96 118.68,102.77 106.37,102.77 104.94,104.2 100.96,104.2 100.58,104.59 70.3,104.59 69.71,103.99 62.16,103.99 57.33,99.16 57.33,97.05 56.97,96.7 56.97,90.97 56.19,90.19 51.65,90.19 50.57,89.11 49.85,89.11 47.49,86.74 47.28,86.74 44.69,84.16 43.79,84.16 42.15,85.79 41.56,85.79 v2(41.5,85.84)
  BOTTOM w0.076: UC1.F56 v2(113.14,85.48)
CPU_DP1_N3_C: length 5
  TOP w0.076: UT1.AC13 33.85,86.94 33.78,87.01 33.78,87.12 33.83,87.17 34.27,87.17 34.39,87.05 34.89,87.05 34.9,87.06 34.92,87.06
  TOP w0.104: 34.92,87.06 35.36,87.06 35.65,86.77 37.89,86.77 CT17.2
CPU_DP1_P0: length 122.6
  TOP w0.104: v2(39.36,83.94) 39.36,83.98 39.19,84.16 37.1,84.16 CT10.1
  IN3 w0.076: v2(114.05,85.48) 113.95,85.48 113.5,85.93 113.5,86.43 114.76,87.7 118.13,87.7 119.01,88.58 119.01,94.97 119.86,95.82 120.17,95.82 120.36,96.01 120.36,96.12 120.33,96.15 120.33,96.17
  IN3 w0.135: 120.33,96.17 120.33,100.47 120.02,100.78 120.02,102.18 118.91,103.29 106.58,103.29 104.69,105.17 100.51,105.17 100.18,105.5 93.49,105.5 93.11,105.12 70.04,105.12 69.5,104.58 59.89,104.58 58.14,102.83 58.14,101.84 56.65,100.36 56.65,98.14 56.19,97.67 56.19,94.85 56,94.66 56,92.25 54.78,91.03 51.75,91.03 50.48,89.76 49.34,89.76 46.74,87.15 46.74,87.15 45.92,86.33 45.91,86.33 44.63,85.05 43.62,85.05 42.3,86.37 41.41,86.37 40.53,85.49 40.53,85.13 39.36,83.96 v2(39.36,83.94)
  BOTTOM w0.076: UC1.F55 v2(114.05,85.48)
CPU_DP1_P0_C: length 3
  TOP w0.076: UT1.AB7 33.53,84.15 33.66,84.02 33.77,84.02 33.84,83.95 34.67,83.95 34.82,84.1 34.92,84.1
  TOP w0.104: 34.92,84.1 36.13,84.1 36.26,83.97 CT10.2
CPU_DP1_P1: length 118.8
  TOP w0.104: CT12.1 38.57,84.84 38.59,84.84 38.68,84.93 39.54,84.93 40.61,83.86 41.23,83.86 41.44,83.66 v2(41.44,83.65)
  IN3 w0.076: v2(112.22,85.48) 112.1,85.6 111.84,85.6 111.62,85.82 111.62,86.64 112.7,87.71 113.33,87.71 114.19,88.57 117.89,88.57 118.32,88.99 118.32,95.49 118.84,96.02 118.84,96.13 118.81,96.16 118.81,96.17
  IN3 w0.135: v2(41.44,83.65) 41.44,83.67 41.76,83.99 42.27,83.99 42.44,83.83 42.44,83.52 42.67,83.29 42.98,83.29 43.14,83.13 45.28,83.13 47.03,84.88 47.8,84.88 51.29,88.37 55.95,88.37 56.93,89.35 57.89,89.35 59.2,90.67 59.2,93.68 58.63,94.26 58.63,97.42 58.5,97.55 58.5,98.2 59.58,99.28 59.88,99.28 63.59,102.99 72.99,102.99 73.55,103.55 100.16,103.55 100.53,103.19 104.53,103.19 105.95,101.78 118.26,101.78 118.49,101.54 118.49,100.15 118.81,99.83 118.81,96.17
  BOTTOM w0.076: UC1.F58 v2(112.22,85.48)
CPU_DP1_P1_C: length 4.5
  TOP w0.076: 34.92,84.88 33.75,84.88 UT1.AB9
  TOP w0.104: 34.92,84.88 37.67,84.88 CT12.2
CPU_DP1_P2: length 123.5
  TOP w0.104: CT14.1 36.79,85.67 37.04,85.67 v2(37.22,85.48)
  IN3 w0.076: v2(114.96,84.84) 114.84,84.97 114.61,84.97 114.41,85.16 114.41,85.77 115.42,86.78 117.71,86.78 119.36,88.43 119.36,94.32 121.12,96.08 121.12,96.12 121.09,96.16 121.09,96.17
  IN3 w0.135: v2(37.22,85.48) 37.53,85.8 37.77,85.8 37.93,85.64 38.41,85.64 38.57,85.8 39.75,85.8 41.17,87.22 44.42,87.22 44.68,86.96 45.47,86.96 45.6,87.09 45.61,87.09 45.98,87.46 45.98,87.47 48.73,90.21 49.03,90.51 50.17,90.51 51.06,91.4 51.06,100.55 52.5,101.99 54.51,101.99 57.91,105.39 57.91,105.66 58.55,106.29 61.76,106.29 62.05,106 69.26,106 69.55,106.29 100.48,106.29 100.83,105.94 105,105.94 106.89,104.05 119.28,104.05 120.79,102.54 120.79,101.09 121.09,100.79 121.09,96.17
  BOTTOM w0.076: UC1.G53 v2(114.96,84.84)
CPU_DP1_P2_C: length 2.8
  TOP w0.076: UT1.AB11 33.55,86.02 33.78,85.79 34.24,85.79 34.39,85.95 34.89,85.95 34.9,85.93 34.92,85.93
  TOP w0.104: 34.92,85.93 35.09,85.93 35.38,85.64 35.83,85.64 CT14.2
CPU_DP1_P3: length 119.5
  TOP w0.104: CT16.1 38.87,86.6 39.02,86.6 39.54,86.08 39.54,85.94 40.03,85.45 41.31,85.45 v2(41.5,85.26)
  IN3 w0.076: 119.57,96.17 119.57,96.13 118.66,95.22 118.66,88.72 118.02,88.08 114.47,88.08 113.1,86.7 112.79,86.7 112.58,86.49 112.58,85.14 112.77,84.95 113.03,84.95 v2(113.14,84.84)
  IN3 w0.135: v2(41.5,85.26) 41.5,85.28 41.78,85.55 42.05,85.55 42.26,85.34 42.26,85.18 42.6,84.83 42.77,84.83 43.69,83.91 44.79,83.91 47.38,86.5 47.59,86.5 49.95,88.87 50.68,88.87 51.75,89.95 56.29,89.95 57.22,90.87 57.22,96.6 57.57,96.95 57.57,99.06 62.26,103.75 69.81,103.75 70.4,104.34 100.48,104.34 100.86,103.96 104.84,103.96 106.27,102.53 118.58,102.53 119.25,101.86 119.25,100.47 119.57,100.15 119.57,96.17
  BOTTOM w0.076: UC1.G56 v2(113.14,84.84)
CPU_DP1_P3_C: length 4.9
  TOP w0.076: 34.92,86.86 34.9,86.86 34.89,86.88 34.39,86.88 34.23,86.71 33.78,86.71 33.55,86.94 UT1.AB13
  TOP w0.104: 34.92,86.86 35.28,86.86 35.57,86.57 37.95,86.57 CT16.2
CPU_DP2_AUXN: length 29.2
  IN1 w0.076: v2(115.64,93.55) 115.79,93.71 116.73,93.71 117.37,94.34 118.1,94.34 118.32,94.12 118.32,88.4 118.08,88.16 118.08,86.01 118,85.93 117.89,85.93 v2(117.71,86.11)
  IN3 w0.076: v2(115.64,93.55) 115.42,93.77 114.87,93.77 114.58,94.06 114.58,95.66 114.25,95.99 114.21,95.99 114.19,96
  IN3 w0.135: 114.19,96 113.55,96.64 113.55,97.71 110.95,100.32 108,100.32 107.7,100.62 107.7,100.84 v2(107.51,101.03)
  BOTTOM w0.076: UC1.E48 v2(117.71,86.11)
  BOTTOM w0.104: CV95.1 106.68,103.5 106.68,102.81 107.75,101.74 107.75,101.28 v2(107.51,101.03)
CPU_DP2_AUXN_C: length 7.2
  BOTTOM w0.104: CV95.2 106.17,104.95 v4(106.17,107.19) 106.17,108.11 107.19,109.12 107.64,109.12 107.67,109.15 108.24,109.15 108.27,109.12 108.78,109.12 108.87,109.22 UV7.25
CPU_DP2_AUXP: length 29.2
  IN1 w0.076: v2(117.71,85.48) 117.71,85.63 117.84,85.76 118.07,85.76 118.25,85.93 118.25,88.09 118.49,88.33 118.49,94.2 118.17,94.52 117.29,94.52 116.66,93.88 115.89,93.88 v2(115.64,94.14)
  IN3 w0.076: 114.37,96.17 114.38,96.16 114.38,96.12 114.76,95.74 114.76,94.14 114.95,93.95 115.45,93.95 v2(115.64,94.14)
  IN3 w0.135: 114.37,96.17 113.79,96.74 113.79,97.81 111.05,100.56 108.1,100.56 107.94,100.72 107.94,100.88 v2(108.09,101.03)
  BOTTOM w0.076: UC1.F48 v2(117.71,85.48)
  BOTTOM w0.104: v2(108.09,101.03) 107.95,101.17 107.95,101.82 106.89,102.89 CV94.1
CPU_DP2_AUXP_C: length 7.1
  BOTTOM w0.104: UV7.24 108.83,108.82 108.75,108.89 108.59,108.89 108.56,108.92 v4(107.95,108.92) 107.27,108.92 106.37,108.03 106.37,107.51 106.4,107.48 106.4,106.91 106.37,106.88 106.37,105.05 106.66,104.77 CV94.2
CPU_DP2_CTRL_CLK: length 67.1
  TOP w0.112: v2(141.77,81.24) 141.59,81.06 141.59,80.94 141.7,80.83 142.68,80.83 v4(143.31,81.46) 143.81,81.96 144.41,81.96 RC176.1
  IN3 w0.076: v2(141.77,81.24) 141.62,81.24 141.49,81.12 141.49,80.83 141.26,80.6 138.2,80.6 138.12,80.52 136.94,80.52 135.96,79.53 135,79.53 134.02,80.52 132.84,80.52 132.24,81.12 132.24,82.41 130.87,83.78 128.68,83.78 127.11,85.34 125.94,85.34 123.56,87.72 123.52,87.72 123.51,87.73
  IN3 w0.135: 123.51,87.73 123.45,87.78 122.26,87.78 121.23,88.8 121.23,94.24 123,96.01 123,101.88 122.64,102.23 122.64,103.16 119.54,106.26 107.94,106.26 107.76,106.09 107.76,105.76 107.89,105.63 v2(108.02,105.63)
  BOTTOM w0.076: UC1.N7 142.14,81.61 v2(141.77,81.24)
  BOTTOM w0.112: v2(108.02,105.63) 107.87,105.63 107.55,105.95 107.55,107.18 108.54,108.17 108.85,108.17 109,108.02 UV7.22
CPU_DP2_CTRL_DATA: length 67.5
  TOP w0.112: RC177.1 144.4,81.73 143.91,81.73 143.64,81.45 143.64,81.45 143.33,81.14 143.32,81.14 142.78,80.6 141.6,80.6 141.35,80.84 141.35,81.03 v2(141.14,81.24)
  IN3 w0.076: 123.69,87.92 123.71,87.9 123.71,87.86 126.02,85.55 127.2,85.55 128.76,83.98 130.95,83.98 132.44,82.49 132.44,81.21 132.93,80.72 134.1,80.72 135.09,79.74 135.87,79.74 136.86,80.73 138.04,80.73 138.11,80.8 141.17,80.8 141.29,80.92 141.29,81.09 v2(141.14,81.24)
  IN3 w0.135: 123.69,87.92 123.56,88.04 122.36,88.04 121.49,88.91 121.49,94.13 123.26,95.9 123.26,101.99 122.91,102.34 122.91,103.27 119.65,106.52 107.83,106.52 107.5,106.19 107.5,105.8 v2(107.31,105.61)
  BOTTOM w0.076: UC1.N8 141.49,81.59 v2(141.14,81.24)
  BOTTOM w0.112: v2(107.31,105.61) 107.31,107.27 108.44,108.4 108.99,108.4 109,108.42 UV7.23
CPU_DP2_HPD: length 56.9
  TOP w0.102: v2(117.18,105.82) v1(118.06,106.7) 119.52,108.16 126.39,108.16 127.35,107.2 135,107.2 135.46,107.66 v2(138.89,107.66)
  IN1 w0.102: v2(138.89,107.66) 139.4,108.16 140.34,108.16 143.09,105.41 143.09,103.32 145.59,100.82 145.59,97.7 144.31,96.43 144.31,96.02 145.6,94.73 145.6,93.05 143.49,90.94 143.49,89.43 142.3,88.24 142.3,86.34 143,85.64 143,83.7 v2(142.41,83.1)
  BOTTOM w0.076: UC1.L7 142.14,82.83 v2(142.41,83.1)
  BOTTOM w0.102: UV7.3 116.93,106.03 117.15,105.82 v2(117.18,105.82)
CPU_DP2_N0: length 20.3
  IN3 w0.135: v2(116.83,101.38) 116.83,100.71 118.06,99.49 118.06,95.85 117.2,94.99 117.2,93.84 117.52,93.52 117.71,93.52 v2(117.93,93.3)
  BOTTOM w0.076: v2(117.93,93.3) 117.93,93.38 117.6,93.71 117.48,93.71 117.27,93.5 117.27,91.42 117.57,91.11 117.57,89.01 117.66,88.92 117.66,88.49 117.64,88.48 117.61,88.38 117.61,88.19 117.64,88.1 117.64,87.85 117.57,87.61 117.57,87.06 117.45,86.93 117.34,86.93 117.33,86.94 117.18,86.94 117.11,87.01 117.11,87.21 UC1.C50
  BOTTOM w0.104: v2(116.83,101.38) 116.84,101.39 116.84,102.14 117.54,102.84 117.54,103.22 CV87.1
CPU_DP2_N0_C: length 4.4
  BOTTOM w0.104: UV7.7 115.33,106.38 115.43,106.28 115.43,105.72 116.06,105.09 116.85,105.09 117.55,104.4 117.55,104.25 CV87.2
CPU_DP2_N1: length 19.8
  IN3 w0.076: v2(116.21,89.36) 116.09,89.24 116.09,89.06 116.19,88.96 116.68,88.96 116.82,89.09 116.82,95.43 117.35,95.96 117.35,96.06 117.33,96.08 117.33,96.13 117.3,96.16 117.3,96.17
  IN3 w0.135: 117.3,96.17 117.3,97.86 117.01,98.15 117.01,99.2 115.98,100.23 115.98,101.01 v2(115.64,101.35)
  BOTTOM w0.076: v2(116.21,89.36) 116.21,89.48 116.15,89.54 115.9,89.54 115.88,89.56 115.83,89.56 115.76,89.48 115.76,89.42 115.81,89.36 115.81,89.1 115.84,89.08 115.84,88.79 115.82,88.77 115.82,88.51 115.88,88.39 115.88,88.24 115.82,88.05 115.82,87.88 115.86,87.76 115.95,87.66 116.07,87.66 116.16,87.57 116.16,87.39 UC1.C52
  BOTTOM w0.104: v2(115.64,101.35) 115.88,101.6 115.88,102.16 115.92,102.2 115.92,103.06 115.74,103.24 CV89.1
CPU_DP2_N1_C: length 4.4
  BOTTOM w0.104: CV89.2 115.89,104.17 115.89,104.31 115.79,104.42 115.07,104.42 114.62,104.86 114.62,104.9 114.23,105.29 114.23,106.19 114.13,106.29 UV7.10
CPU_DP2_N2: length 18.4
  IN3 w0.076: v2(115.74,91.52) 116.12,91.14 116.17,91.14 116.36,91.33 116.36,95.14 115.97,95.52 115.97,96.13 115.94,96.16 115.94,96.17
  IN3 w0.135: v2(113.8,101.35) 113.8,100.82 114.93,99.69 114.93,98.68 114.94,98.68 114.94,98.62 115.94,97.61 115.94,96.17
  BOTTOM w0.076: v2(115.74,91.52) 115.74,91.48 115.96,91.27 116.78,91.27 117.23,90.82 117.23,89.07 116.92,88.76 116.92,88.53 117,88.46 117.13,88.46 117.21,88.53 UC1.A50
  BOTTOM w0.104: CV91.1 113.98,102.8 114.21,102.57 v4(114.21,101.96) 114.21,101.76 v2(113.8,101.35)
CPU_DP2_N2_C: length 4.3
  BOTTOM w0.104: CV91.2 114.3,103.79 114.3,104.17 v4(113.7,104.77) 113.03,105.44 113.03,106.19 112.93,106.29 UV7.13
CPU_DP2_N3: length 18.9
  IN3 w0.076: v2(116.04,89.9) 115.87,90.07 115.69,90.07 115.17,90.6 115.17,91.74 115.99,92.56 115.99,94.82 114.92,95.9 114.92,96.12 114.89,96.15 114.89,96.17
  IN3 w0.135: v2(112.6,101.35) 112.78,101.18 112.78,100.77 114.18,99.37 114.18,98.19 114.89,97.48 114.89,96.17
  BOTTOM w0.076: v2(116.04,89.9) 116.39,89.9 116.67,89.62 116.67,89.28 116.62,89.23 116.37,88.98 116.37,87.46 UC1.D51
  BOTTOM w0.104: v2(112.6,101.35) 112.78,101.53 v4(112.78,101.9) 112.78,102.13 112.7,102.21 112.7,102.34 CV93.1
CPU_DP2_N3_C: length 4.2
  BOTTOM w0.104: UV7.16 111.73,106.29 111.83,106.19 111.83,105.43 112.09,105.18 112.09,105.13 112.5,104.72 112.54,104.72 112.65,104.62 112.65,103.66 CV93.2
CPU_DP2_P0: length 20.2
  IN3 w0.135: v2(117.93,93.88) 117.81,93.76 117.62,93.76 117.44,93.94 117.44,94.89 118.3,95.75 118.3,99.59 117.07,100.81 117.07,101.03 v2(117.41,101.38)
  BOTTOM w0.076: v2(117.93,93.88) 117.41,93.88 117.1,93.57 117.1,91.34 117.4,91.04 117.4,88.93 117.48,88.85 117.48,88.52 117.44,88.41 117.44,88.16 117.48,88.07 117.48,87.88 117.42,87.72 117.41,87.7 117.27,87.6 117.11,87.6 116.93,87.43 116.93,86.94 UC1.D50
  BOTTOM w0.104: CV86.1 117.74,102.96 117.74,102.75 117.04,102.06 117.04,101.75 v2(117.41,101.38)
CPU_DP2_P0_C: length 4.4
  BOTTOM w0.104: UV7.6 115.73,106.37 115.67,106.3 115.67,105.82 116.16,105.32 v4(116.36,105.32) 116.91,105.32 CV86.2
CPU_DP2_P1: length 19.8
  IN3 w0.076: v2(115.46,89.21) 115.67,89.21 116.11,88.77 116.76,88.77 117,89.01 117,95.35 117.53,95.88 117.53,96.16 117.54,96.17
  IN3 w0.135: 117.54,96.17 117.54,97.96 117.25,98.25 117.25,99.3 116.22,100.33 v2(116.22,101.35)
  BOTTOM w0.076: UC1.D52 115.87,86.99 115.79,87.26 115.79,87.37 115.71,87.66 115.71,87.66 115.64,87.85 115.64,88.07 115.7,88.27 115.7,88.35 115.64,88.47 115.64,88.84 115.66,88.86 115.66,89.01 v2(115.46,89.21)
  BOTTOM w0.104: CV88.1 116.12,102.93 116.12,102.12 116.08,102.08 116.08,101.49 v2(116.22,101.35)
CPU_DP2_P1_C: length 4.4
  BOTTOM w0.104: UV7.9 114.53,106.29 114.43,106.19 114.43,105.37 v4(114.99,104.82) 115.19,104.62 115.87,104.62 116.09,104.39 116.09,104.17 CV88.2
CPU_DP2_P2: length 18.4
  IN3 w0.076: v2(115.76,90.96) 116.25,90.96 116.54,91.26 116.54,95.21 116.16,95.6 116.16,96.14 116.19,96.17
  IN3 w0.135: v2(114.37,101.35) 114.05,101.02 114.05,100.92 115.17,99.79 115.17,98.78 115.18,98.78 115.18,98.72 116.19,97.71 116.19,96.17
  BOTTOM w0.076: v2(115.76,90.96) 115.9,91.09 116.71,91.09 117.06,90.75 117.06,89.14 116.75,88.83 116.75,88.4 117,88.15 117.03,88.15 UC1.B50
  BOTTOM w0.104: CV90.1 114.42,102.43 114.42,101.68 114.37,101.64 v2(114.37,101.35)
CPU_DP2_P2_C: length 4.3
  BOTTOM w0.104: CV90.2 114.5,103.67 114.5,104.25 114.06,104.69 114.06,104.73 113.66,105.14 113.62,105.14 113.23,105.52 113.23,106.19 113.33,106.29 UV7.12
CPU_DP2_P3: length 18.7
  IN3 w0.076: v2(116.08,90.46) 115.88,90.26 115.77,90.26 115.35,90.68 115.35,91.66 116.17,92.49 116.17,94.9 115.1,95.98 115.1,96.12 115.13,96.15 115.13,96.17
  IN3 w0.135: 115.13,96.17 115.13,97.58 114.42,98.29 114.42,99.47 113.02,100.87 113.02,101.19 v2(113.19,101.35)
  BOTTOM w0.076: v2(116.08,90.46) 116.84,89.69 116.84,89.21 116.74,89.11 116.54,88.91 116.54,88.12 116.62,88.04 116.81,88.04 116.91,87.95 116.91,87.77 116.78,87.64 UC1.C51
  BOTTOM w0.104: v2(113.19,101.35) 113.01,101.53 113.01,102.2 112.91,102.3 112.91,102.45 CV92.1
CPU_DP2_P3_C: length 4.1
  BOTTOM w0.104: CV92.2 112.85,103.67 112.85,104.7 v4(112.46,105.09) 112.03,105.52 112.03,106.19 112.13,106.29 UV7.15
CPU_DP3_AUXN: length 1.2
  TOP w0.104: T1.1 118.58,84.33 118.58,84.8 v2(118.63,84.85)
  BOTTOM w0.076: UC1.G46 119.08,84.59 v2(118.63,84.85)
CPU_DP3_AUXP: length 2.8
  TOP w0.104: T2.1 117.97,84.11 118.24,84.38 118.24,85.09 v2(118.63,85.48)
  BOTTOM w0.076: UC1.F46 v2(118.63,85.48)
CPU_POPIRCOMP: length 19.1
  TOP w0.381: RC88.1 144.07,55.77 v2(144.07,57.3)
  IN1 w0.203: v2(135.95,69.36) 135.95,69.36 135.56,68.97 135.56,67.99
  IN1 w0.381: v2(144.07,57.3) 144.07,59.32 137.79,65.6 136.58,65.6 135.65,66.53 135.65,67.9 135.56,67.99
  BOTTOM w0.254: v2(135.95,69.36) 135.95,69.37 UC1.AT16
CPU_XDP_PRDY#: length 39.6
  IN3 w0.076: 109.19,94.71 109.24,94.71 109.64,94.31 109.64,92.94 110.09,92.48 110.09,91.43 111.08,90.45 112.42,90.45 v2(112.98,89.89)
  IN3 w0.135: v2(86.68,98.38) 87.58,99.27 89.96,99.27 90.36,99.68 96.89,99.68 97.7,98.86 98.68,97.89 99.1,97.89 102.58,97.89 103.77,96.7 105.99,96.7 106.48,96.21 107.54,96.21 109.05,94.71 109.19,94.71
  BOTTOM w0.076: v2(112.98,89.89) 113.32,89.54 113.32,88.99 113.17,88.84 113.17,88.47 113.21,88.4 113.21,88.19 113.2,88.16 113.2,88.13 113.18,88.12 113.17,88.1 113.17,87.85 113.19,87.81 113.23,87.65 113.31,87.37 113.31,87.26 113.39,86.99 UC1.D56
  BOTTOM w0.112: v2(86.68,98.38) 86.68,99.07 87.09,99.48 87.09,100.2 87.61,100.72 JXDP1.5
CPU_XDP_PREQ#: length 35.8
  IN3 w0.076: 109.19,94.44 109.26,94.44 109.48,94.22 109.48,92.87 109.87,92.48 109.87,91.36 111.14,90.09 v2(111.37,90.09)
  IN3 w0.135: v2(88.06,98.42) 88.33,98.42 88.64,98.11 97.75,98.11 98.21,97.65 98.58,97.65 102.48,97.65 103.67,96.47 105.89,96.47 106.4,95.96 107.46,95.96 108.98,94.44 109.19,94.44
  BOTTOM w0.076: v2(111.37,90.09) 111.4,90.06 111.4,87.48 111.43,87.44 111.43,87.17 111.13,86.86 UC1.D61
  BOTTOM w0.112: v2(88.06,98.42) 88.06,98.52 87.64,98.94 87.64,99.52 RC138.1 87.97,100.29 87.97,101.05 88.21,101.29 JXDP1.3
CPU_XDP_TCLK: length 58.2
  TOP w0.112: v2(110.49,91.96) 110.59,92.06 v2(110.59,92.76) v1(110.59,93.33)
  IN3 w0.084: v2(110.49,91.96) 110.96,92.43 110.96,93.52 109.83,94.65 109.83,95.67 109.56,95.94
  IN3 w0.135: 109.56,95.94 108.78,96.73 106.69,96.73 106.2,97.22 103.98,97.22 102.79,98.41 98.89,98.41 97.92,99.38 97.1,100.19 90.15,100.19 89.75,99.79 73.84,99.79 73.42,99.37 71.17,99.37 v2(70.15,98.35)
  BOTTOM w0.076: UC1.B61 110.92,88.17 110.92,88.39 110.86,88.51 110.86,88.77 111.04,88.94 111.04,89.53 110.42,90.14 110.42,91 110.17,91.25 110.17,91.65 v2(110.49,91.96) ; RC328.1 110.96,93.15 110.59,92.78 v2(110.59,92.76)
  BOTTOM w0.112: JXDP1.57 72.01,101.2 71.5,100.69 RC139.1 70.86,99.41 70.86,98.89 70.32,98.35 v2(70.15,98.35)
CPU_XDP_TDI: length 72.4
  TOP w0.112: UC8.6 62.62,102.52 62.5,102.63 61.17,102.63 60.58,102.05 60.47,102.05 60.45,102.03 59.95,102.03 59.93,102.05 59.77,102.05 59.31,101.59 59.31,100.81 RC134.1 59.96,100.16 60.57,100.16 61.2,99.52 61.2,99.35 v2(61.67,98.88)
  IN3 w0.076: v2(111.21,91.31) 112.29,91.31 112.44,91.45 112.44,94.2 111.52,95.11 111.52,95.81 111.16,96.17
  IN3 w0.135: v2(61.67,98.88) 62.26,98.29 63.29,98.29 64.88,99.88 73.2,99.88 73.62,100.3 89.53,100.3 89.94,100.71 97.32,100.71 98.13,99.89 98.15,99.88 103.04,99.88 104.63,98.29 108.7,98.29 110.25,96.74 110.59,96.74 111.16,96.17
  BOTTOM w0.076: v2(111.21,91.31) 111.56,91.31 111.9,90.96 111.9,88.92 111.82,88.84 111.82,88.16 111.98,88 111.98,87.52 111.84,87.37 111.84,87.37 111.69,87.22 UC1.D60
CPU_XDP_TDO: length 69.8
  TOP w0.112: UC8.3 64.12,103.07 RC135.1 65.58,104.54 65.58,104.87 65.89,105.17 v2(65.89,105.58)
  IN3 w0.076: v2(110.66,91.42) 110.76,91.42 111.01,91.67 112.15,91.67 112.27,91.79 112.27,94.05 111.01,95.3 111.01,95.83 110.67,96.17
  IN3 w0.135: v2(100.49,99.23) 100.9,99.64 102.95,99.64 104.53,98.06 108.6,98.06 110.28,96.38 110.46,96.38 110.67,96.17
  BOTTOM w0.076: v2(110.66,91.42) 110.63,91.4 110.63,91.28 110.61,91.26 110.61,90.19 111.21,89.59 111.21,88.7 UC1.A61
  BOTTOM w0.112: v2(100.49,99.23) 100.49,99.86 99.04,101.31 v1(99.04,101.82) 99.19,101.97 99.19,103.28 98.9,103.58 98.9,105.94 98.77,106.06 94.24,106.06 90.45,109.85 75.22,109.85 72.84,107.46 68.66,107.46 67.24,106.05 66.35,106.05 v2(65.89,105.58)
CPU_XDP_TMS: length 68.5
  TOP w0.112: v1(110.05,90.26) 111.01,90.26 111.47,90.73 v2(111.47,90.81) ; v2(62.28,98.88) 60.71,100.45 RC131.1 61.47,100.68 61.5,100.66 UC8.8
  IN3 w0.076: v2(111.47,90.81) 112.37,90.81 112.6,91.04 112.6,94.37 111.81,95.16 111.81,95.86 111.5,96.17
  IN3 w0.135: v2(62.28,98.88) 63.54,100.13 73.11,100.13 73.58,100.61 73.58,100.79 74.43,101.64 97.63,101.64 98.19,101.07 98.51,100.76 104.44,100.76 106.67,98.53 108.8,98.53 110.35,96.98 110.69,96.98 111.5,96.17
  BOTTOM w0.076: UC1.C60 111.69,88.06 111.66,88.09 111.66,88.91 111.74,88.98 111.74,90.54 v2(111.47,90.81)
CPU_XDP_TRST#: length 102.8
  TOP w0.112: UC8.11 63.62,98 RC136.1 63.25,98.14 59.97,98.14 57.91,100.2 57.91,103.53 57.19,104.25 57.19,105.65 56.63,106.2 56.63,106.21 55.41,107.44 55.41,111.27 v2(55.76,111.62)
  BOTTOM w0.076: UC1.C61 111.13,87.53 110.73,87.93 110.73,88.38 110.71,88.44 110.7,88.47 110.7,88.84 110.87,89.01 110.87,89.46 110.26,90.07 110.26,90.93 110.01,91.18 110.01,91.44 109.98,91.46 109.98,92.3 ; UC1.B59 111.99,88.23 111.99,88.77 112.07,88.85 112.07,91.03 111.44,91.66 111.15,91.66 110.87,91.94 110.87,92.15 110.7,92.32 110.01,92.32 109.98,92.3 ; 109.98,92.3 109.69,92.6 109.69,94.93 109.93,95.17 109.93,95.52 109.98,95.57 CC308.1 109.41,97.06 109.41,97.5
  BOTTOM w0.112: 109.41,97.5 109.41,98.05 108.87,98.6 106.74,98.6 102.75,102.59 101.9,102.59 v3(100.81,103.68) 100.29,104.2 100.29,104.58 100.29,105.07 99.83,105.52 99.83,106.22 99.33,106.72 94.45,106.72 90.54,110.64 74.14,110.64 71.86,108.35 68.94,108.35 67.08,106.49 63.99,106.49 58.36,112.12 56.26,112.12 v2(55.76,111.62)
CSI2_COMP: length 16.3
  TOP w0.102: RC3.1 134.26,98.77 v1(133.97,98.48) 133.58,98.09 133.58,97.52 137.2,93.9 137.2,86.74 v2(137.82,86.11)
  BOTTOM w0.254: UC1.E13 v2(137.82,86.11)
CSIN_ISL88738: length 3.6
  BOTTOM w0.203: PC927.1 60.51,88.75 60.97,89.21 PU901.14
  BOTTOM w0.254: PR910.2 PC925.2 60.51,88.36 PC927.1
CSIP_ISL88738: length 5.1
  BOTTOM w0.203: PU901.15 60.57,89.34 60.38,89.15 59.51,89.15 PC925.1
  BOTTOM w0.254: PC926.1 57.43,89.32 PR909.2 57.53,88.36 PC925.1
CSON_ISL88738: length 4.8
  BOTTOM w0.203: PR938.1 65.19,96.86 65.19,96.8 PC946.1 64.76,96.35 PC945.1 64.06,94.71 64.06,93.62 63.86,93.42 PU901.1
CSOP_ISL88738: length 5.6
  BOTTOM w0.102: PC945.2 v3(66.68,95.41)
  BOTTOM w0.203: PR937.1 65.61,95.48 PC945.2 65.67,95.07 PC942.1 64.42,93.82 64.42,93.26 64.17,93.02 PU901.2
CV2_ON: length 36.1
  TOP w0.102: v3(275.97,53.63) 275.97,53.37 276.93,52.42 276.93,51.8 RE539.2 277.7,51.15 v2(278.17,50.68)
  IN2 w0.102: v2(278.17,50.68) 279.17,51.67 280.25,51.67 281.27,50.65 281.27,44.29 280.35,43.37 280.35,31.34 278.26,29.25 275.21,29.25 v2(274.68,28.72)
  BOTTOM w0.102: v2(274.68,28.72) 274.15,28.19 JUSH1.3
CV2_ON_R: length 16.7
  TOP w0.102: RPE10.1 276.84,49.85 276.93,49.94 276.93,50.88 RE539.1 276.42,51.15 276.16,50.89 276.16,50.18 275.42,49.43 275.42,48.83 275.3,48.71 274.77,48.71 274.67,48.61 274.21,48.61 v2(274.02,48.42)
  TOP w0.107: v2(268.42,42.79) UE1.H8
  BOTTOM w0.102: v2(274.02,48.42) 273.62,48.03 273.62,45.63 272.49,44.49 271.35,44.49 271.06,44.79 270.56,44.79 270.4,44.63 270.4,44.23 270.14,43.97 269.87,43.97 269.64,43.74 269.64,43.43 269.38,43.17 269.06,43.17 268.68,42.79 v2(268.42,42.79)
DAT_TP_SIO_I2C_CLK: length 36.1
  TOP w0.102: CZ80.1 250.28,25.51 RZ22.2 250.39,26.26 250.61,26.04 RZ347.1 252.52,26.03 253.99,26.03 254.41,26.45 v1(254.41,27.65) 254.74,27.98 254.74,29.76 253.88,30.62 v2(253.88,30.86)
  TOP w0.107: UE1.C12 264.02,45.92 263.7,46.25 263.7,46.72 262.88,47.53 260.03,47.53 259.77,47.27 v2(259.77,47.26)
  BOTTOM w0.102: v2(253.88,30.86) 254.15,31.13 254.15,39.06 255.57,40.48 256.53,40.48 257.14,41.09 257.29,41.09 258.15,41.95 258.62,41.95 259.72,43.05 259.72,44.43 259.34,44.81 259.34,46.84 259.77,47.27 v2(259.77,47.26)
DAT_TP_SIO_R: length 5.3
  TOP w0.102: RZ18.2 249.59,26.49 RZ22.1 249.97,27.18 249.44,27.71 v3(249.44,27.97) 249.44,28.42 v2(249.47,28.45)
  BOTTOM w0.102: v2(249.47,28.45) 249.35,28.33 JKBTP1.8
DCIN1_EN: length 344.3
  TOP w0.102: v2(271.12,58.99) 271.58,58.99 271.86,58.71 UE2.12 ; v2(39.6,77.24) 39.9,77.24 41.16,78.5 42.03,78.5 42.88,77.66 42.88,76.74 44.03,75.58 45.47,75.58 45.95,76.07 45.95,76.79 46.84,77.68 46.84,79.05 47.35,79.56 47.35,82.8 PR1221.1
  IN2 w0.102: v2(39.6,77.24) 40.26,77.91 40.26,81.56 39.63,82.19 39.63,82.39 36.24,85.77 36.24,89.77 37.31,90.84 37.31,92.93 36.41,93.84 36.41,94.38 36.58,94.55 36.58,98.61 v2(35.91,99.28) ; v2(271.12,58.99) 269.99,58.99 267.85,61.13 252.75,61.13 244.09,52.47 241.71,52.47 240.35,51.11 210.69,51.11 191.26,70.54 190.68,70.54 189.95,71.27 189.95,73.35 187.15,76.15 186.5,76.15 177.95,84.7 177.95,86.35 179.35,87.75 179.35,91.07 177.46,92.97 177.46,95.1 176.68,95.88 176.68,97.83 172.27,102.24 172.27,102.95 164.33,110.89 160.22,110.89 153.61,117.49 90.57,117.49 88.54,115.46 81.24,115.46 79.18,117.52 57.29,117.52 56.31,116.55 56.31,115.33 53.27,112.29 38.76,112.29 38.42,111.94 37.48,111.67 36.68,111.67 34.35,109.34 v2(31.77,109.34)
  BOTTOM w0.102: v2(35.91,99.28) 35.91,99.28 34.93,99.28 30.53,103.68 30.53,108.1 v3(31.15,108.71) v2(31.77,109.34)
DCIN2_EN: length 298.8
  TOP w0.102: PR26.1 33.06,106.38 v2(32.64,105.96) ; v3(271.15,56.67) 271.44,56.96 v2(271.44,57.21) UE2.15
  IN2 w0.102: v2(271.44,57.21) 271.44,57.22 272.07,57.85 272.07,58.59 271.26,59.4 269.86,59.4 267.78,61.48 252.82,61.48 244.01,52.67 241.52,52.67 240.16,51.31 210.77,51.31 191.26,70.83 190.68,70.83 190.15,71.35 190.15,73.43 187.09,76.49 186.44,76.49 178.16,84.78 178.16,86.27 179.55,87.67 179.55,91.16 177.66,93.05 177.66,95.19 176.96,95.88 176.96,97.84 172.48,102.32 172.48,103.04 164.42,111.09 160.3,111.09 153.7,117.7 90.49,117.7 88.46,115.66 81.32,115.66 79.26,117.72 57.2,117.72 56.11,116.63 56.11,115.54 53.06,112.49 38.68,112.49 38.31,112.12 37.45,111.87 36.6,111.87 34.58,109.85 31.66,109.85 30.41,108.61 30.41,106.57 31.02,105.96 v2(32.64,105.96)
DCIN_ISL88738: length 5.1
  TOP w0.254: PR916.1 56.1,90.8 v2(56.45,91.15)
  BOTTOM w0.203: PC931.2 57.29,91.62 58.02,90.89 58.02,90.87 58.43,90.46 59.02,90.46 59.18,90.62 PU901.17
  BOTTOM w0.254: PC931.2 56.92,91.62 v2(56.45,91.15)
DDR_A_ACT#: length 72.9
  IN1 w0.076: v2(111.58,58.93) 108.39,55.73 107.9,55.73 105.88,53.71 105.88,53.63
  IN1 w0.188: v2(72.51,27.27) 71.44,28.33 71.44,31.33 70.78,31.98 70.78,35.66 85.63,50.51 103.02,50.51 105.88,53.37 105.88,53.63
  BOTTOM w0.076: v2(111.58,58.93) 112.63,59.97 112.63,62.66 114.7,64.73 114.7,65.56 114.49,65.76 114.49,66.13 114.51,66.16 114.54,66.24 114.54,66.36 114.46,66.62 arc(114.38,66.8) UC1.BA55
  BOTTOM w0.183: v2(72.51,27.27) 73.26,27.27 74.57,25.96 JDIMM1.114
DDR_A_ALERT#: length 78
  IN1 w0.076: v2(116.26,63.37) 116.24,63.39 114.75,63.39 113.69,62.32 111.33,62.32 111.25,62.25 111.25,61.62 111.38,61.5 111.75,61.5 112.27,60.97 112.27,57.69 109.99,55.4 108.4,55.4 107.04,54.05 107.04,53.63
  IN1 w0.188: 107.04,53.63 107.04,52.88 103.51,49.34 86.12,49.34 72.1,35.33 72.1,34.01 72.63,33.48 72.63,32.25 72.93,31.95 72.93,29.22 v2(72.51,28.79)
  BOTTOM w0.076: v2(116.26,63.37) 116.52,63.63 116.52,64.49 117.19,65.17 117.19,65.65 117.01,65.83 117.01,66.09 117.06,66.21 117.06,66.38 117.05,66.4 116.99,66.6 116.99,66.69 117.05,66.85 117.05,67.09 117.05,67.1 117.01,67.19 117.01,67.29 117,67.37 117,67.72 UC1.AW50
  BOTTOM w0.183: JDIMM1.116 75.07,26.22 v2(72.51,28.79)
DDR_A_BA0: length 71.9
  IN1 w0.076: 116.43,53.63 116.43,53.99 118.31,55.87 118.31,63.36 117.16,64.51 117.16,65.63 116.77,66.02 116.77,68.52 v2(115.89,69.4)
  IN1 w0.188: v2(85.29,27.46) 84.52,27.46 84.39,27.59 84.39,34.81 87.31,37.72 90.11,37.72 90.38,37.99 90.38,38.95 90.63,39.2 106.27,39.2 116.43,49.36 116.43,53.63
  BOTTOM w0.076: UC1.AU52 116.19,69.1 v2(115.89,69.4)
  BOTTOM w0.183: JDIMM1.150 85.57,25.85 85.28,26.14 85.28,26.94 85.29,26.94 v2(85.29,27.46)
DDR_A_BA1: length 73.3
  IN1 w0.076: 117.37,53.63 117.37,54.18 118.64,55.46 118.64,63.5 117.49,64.65 117.49,65.77 117.1,66.16 117.1,69.22 117.36,69.48 v2(117.71,69.48)
  IN1 w0.188: v2(85.29,30.51) 85.71,30.93 85.71,34.09 85.9,34.28 85.9,34.81 87.87,36.79 94.25,36.79 94.44,36.98 94.44,38.02 94.62,38.21 95,38.21 95.19,38.02 95.19,36.98 95.38,36.79 95.82,36.79 96,36.98 96,38.08 96.19,38.27 96.51,38.27 96.71,38.07 96.71,36.98 96.9,36.79 97.2,36.79 97.41,36.99 97.41,38.02 97.66,38.27 106.66,38.27 117.37,48.98 117.37,53.63
  BOTTOM w0.076: v2(117.71,69.48) 118.07,69.75 UC1.AT48
  BOTTOM w0.183: v2(85.29,30.51) 84.86,30.51 84.32,31.04 JDIMM1.145
DDR_A_BG0: length 73.5
  IN1 w0.076: v2(111.63,61.85) 112.38,61.85 113.47,60.75 114.26,60.75 114.46,60.55 114.46,60.09 114.25,59.88 113.99,59.88 113.53,59.42 113.53,58.48 110.12,55.07 109.32,55.07 108.21,53.96 108.21,53.63
  IN1 w0.188: 108.21,53.63 108.21,52.4 103.99,48.18 86.6,48.18 73.42,35 73.42,34.34 73.8,33.96 73.8,32.81 74.09,32.51 74.09,30.07 74.42,29.74 v2(74.56,29.74)
  BOTTOM w0.076: UC1.AY55 114.07,67.52 114.07,67.25 114.04,67.18 113.99,67.05 113.99,66.88 114.05,66.72 114.05,66.58 114.02,66.49 113.99,66.4 113.99,66.21 114.03,66.13 114.03,66.12 114.05,66.11 114.05,65.92 114.05,65.68 113.9,65.53 113.9,65.27 114.01,65.16 114.01,64.29 111.63,61.9 v2(111.63,61.85)
  BOTTOM w0.183: JDIMM1.115 74.82,32.22 73.94,31.34 73.94,30.36 v2(74.56,29.74)
DDR_A_BG1: length 72.4
  IN1 w0.076: v2(111.6,57.64) 111.6,57.35 109.81,55.57 108.05,55.57 106.35,53.86 106.35,53.63
  IN1 w0.188: 106.35,53.63 106.35,53.17 103.22,50.04 85.83,50.04 71.25,35.46 71.25,33.46 71.38,33.34 71.79,33.34 71.94,33.19 71.94,32.8 71.81,32.67 71.44,32.67 71.25,32.48 71.25,32.17 71.46,31.96 71.77,31.96 71.94,31.8 71.94,30.54 72.16,30.32 v2(72.51,30.32)
  BOTTOM w0.076: UC1.AY54 114.72,67.19 114.72,66.93 114.65,66.71 114.65,66.58 114.71,66.35 114.71,66.21 114.66,66.09 114.66,65.83 114.86,65.63 114.86,64.66 112.79,62.59 112.79,58.83 v2(111.6,57.64)
  BOTTOM w0.183: v2(72.51,30.32) 73.34,30.32 73.48,30.46 73.48,31.29 73.79,31.6 73.79,31.84 74.32,32.38 JDIMM1.113
DDR_A_CKE0: length 73.8
  IN1 w0.076: v2(111.6,60.4) 111.25,60.4 110.76,59.91 110.76,58.41 108.24,55.9 107.42,55.9 105.19,53.66
  IN1 w0.188: 105.19,53.66 105.18,53.66 102.73,51.2 85.35,51.2 70.09,35.95 70.09,35.53 69.96,35.4 69.79,35.4 69.6,35.21 69.6,33.94 69.79,33.75 69.9,33.75 70.09,33.56 70.09,33.18 69.9,33 69.79,33 69.6,32.81 69.6,32.01 69.73,31.88 69.94,31.88 70.17,31.65 70.17,31.12 69.6,30.55 69.6,30.09 69.79,29.9 70.19,29.9 70.63,30.34 v2(70.63,30.51)
  BOTTOM w0.076: v2(111.6,60.4) 111.23,60.4 110.83,60.8 110.83,62.24 112.69,64.1 113.13,64.1 113.52,64.49 113.52,64.63 113.52,64.96 113.36,65.12 113.36,65.76 113.33,65.79 113.33,66.09 113.33,66.09 113.45,66.34 113.45,66.34 113.46,66.35 113.6,66.49 UC1.BA56
  BOTTOM w0.183: JDIMM1.109 73.32,32.28 72.82,31.78 72.32,31.78 71.05,30.51 v2(70.63,30.51)
DDR_A_CKE1: length 73.6
  IN1 w0.076: 104.86,53.99 106.94,56.07 108.18,56.07 109.9,57.78 109.9,59.28 v2(111.63,61.02)
  IN1 w0.188: v2(70.63,28.22) 70.51,28.22 69.13,29.6 69.13,36.01 84.79,51.67 102.53,51.67 104.86,53.99
  BOTTOM w0.076: UC1.BB56 113.52,65.91 113.52,65.19 113.68,65.02 113.68,64.7 113.68,64.42 113.2,63.94 112.76,63.94 111.11,62.29 111.11,61.46 111.56,61.02 v2(111.63,61.02)
  BOTTOM w0.183: JDIMM1.110 73.57,25.62 73.1,26.09 72.76,26.09 v2(70.63,28.22)
DDR_A_CKE2: length 9.8
  BOTTOM w0.076: T3.1 112.33,60.48 112.15,60.48 111.99,60.64 111.99,61.25 111.86,61.37 111.43,61.37 111.27,61.53 111.27,62.22 112.83,63.77 113.27,63.77 113.85,64.35 113.85,65.09 113.74,65.2 113.74,65.6 113.88,65.75 113.88,66.04 113.86,66.09 113.83,66.17 113.82,66.18 113.82,66.4 113.88,66.6 113.88,66.69 113.83,66.85 113.83,67.1 113.84,67.12 113.86,67.18 113.86,67.44 113.6,67.71 UC1.AW56
DDR_A_CKE3: length 8.8
  BOTTOM w0.076: T4.1 110.67,60.55 110.67,62.31 112.63,64.27 113.06,64.27 113.35,64.56 113.35,64.85 113.17,65.04 113.17,66.12 113.19,66.17 113.19,66.17 113.33,66.53 113.33,66.82 113.6,67.08 UC1.AY56
DDR_A_CLK0: length 74.1
  IN1 w0.076: v2(114.96,69.4) 115.15,69.22 115.34,69.22 116.27,68.28 116.27,67.28 116.02,67.02 115.51,67.02 115.25,66.77 115.25,65.95 115.51,65.69 115.98,65.69 116.21,65.46 116.21,65 117.92,63.28 117.92,57.65 114.81,54.54 114.81,53.65 114.83,53.63
  IN1 w0.119: v2(81.62,29.68) 81.75,29.81 82.26,29.81 82.52,30.07 82.52,31.46 82.26,31.72 81.96,31.72 81.84,31.84 81.84,32.5 82.06,32.72 82.38,32.72 82.51,32.72 82.77,32.97 82.77,35.44 88.13,40.8 105.61,40.8 114.83,50.02 114.83,53.63
  BOTTOM w0.076: UC1.AT53 v2(114.96,69.4)
  BOTTOM w0.104: v2(81.62,29.68) 80.71,29.68 80.39,29.99 80.39,32.16 80.32,32.22 JDIMM1.137
DDR_A_CLK1: length 73.9
  IN1 w0.076: v2(114.01,69.39) 114.2,69.21 114.39,69.21 114.57,69.03 114.57,65.9 116.91,63.56 116.91,57.33 114.07,54.49 114.07,53.67 114.09,53.64 114.09,53.63
  IN1 w0.119: 114.09,53.63 114.09,50.33 105.3,41.54 87.82,41.54 82.02,35.75 82.02,33.74 81.09,32.81 81.09,28.65 80.53,28.08 80.53,27.86 80.96,27.43 81.31,27.43 81.62,27.74 v2(81.62,27.84)
  BOTTOM w0.076: v2(114.01,69.39) 114.48,69.75 UC1.AT55
  BOTTOM w0.104: v2(81.62,27.84) 81.4,27.63 80.98,27.63 80.74,27.38 80.74,25.9 80.57,25.74 JDIMM1.138
DDR_A_CLK#0: length 74.1
  IN1 w0.076: v2(114.97,68.71) 114.97,68.93 115.08,69.04 115.26,69.04 116.1,68.21 116.1,67.35 115.94,67.2 115.44,67.2 115.08,66.84 115.08,65.88 115.44,65.52 115.9,65.52 116.03,65.39 116.03,64.92 117.75,63.21 117.75,57.72 114.64,54.61 114.64,53.65 114.62,53.63
  IN1 w0.119: v2(81.62,30.44) 81.62,30.2 81.79,30.03 82.17,30.03 82.3,30.16 82.3,31.37 82.17,31.5 81.87,31.5 81.62,31.75 81.62,32.59 81.97,32.94 82.37,32.94 82.38,32.94 82.42,32.94 82.55,33.06 82.55,35.53 88.04,41.02 105.52,41.02 114.62,50.12 114.62,53.63
  BOTTOM w0.076: UC1.AU53 115.42,69.04 v2(114.97,68.71)
  BOTTOM w0.104: v2(81.62,30.44) 81.62,30.22 81.28,29.88 80.79,29.88 80.59,30.08 80.59,32.05 80.82,32.28 JDIMM1.139
DDR_A_CLK#1: length 73.9
  IN1 w0.076: 113.87,53.63 113.87,53.64 113.89,53.67 113.89,54.56 116.74,57.4 116.74,63.48 114.39,65.83 114.39,68.95 114.31,69.03 114.08,69.03 114.01,68.95 v2(114.01,68.76)
  IN1 w0.119: 113.87,53.63 113.87,50.42 105.21,41.76 87.73,41.76 81.81,35.84 81.81,33.83 80.87,32.9 80.87,28.74 80.31,28.17 80.31,27.77 80.87,27.21 81.49,27.21 v2(81.62,27.08)
  BOTTOM w0.076: v2(114.01,68.76) 114.01,68.94 114.23,69.1 UC1.AU55
  BOTTOM w0.104: v2(81.62,27.08) 81.62,27.22 81.42,27.43 81.06,27.43 80.94,27.3 80.94,25.91 80.95,25.9 80.95,25.89 81.07,25.77 JDIMM1.140
DDR_A_CS#0: length 76.3
  IN1 w0.076: v2(119.54,69.4) 119.27,69.13 118.39,69.13 118.25,69 118.25,68.26 118.38,68.14 118.38,64.46 119.14,63.7 119.14,55.26 119.09,55.21 119.09,53.63
  IN1 w0.188: 119.09,53.63 119.09,48.26 107.46,36.64 106.67,36.64 106.48,36.45 106.48,35.65 106.29,35.46 105.89,35.46 105.77,35.59 105.77,36.45 105.58,36.64 105.23,36.64 105.03,36.44 105.03,34.8 104.84,34.61 104.49,34.61 104.25,34.85 104.25,36.45 104.06,36.64 103.73,36.64 103.5,36.4 103.5,34.82 103.29,34.61 102.01,34.61 101.55,35.07 93.74,35.07 93.29,34.61 90.68,34.61 90.14,35.16 88.85,35.16 88.24,34.55 88.24,34.01 87.38,33.15 87.38,30.32 86.88,29.81 v2(86.69,29.81)
  BOTTOM w0.076: v2(119.54,69.4) 119.84,69.1 UC1.AU45
  BOTTOM w0.183: v2(86.69,29.81) 86.05,30.45 86.05,31.33 85.32,32.06 JDIMM1.149
DDR_A_CS#1: length 78.7
  IN1 w0.076: v2(120.42,68.72) 120.42,68.71 120.61,68.53 120.61,66.36 120.88,66.08 120.88,54.77 120.95,54.7 120.95,53.63
  IN1 w0.188: v2(88.98,30.51) 89.53,30.51 89.76,30.73 89.76,32.26 90.13,32.63 106.7,32.63 107.38,33.31 107.63,33.31 108.31,32.63 108.61,32.63 109.1,33.11 109.1,33.38 108.46,34.02 108.46,34.28 108.72,34.55 108.97,34.55 109.61,33.91 109.89,33.91 110.3,34.32 110.3,34.83 109.48,35.65 109.48,36.02 110.32,36.86 110.67,36.86 111.36,36.17 111.63,36.17 111.98,36.52 111.98,36.79 111.29,37.47 111.29,37.74 111.54,37.99 111.81,37.99 112.49,37.3 112.76,37.3 113.03,37.57 113.03,37.84 112.29,38.57 112.29,38.84 112.56,39.11 112.83,39.11 113.56,38.38 113.82,38.38 114.09,38.65 114.09,38.91 113.4,39.6 113.4,39.87 113.67,40.14 113.96,40.14 114.6,39.49 114.95,39.49 120.95,45.49 120.95,53.63
  BOTTOM w0.076: v2(120.42,68.72) 120.9,69.06 UC1.AU43
  BOTTOM w0.183: v2(88.98,30.51) 88.6,30.89 88.6,31.02 87.57,32.05 87.57,32.13 87.32,32.38 JDIMM1.157
