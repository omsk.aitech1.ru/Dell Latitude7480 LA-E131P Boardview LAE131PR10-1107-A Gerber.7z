# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS4: length 77.2
  IN1 w0.124: v2(103.72,61.39) 103.72,61.32 103.35,60.95 102.98,60.95 102.72,60.69 102.72,59.68 102.47,59.43 101.46,59.43 100.01,57.97 81.25,57.97 71.45,48.18 71.45,47.25 60.72,36.52 60.72,35.6 60.99,35.32 60.99,34.85 60.72,34.58 60.72,33.75 60.99,33.48 60.99,32.09 60.46,31.56 60.46,30.06 60.32,29.93 60.14,29.93 v2(59.95,30.13)
  BOTTOM w0.076: UC1.AY64 109.21,67.42 109.17,67.38 109.05,67.38 108.96,67.29 108.87,67.11 108.87,66.82 108.91,66.74 108.91,66.53 108.86,66.42 108.86,66.2 108.91,66.09 108.91,65.83 108.71,65.64 108.71,64.93 107.84,64.06 105.21,64.06 104.46,63.3 104.46,61.22 104.33,61.1 103.79,61.1 103.72,61.17 v2(103.72,61.39)
  BOTTOM w0.112: JDIMM1.55 59.82,32.1 59.67,31.94 59.67,31.53 59.43,31.29 59.43,29.94 59.54,29.83 59.65,29.83 v2(59.95,30.13)
DDR_A_DQS5: length 78.5
  IN1 w0.076: v2(109.35,62.18) 109.35,62.03 109.59,61.79 109.79,61.79 109.88,61.89 109.88,62.15 109.5,62.54 109.2,62.54 108.33,61.67 108.33,58.83 106.47,56.97 104.65,56.97 103.35,55.66 103.35,55.63 103.34,55.62
  IN1 w0.124: v2(65.03,27.76) 65.22,27.95 65.22,28.16 65.34,28.28 65.55,28.28 65.87,28.61 65.87,30.69 65.43,31.14 65.43,35.54 83.84,53.95 101.67,53.95 103.34,55.62
  BOTTOM w0.076: v2(109.35,62.18) 109.35,62.01 109.48,61.88 109.68,61.88 109.81,62.01 109.81,62.66 111.73,64.59 111.73,64.65 111.73,64.98 112.05,65.3 112.05,65.56 111.89,65.71 111.89,66.13 111.9,66.16 111.94,66.24 111.94,66.36 111.91,66.44 111.89,66.5 111.89,66.77 111.93,66.85 111.93,67.07 111.87,67.2 111.76,67.31 111.69,67.31 111.66,67.27 111.66,67.17 UC1.BA60
  BOTTOM w0.112: JDIMM1.76 65.07,25.83 64.78,26.12 64.78,26.7 64.64,26.84 64.64,27.99 64.76,28.1 64.91,28.1 65.03,27.98 v2(65.03,27.76)
DDR_A_DQS6: length 50.8
  IN3 w0.076: 102.37,63.43 102.37,63.55 105.95,67.13 107.16,67.13 108.02,67.99 108.02,70.31 108.2,70.48 108.37,70.48 v2(108.56,70.67)
  IN3 w0.117: 102.37,63.43 102.37,63.23
  IN3 w0.124: 102.37,63.23 102.37,57.89 102.53,57.73 102.53,39.85 103.4,38.98 103.4,31.92 102.87,31.4 102.87,30.01 102.87,29.96 102.87,29.83 102.91,29.79 102.91,29.79 103.16,29.54 103.4,29.54 v2(103.57,29.36)
  BOTTOM w0.076: UC1.AR65 108.84,70.4 v2(108.56,70.67)
  BOTTOM w0.112: JDIMM1.221 103.32,32.03 104.19,31.16 104.19,29.83 104.08,29.71 104.08,29.71 103.91,29.55 103.76,29.55 v2(103.57,29.36)
DDR_A_DQS7: length 51.9
  IN3 w0.076: 111.02,67.97 111.04,67.99 111.04,68.19 110.77,68.45 110.77,70.27 110.93,70.43 111.04,70.43 111.29,70.67 v2(111.31,70.67)
  IN3 w0.112: 111.02,67.94 111.02,67.97
  IN3 w0.124: v2(108.99,27.84) 108.75,28.09 108.43,28.09 108.19,28.32 108.19,31.78 108.92,32.51 108.92,34.84 109.17,35.09 109.17,38.56 106.33,41.41 106.33,57.35 106.82,57.84 106.82,59.38 106.8,59.4 106.8,62.96 107.37,63.53 108.03,63.53 109.81,65.31 109.81,66.36 111.02,67.57 111.02,67.94
  BOTTOM w0.076: v2(111.31,70.67) 111.58,70.4 UC1.AR60
  BOTTOM w0.112: JDIMM1.242 108.57,25.76 108.45,25.89 108.45,26.14 108.55,26.24 108.55,27.89 108.66,28 108.84,28 v2(108.99,27.84)
DDR_A_DQS#0: length 88.2
  IN1 w0.124: v2(98.4,71.79) 98.51,71.79 98.73,72.01 98.73,72.13 98.6,72.26 94.67,72.26 89.79,67.38 82.35,67.38 81.68,66.71 79.52,66.71 49.91,37.1 49.91,34.87 49.66,34.62 49.12,34.62 49,34.5 49,34.12 49.12,34 49.58,34 49.88,33.7 49.88,33.03 49.51,32.65 48.81,32.65 48.56,32.4 48.56,29.71 48.69,29.58 48.87,29.58 49.21,29.93 49.21,30.11 v2(49.2,30.12)
  BOTTOM w0.076: v2(98.4,71.79) 98.47,71.86 98.57,71.86 98.71,71.72 98.71,71.61 99.09,71.23 102.06,71.23 102.74,71.9 103.07,71.9 103.64,72.47 104.56,72.47 104.66,72.38 104.66,72.38 105.02,72.38 105.16,72.43 105.27,72.43 105.4,72.38 105.67,72.38 105.75,72.41 105.97,72.41 106.11,72.34 106.11,72.23 106.03,72.14 UC1.AM70
  BOTTOM w0.112: JDIMM1.11 48.82,32.36 49.12,32.07 49.12,31.57 49.71,30.98 49.71,29.85 49.6,29.74 49.32,29.74 49.2,29.85 v2(49.2,30.12)
DDR_A_DQS#1: length 82.2
  IN1 w0.076: v2(101.76,66.86) 101.76,66.69 102.05,66.4 102.05,66.27 102.17,66.15 102.17,65.21 101.67,64.71
  IN1 w0.124: v2(54.3,27.79) 54.44,27.92 54.44,28 54.62,28.17 54.8,28.17 55.43,28.8 55.43,36.86 56.85,38.27 57.39,38.27 57.78,38.66 57.78,39.02 57.58,39.22 57.58,39.39 57.91,39.72 58.09,39.72 58.29,39.52 58.64,39.52 59.03,39.91 59.03,40.26 58.83,40.47 58.83,40.64 79.76,61.57 98.51,61.57 101.63,64.68 101.64,64.68 101.67,64.71
  BOTTOM w0.076: v2(101.76,66.86) 101.55,67.07 101.55,67.52 102.24,68.21 102.68,68.21 103.69,69.23 104.44,69.23 104.6,69.4 104.99,69.4 105.1,69.34 105.32,69.34 105.43,69.39 105.64,69.39 105.72,69.36 106.01,69.36 106.2,69.45 106.2,69.45 106.28,69.53 106.28,69.73 106.33,69.79 UC1.AT69
  BOTTOM w0.112: v2(54.3,27.79) 54.51,27.99 54.71,27.99 54.75,27.95 54.75,26.89 54.23,26.37 54.23,26.06 54.07,25.91 JDIMM1.32
DDR_A_DQS#2: length 65.7
  IN3 w0.076: 102.03,68.63 102.46,68.63 103.18,69.36 104.84,69.36 105.39,69.91 105.39,71.44 107.53,73.58 108.4,73.58 108.47,73.65 v2(108.47,73.78)
  IN3 w0.124: 102.03,68.63 101.37,68.63 100.49,67.75 100.49,65.96 98.51,63.98 98.51,62.82 98.4,62.72 97.35,62.72 97.08,62.44 97.08,61.94 97.33,61.69 98.38,61.69 98.49,61.58 98.49,61.29 98.39,61.18 98.16,61.18 97.86,60.88 97.86,41.92 97.72,41.78 97.53,41.78 97.28,41.53 97.28,41.1 97.5,40.89 97.73,40.89 97.86,40.76 97.86,40.47 97.74,40.35 97.53,40.35 97.28,40.1 97.28,39.67 97.53,39.42 97.73,39.42 97.86,39.29 97.86,39.04 97.73,38.91 97.54,38.91 97.28,38.66 97.28,38.17 97.53,37.92 98.01,37.92 98.16,37.78 98.16,37.56 98.01,37.41 97.57,37.41 97.28,37.13 97.28,36.76 97.57,36.48 97.62,36.48 97.62,36.47 98.01,36.47 98.16,36.32 98.16,36.11 98.01,35.96 97.67,35.96 97.41,35.69 97.41,35.29 97.66,35.03 98.04,35.03 98.16,34.91 98.16,31.31 98.06,31.21 97.96,31.21 97.68,30.94 97.68,28.49 97.99,28.18 98.29,28.18 98.47,28 v2(98.47,27.87)
  BOTTOM w0.076: UC1.AH66 v2(108.47,73.78)
  BOTTOM w0.112: JDIMM1.198 97.57,25.77 97.72,25.92 97.72,26.25 97.98,26.51 98.53,26.51 98.91,26.89 98.91,27.99 98.75,28.15 98.6,28.15 98.49,28.04 98.49,27.89 v2(98.47,27.87)
DDR_A_DQS#3: length 69.1
  IN3 w0.112: v2(101.15,75.29) 100.69,74.83
  IN3 w0.124: 100.69,74.83 100.58,74.72 95.42,74.72 89.93,69.23 89.93,63.57 94.06,59.44 94.06,51.24 93.18,50.36 93.18,48.61 93.49,48.3 93.49,47.86 93.18,47.56 93.18,46.94 93.49,46.63 93.49,46.19 93.18,45.88 93.18,45 93.49,44.69 93.49,44.25 93.18,43.95 93.18,33.26 93.06,33.14 92.83,33.14 92.53,32.84 92.53,32.44 92.81,32.16 93.36,32.16 93.49,32.03 93.49,31.79 93.36,31.66 93.01,31.66 92.67,31.32 92.67,29.87 92.94,29.6 93.18,29.6 v2(93.41,29.36)
  BOTTOM w0.076: v2(101.15,75.29) 101.38,75.05 101.38,74.62 101.61,74.4 103.89,74.4 103.89,74.4 104.99,74.4 105.13,74.35 105.3,74.35 105.43,74.4 105.64,74.4 105.72,74.37 106.01,74.37 106.19,74.45 106.2,74.45 106.44,74.7 UC1.AG69
  BOTTOM w0.112: JDIMM1.177 92.32,32.33 92.5,32.15 92.5,31.93 92.76,31.67 92.76,31.01 92.67,30.92 92.67,30.09 92.76,30 92.76,29.82 92.99,29.58 93.3,29.58 93.41,29.47 v2(93.41,29.36)
DDR_A_DQS#4: length 77.3
  IN1 w0.124: v2(103.72,60.73) 103.07,60.73 102.94,60.6 102.94,59.59 102.56,59.21 101.55,59.21 100.09,57.76 81.33,57.76 71.67,48.09 71.67,47.16 60.93,36.43 60.93,35.68 61.21,35.41 61.21,34.77 60.93,34.49 60.93,33.84 61.21,33.57 61.21,32 60.67,31.47 60.67,29.98 60.41,29.71 60.3,29.71 v2(59.95,29.36)
  BOTTOM w0.076: UC1.BA64 109.31,67.17 109.26,67.21 109.11,67.21 109.1,67.2 109.04,67.07 109.04,66.85 109.07,66.77 109.07,66.5 109.02,66.37 109.02,66.26 109.02,66.24 109.07,66.13 109.07,65.76 108.88,65.57 108.88,64.86 107.88,63.86 105.25,63.86 104.63,63.23 104.63,61.15 104.4,60.93 103.91,60.93 v2(103.72,60.73)
  BOTTOM w0.112: JDIMM1.53 59.32,32.1 59.46,31.96 59.46,31.61 59.22,31.37 59.22,29.85 59.45,29.62 59.69,29.62 v2(59.95,29.36)
DDR_A_DQS#5: length 78.6
  IN1 w0.076: v2(109.35,61.53) 109.44,61.62 109.85,61.62 110.05,61.82 110.05,62.22 109.56,62.7 109.13,62.7 108.17,61.74 108.17,58.9 106.4,57.13 104.58,57.13 103.23,55.78 103.2,55.78 103.18,55.77
  IN1 w0.124: v2(65.03,28.52) 65.49,28.52 65.66,28.69 65.66,30.61 65.22,31.05 65.22,35.63 83.76,54.17 101.58,54.17 103.18,55.77
  BOTTOM w0.076: v2(109.35,61.53) 109.53,61.71 109.76,61.71 109.98,61.93 109.98,62.59 111.9,64.52 111.9,64.72 111.9,64.72 111.9,64.91 112.22,65.23 112.22,65.67 112.06,65.83 112.06,66.09 112.11,66.21 112.11,66.35 112.09,66.43 112.08,66.49 112.06,66.53 112.06,66.74 112.09,66.82 112.09,67.11 112,67.29 111.76,67.54 UC1.AY60
  BOTTOM w0.112: v2(65.03,28.52) 64.81,28.3 64.67,28.3 64.44,28.07 64.44,26.75 64.57,26.62 JDIMM1.74
DDR_A_DQS#6: length 50.8
  IN3 w0.076: 102.58,63.43 102.58,63.53 106.02,66.96 107.23,66.96 108.19,67.92 108.19,70.24 108.27,70.31 108.56,70.31 108.64,70.23 108.64,70.12 v2(108.56,70.04)
  IN3 w0.112: 102.58,63.23 102.58,63.43
  IN3 w0.124: 102.58,63.23 102.58,57.98 102.75,57.82 102.75,39.93 103.61,39.07 103.61,31.83 103.09,31.31 103.09,30.01 103.09,29.96 103.09,29.91 103.25,29.75 103.45,29.75 103.57,29.87 v2(103.57,30.13)
  BOTTOM w0.076: UC1.AR66 108.33,70.4 108.56,70.17 v2(108.56,70.04)
  BOTTOM w0.112: v2(103.57,30.13) 103.52,30.07 103.52,29.86 103.63,29.75 103.82,29.75 103.99,29.91 103.99,31.07 102.82,32.24 JDIMM1.219
DDR_A_DQS#7: length 51.9
  IN3 w0.076: v2(111.31,70.04) 111.08,70.26 111,70.26 110.94,70.2 110.94,68.52 111.23,68.23 111.23,67.97
  IN3 w0.112: 111.23,67.97 111.23,67.94
  IN3 w0.124: 111.23,67.94 111.23,67.48 110.02,66.27 110.02,65.22 108.11,63.32 107.46,63.32 107.01,62.87 107.01,59.49 107.03,59.47 107.03,57.75 106.54,57.26 106.54,41.5 109.39,38.65 109.39,35 109.14,34.75 109.14,32.42 108.41,31.69 108.41,28.41 108.52,28.3 108.69,28.3 v2(108.99,28.6)
  BOTTOM w0.076: v2(111.31,70.04) 110.94,70.4 UC1.AR61
  BOTTOM w0.112: v2(108.99,28.6) 108.99,28.39 108.81,28.2 108.57,28.2 108.34,27.98 108.34,26.33 108.24,26.23 108.24,25.9 108.07,25.73 JDIMM1.240
DDR_A_MA0: length 71.8
  IN1 w0.076: 115.96,53.63 115.96,54.47 117.75,56.25 117.75,56.74 v2(117.8,56.79)
  IN1 w0.188: v2(82.91,27.42) 83.46,27.42 83.93,27.88 83.93,35 87.11,38.19 88.1,38.19 88.39,38.49 88.39,39.47 88.6,39.67 88.97,39.67 89.16,39.48 89.16,38.38 89.35,38.19 89.72,38.19 89.91,38.38 89.91,39.48 90.1,39.67 106.08,39.67 115.96,49.56 115.96,53.63
  BOTTOM w0.076: UC1.AY50 117.28,67.06 117.7,66.65 117.7,63.9 116.98,63.19 116.98,61.16 116.94,61.12 116.94,57.64 v2(117.8,56.79)
  BOTTOM w0.183: JDIMM1.144 82.07,26.71 82.48,27.12 82.61,27.12 v2(82.91,27.42)
DDR_A_MA1: length 70.9
  IN1 w0.076: v2(115.33,61.93) 116.57,60.68 116.57,57.47 112.95,53.85 112.95,53.63
  IN1 w0.188: 112.95,53.63 112.95,50.43 106.02,43.51 105.39,43.51 105.2,43.32 105.2,42.69 105.01,42.5 104.69,42.5 104.45,42.74 104.45,43.32 104.26,43.51 103.89,43.51 103.7,43.32 103.7,42.61 103.51,42.42 103.16,42.42 102.97,42.61 102.97,43.32 102.78,43.51 102.41,43.51 102.22,43.32 102.22,42.69 101.96,42.42 87.45,42.42 81.14,36.12 81.14,35.77 80.96,35.59 80.62,35.59 80.44,35.41 80.44,34.89 80.56,34.77 81.02,34.77 81.14,34.64 81.14,34.17 80.96,33.98 80.28,33.98 80.15,33.85 80.15,30.93 v2(79.73,30.51)
  BOTTOM w0.076: v2(115.33,61.93) 116.32,61.93 116.64,62.25 116.64,63.39 117.35,64.11 117.35,65.91 UC1.BB50
  BOTTOM w0.183: v2(79.73,30.51) 79.57,30.51 79.29,30.79 79.29,31.59 79.32,31.63 JDIMM1.133
DDR_A_MA2: length 73.4
  IN1 w0.076: 111.99,53.63 111.99,53.79 113.71,55.51 114.14,55.51 116.24,57.61 116.24,59.49 115.49,60.24 115.19,60.24 114.96,60.47 114.96,62.73 115.25,63.02 v2(115.76,63.02)
  IN1 w0.188: v2(79.73,27.46) 78.84,28.35 78.84,32.13 78.93,32.23 78.93,35.23 87.07,43.36 99.6,43.36 99.79,43.55 99.79,44.25 99.98,44.44 100.35,44.44 100.54,44.25 100.54,43.55 100.73,43.36 101.1,43.36 101.29,43.55 101.29,44.25 101.47,44.44 105.54,44.44 111.99,50.89 111.99,53.63
  BOTTOM w0.076: UC1.AY51 116.84,67.19 116.88,67.06 116.88,66.88 116.83,66.72 116.83,66.58 116.89,66.35 116.89,66.24 116.85,66.13 116.85,65.76 117.02,65.59 117.02,65.24 116.35,64.56 116.35,63.99 115.76,63.4 v2(115.76,63.02)
  BOTTOM w0.183: JDIMM1.132 79.07,26.8 v2(79.73,27.46)
DDR_A_MA3: length 70.8
  IN1 w0.076: v2(115.33,61.28) 116.41,60.2 116.41,57.54 114.2,55.34 113.77,55.34 112.46,54.03 112.46,53.63
  IN1 w0.188: 112.46,53.63 112.46,50.7 105.73,43.97 102.06,43.97 101.75,43.67 101.75,43.04 101.61,42.89 87.26,42.89 79.4,35.03 79.4,33.34 79.68,33.05 79.68,31.97 79.3,31.59 79.3,29.41 v2(79.73,28.98)
  BOTTOM w0.076: v2(115.33,61.28) 116.3,61.28 116.82,61.79 116.82,63.32 117.53,64.03 117.53,66.38 UC1.BA50
  BOTTOM w0.183: JDIMM1.131 78.82,29.89 v2(79.73,28.98)
DDR_A_MA4: length 70.8
  IN1 w0.076: 110.59,53.63 110.59,53.67 112.93,56 113.88,56 115.75,57.87 115.75,58.91 115.57,59.09 114.87,59.09 114.63,59.33 114.63,61.16 v2(114.12,61.67)
  IN1 w0.188: v2(77.91,27.46) 77.02,28.35 77.02,33.76 76.54,34.24 76.54,34.82 86.5,44.77 93.96,44.77 95.03,45.84 104.96,45.84 110.59,51.48 110.59,53.63
  BOTTOM w0.076: v2(114.12,61.67) 114.58,62.13 114.58,62.98 115.85,64.26 115.85,65.89 UC1.BB52
  BOTTOM w0.183: JDIMM1.128 78.07,25.88 78.35,26.16 78.35,27.02 v2(77.91,27.46)
DDR_A_MA5: length 72.1
  IN1 w0.076: 109.61,53.63 109.61,53.71 113.64,57.74 115.05,57.74 v2(115.33,58.03)
  IN1 w0.188: v2(76.56,28.98) 76.06,28.98 75.61,29.43 75.61,32.83 75.61,35.2 86.11,45.71 90.33,45.71 90.52,45.9 90.52,46.4 90.9,46.78 104.57,46.78 109.61,51.82 109.61,53.63
  BOTTOM w0.076: v2(115.33,58.03) 115.69,58.39 115.69,59.74 114.96,60.47 114.96,62.84 116.19,64.07 116.19,65.56 116.38,65.76 116.38,66.12 116.38,66.12 116.35,66.21 116.35,66.41 116.38,66.5 116.38,66.5 116.39,66.5 116.39,66.51 116.39,66.74 UC1.BA51
  BOTTOM w0.183: v2(76.56,28.98) 77.46,28.08 77.46,25.72 77.57,25.61 JDIMM1.126
DDR_A_MA6: length 71
  IN1 w0.076: v2(114.11,62.23) 114.54,62.23 114.79,61.97 114.79,60.4 115.12,60.08 115.42,60.08 116.08,59.43 116.08,57.68 114.07,55.67 113.06,55.67 111.53,54.13 111.53,53.63
  IN1 w0.188: 111.53,53.63 111.53,51.09 105.35,44.91 99.56,44.91 99.32,44.67 99.32,44.01 99.14,43.83 98.7,43.83 98.52,44.01 98.52,44.72 98.33,44.91 97.95,44.91 97.76,44.72 97.76,44.01 97.58,43.83 86.87,43.83 77.97,34.93 77.97,34.07 78.11,33.94 78.3,33.94 78.47,33.77 78.47,33.27 78.33,33.13 78.14,33.13 77.96,32.94 77.96,32.57 78.14,32.38 78.24,32.38 78.37,32.25 78.37,30.63 78.24,30.51 v2(77.91,30.51)
  BOTTOM w0.076: v2(114.11,62.23) 114.11,62.75 115.69,64.32 115.69,66.15 115.95,66.41 UC1.BA52
  BOTTOM w0.183: JDIMM1.127 77.82,32.19 78.33,31.68 78.33,30.93 v2(77.91,30.51)
DDR_A_MA7: length 73
  IN1 w0.076: 109.14,53.63 113.85,58.33 v2(114.11,58.33)
  IN1 w0.188: v2(76.56,27.46) 75.7,27.46 75.14,28.02 75.14,32.79 74.73,33.2 74.73,34.99 85.92,46.18 89.64,46.18 90.71,47.25 104.38,47.25 109.14,52.01 109.14,53.63
  BOTTOM w0.076: UC1.AW52 116.05,67.75 115.73,67.42 115.73,66.88 115.52,66.67 115.52,64.39 113.76,62.63 113.76,60.94 113.94,60.75 114.32,60.75 114.63,60.44 114.63,58.85 v2(114.11,58.33)
  BOTTOM w0.183: v2(76.56,27.46) 76.14,27.04 76.14,26.45 76.57,26.01 JDIMM1.122
DDR_A_MA8: length 73.1
  IN1 w0.076: v2(115.31,59.45) 115.78,59.45 115.91,59.33 115.91,57.75 114,55.84 112.99,55.84 111.06,53.9 111.06,53.63
  IN1 w0.188: 111.06,53.63 111.06,51.28 105.15,45.38 97.51,45.38 97.3,45.16 97.3,44.52 97.08,44.31 96.5,44.31 96.31,44.49 96.31,45.19 96.13,45.38 95.75,45.38 95.56,45.19 95.56,44.49 95.37,44.31 86.69,44.31 77.4,35.01 77.4,34.03 77.49,33.94 77.49,29.41 v2(77.91,28.98)
  BOTTOM w0.076: UC1.AY52 116.15,67.19 116.15,66.92 116.22,66.74 116.22,66.53 116.18,66.44 116.18,66.18 116.22,66.09 116.22,65.83 116.02,65.63 116.02,64.18 114.79,62.96 114.79,60.4 115.31,59.88 v2(115.31,59.45)
  BOTTOM w0.183: v2(77.91,28.98) 77.32,29.57 JDIMM1.125
DDR_A_MA9: length 70.8
  IN1 w0.076: v2(114.11,57.38) 113.51,57.38 110.12,53.99 110.12,53.63
  IN1 w0.188: 110.12,53.63 110.12,51.67 104.76,46.31 94.21,46.31 93.96,46.06 93.96,45.43 93.77,45.24 93.48,45.24 93.29,45.43 93.29,46.12 93.1,46.31 92.73,46.31 92.54,46.12 92.54,45.43 92.35,45.24 91.89,45.24 91.76,45.37 91.76,46.18 91.63,46.31 91.18,46.31 90.99,46.12 90.99,45.42 90.81,45.24 86.3,45.24 76.07,35.01 76.07,34.07 76.07,34.07 76.07,33.04 76.26,32.85 76.37,32.85 76.55,32.66 76.55,32.29 76.37,32.1 76.26,32.1 76.07,31.91 76.07,30.64 76.21,30.51 v2(76.56,30.51)
  BOTTOM w0.076: v2(114.11,57.38) 113.28,58.2 113.28,60.05 112.96,60.38 112.96,62.53 115.03,64.6 115.03,65.88 UC1.BB54
  BOTTOM w0.183: JDIMM1.121 76.32,32.2 76.14,32.01 76.14,30.93 v2(76.56,30.51)
DDR_A_MA10: length 73.9
  IN1 w0.076: v2(116.79,69.4) 116.93,69.26 116.93,66.09 117.33,65.7 117.33,64.58 118.47,63.43 118.47,55.76 116.9,54.19 116.9,53.63
  IN1 w0.188: 116.9,53.63 116.9,49.17 106.47,38.74 94.16,38.74 93.97,38.55 93.97,37.44 93.78,37.25 93.36,37.25 93.17,37.44 93.17,38.5 92.98,38.69 92.66,38.69 92.48,38.5 92.48,37.44 92.29,37.25 87.68,37.25 85.43,35.01 85.43,34.47 85.24,34.28 85.24,32.7 84.86,32.31 84.86,29.41 v2(85.29,28.98)
  BOTTOM w0.076: UC1.AT50 v2(116.79,69.4)
  BOTTOM w0.183: JDIMM1.146 84.57,25.7 84.13,26.15 84.13,28.12 84.69,28.68 84.99,28.68 v2(85.29,28.98)
DDR_A_MA11: length 72.6
  IN1 w0.076: 107.74,53.63 107.74,53.99 108.99,55.24 110.06,55.24 113.3,58.48 113.3,59.52 114.01,60.23 v2(114.1,60.23)
  IN1 w0.188: 107.74,53.63 107.74,52.59 103.8,48.65 86.4,48.65 72.95,35.19 72.95,34.15 73.33,33.77 73.33,32.54 73.63,32.24 73.63,28.42 73.82,28.22 v2(74.56,28.22)
  BOTTOM w0.076: v2(114.1,60.23) 114,60.23 113.41,60.82 113.41,62.75 115.19,64.53 115.19,66.16 114.92,66.42 UC1.BA54
  BOTTOM w0.183: JDIMM1.120 76.07,25.77 75.67,26.17 75.67,27.11 v2(74.56,28.22)
DDR_A_MA12: length 72.1
  IN1 w0.076: v2(114.11,59.49) 113.91,59.49 113.69,59.28 113.69,58.41 110.19,54.91 109.67,54.91 108.68,53.91 108.68,53.63
  IN1 w0.188: v2(74.56,31.27) 74.56,32.71 74.26,33.01 74.26,35.19 85.72,46.64 86.42,46.64 86.6,46.83 86.6,47.52 86.79,47.71 87.17,47.71 87.36,47.52 87.36,46.83 87.54,46.64 87.92,46.64 88.11,46.83 88.11,47.52 88.29,47.71 88.67,47.71 88.86,47.52 88.86,46.83 89.05,46.64 89.45,46.64 89.63,46.83 89.63,47.42 89.93,47.71 104.18,47.71 108.68,52.21 108.68,53.63
  BOTTOM w0.076: v2(114.11,59.49) 114.46,59.85 114.46,60.38 114.25,60.59 113.87,60.59 113.57,60.89 113.57,62.68 115.36,64.46 115.36,66.64 115.13,66.86 115.13,67.41 114.82,67.72 UC1.AW54
  BOTTOM w0.183: v2(74.56,31.27) 75.31,31.27 75.82,31.78 JDIMM1.119
DDR_A_MA13: length 76
  IN1 w0.076: v2(119.54,68.74) 119.54,65.93 120.04,65.42 120.04,62.44 119.69,62.09 119.69,55.55 120.25,54.99 120.25,53.63
  IN1 w0.188: 120.25,53.63 120.25,45.78 118.19,43.72 117.8,43.72 117.13,44.39 116.86,44.39 116.61,44.14 116.61,43.87 117.18,43.3 117.18,43.04 116.91,42.77 116.64,42.77 116.08,43.34 115.81,43.34 115.54,43.07 115.54,42.81 116.02,42.33 116.02,42.07 115.75,41.8 115.48,41.8 115.01,42.27 114.75,42.27 114.48,42.01 114.48,41.74 114.98,41.24 114.98,40.97 114.72,40.71 114.45,40.71 113.95,41.21 113.68,41.21 107,34.53 107,33.91 106.41,33.32 89.2,33.32 88.55,32.67 88.55,27.89 v2(88.98,27.46)
  BOTTOM w0.076: UC1.AU46 119.17,69.1 v2(119.54,68.74)
  BOTTOM w0.183: JDIMM1.158 87.57,26.05 v2(88.98,27.46)
DDR_A_MA14: length 71.5
  IN1 w0.076: v2(118.62,69.51) 118.54,69.51 118.09,69.07 118.09,68.19 118.21,68.07 118.21,64.39 118.97,63.64 118.97,55.32 118.39,54.74 118.39,53.63
  IN1 w0.188: v2(86.69,31.34) 86.69,33.44 87.3,34.05 87.3,34.89 88.26,35.85 91.82,35.85 92.36,35.31 93,35.31 93.46,35.76 99.5,35.76 99.83,36.09 99.83,37.15 100.01,37.33 100.36,37.33 100.55,37.15 100.55,35.95 100.74,35.76 101.11,35.76 101.3,35.95 101.3,37.15 101.49,37.33 101.86,37.33 102.05,37.15 102.05,35.95 102.24,35.76 102.62,35.76 102.8,35.95 102.8,37.15 102.99,37.33 107.18,37.33 118.39,48.55 118.39,53.63
  BOTTOM w0.076: UC1.AT46 118.86,69.75 v2(118.62,69.51)
  BOTTOM w0.183: v2(86.69,31.34) 85.82,32.2 JDIMM1.151
DDR_A_MA15: length 74.1
  IN1 w0.076: v2(118.62,68.77) 118.62,66.39 119.48,65.53 119.48,63.33 119.31,63.15 119.31,55.21 119.78,54.74 119.78,53.63
  IN1 w0.188: v2(86.75,26.7) 87.95,26.7 88.08,26.83 88.08,32.86 89.01,33.79 105.6,33.79 116.86,45.05 117.13,45.05 117.86,44.32 118.13,44.32 118.4,44.58 118.4,44.85 117.66,45.58 117.66,45.85 117.93,46.12 118.19,46.12 118.93,45.38 119.19,45.38 119.46,45.65 119.46,45.91 118.72,46.65 118.72,46.91 119.78,47.97 119.78,53.63
  BOTTOM w0.076: UC1.AU48 118.28,69.1 v2(118.62,68.77)
  BOTTOM w0.183: v2(86.75,26.7) 87.08,26.38 JDIMM1.156
DDR_A_MA16: length 72.5
  IN1 w0.076: 117.83,53.63 117.83,54.42 118.8,55.39 118.8,63.57 117.66,64.71 117.66,65.84 117.26,66.23 117.26,68.44 v2(117.55,68.73)
  IN1 w0.188: 117.83,53.63 117.83,48.78 106.85,37.8 99.55,37.8 99.36,37.61 99.36,36.51 99.17,36.32 98.8,36.32 98.61,36.51 98.61,37.61 98.42,37.8 98.08,37.8 97.88,37.6 97.88,36.52 97.68,36.32 88.07,36.32 86.83,35.08 86.83,34.34 86.18,33.69 86.18,28.8 v2(86.69,28.29)
  BOTTOM w0.076: v2(117.55,68.73) 117.25,69.03 UC1.AU50
  BOTTOM w0.183: JDIMM1.152 86.07,26.09 85.88,26.28 85.88,27.48 v2(86.69,28.29)
DDR_A_ODT0: length 76.6
  IN1 w0.076: 121.41,53.63 121.41,56.68 121.05,57.05 121.05,66.15 120.79,66.41 120.79,68.85 120.52,69.13 120.37,69.13 120.11,69.39 120.11,69.73 v2(120.48,70.1)
  IN1 w0.188: v2(88.98,28.98) 89.4,28.98 90.22,29.8 90.22,31.9 90.48,32.16 108.8,32.16 111.09,34.44 111.09,34.97 118.45,42.33 118.72,42.33 119.4,41.65 119.66,41.65 119.93,41.92 119.93,42.18 119.25,42.86 119.25,43.13 119.51,43.4 119.78,43.4 120.51,42.67 120.82,42.67 121.06,42.91 121.06,43.18 120.31,43.93 120.31,44.19 121.41,45.3 121.41,53.63
  BOTTOM w0.076: v2(120.48,70.1) 120.13,69.75 UC1.AT45
  BOTTOM w0.183: JDIMM1.155 86.82,32.14 88.14,30.82 88.14,29.83 v2(88.98,28.98)
DDR_A_ODT1: length 79.2
  IN1 w0.076: v2(120.46,69.54) 120.76,69.23 120.96,69.04 120.96,67.8 122.27,66.49 122.27,64.18 122.41,64.04 122.41,58.73 121.88,58.2 121.88,53.63
  IN1 w0.188: v2(90.65,30.55) 91.57,30.55 91.72,30.7 91.72,31.5 91.91,31.69 109.37,31.69 113.92,36.24 113.92,36.53 113.75,36.7 113.75,36.97 114.01,37.23 114.28,37.23 114.82,36.69 115.09,36.69 115.35,36.96 115.35,37.22 114.81,37.77 114.81,38.03 115.21,38.43 115.47,38.43 116.21,37.69 116.48,37.69 116.74,37.96 116.74,38.22 116.01,38.96 116.01,39.23 116.3,39.52 116.56,39.52 117.29,38.79 117.56,38.79 117.82,39.05 117.82,39.31 117.09,40.05 117.09,40.31 117.36,40.58 117.65,40.58 118.39,39.84 118.65,39.84 118.93,40.12 118.93,40.39 118.18,41.14 118.18,41.4 118.45,41.67 118.72,41.67 119.47,40.92 119.73,40.92 121.88,43.07 121.88,53.63
  BOTTOM w0.076: v2(120.46,69.54) 120.68,69.75 UC1.AT43
  BOTTOM w0.183: v2(90.65,30.55) 89.23,31.97 88.52,31.97 88.32,32.17 JDIMM1.161
DDR_A_PARITY: length 72.5
  IN1 w0.076: 115.5,53.63 115.5,54.99 118.14,57.64 118.14,63.29 117,64.44 117,65.56 116.6,65.96 116.6,68.18 115.5,69.29 115.5,69.66 v2(115.89,70.05)
  IN1 w0.188: 115.5,53.63 115.5,49.75 105.88,40.14 88.4,40.14 83.43,35.17 83.43,29.46 v2(82.91,28.94)
  BOTTOM w0.076: v2(115.89,70.05) 116.19,69.75 UC1.AT52
  BOTTOM w0.183: JDIMM1.143 81.82,32.19 82.32,31.7 82.32,29.4 82.48,29.24 82.61,29.24 v2(82.91,28.94)
DDR_B_ACT#: length 86.1
  IN3 w0.076: 110.47,62.32 110.47,63.21 113.65,66.39 113.65,71.4 113.88,71.63 114.61,71.63 v2(114.97,71.27)
  IN3 w0.183: v2(152.3,30.2) 152.22,30.2 149.73,27.71 123.87,27.71 118.81,32.78 118.55,32.78 113.29,38.04 113.29,39.79 109.48,43.6 109.48,56.13 110.47,57.13 110.47,62.32
  BOTTOM w0.076: UC1.AN53 115.42,71.67 v2(114.97,71.27)
  BOTTOM w0.183: v2(152.3,30.2) 152.9,29.61 152.9,29.5 153.67,28.72 JDIMM2.114
DDR_B_ALERT#: length 101
  IN3 w0.183: v2(153.32,30.44) 152.88,30 152.88,29.43 150.48,27.02 150.48,26.49 148.59,24.61 129.84,24.61 127.98,26.47 123.78,26.47 122.44,27.81 121.86,27.81 112.6,37.07 112.6,39.5 108.74,43.35 108.74,56.38 109.78,57.41 109.78,62.89 113.4,66.52 113.4,68.09 112.91,68.59 112.91,69.89 112.69,70.11 112.69,72.27 113.02,72.6 114.34,72.6 114.43,72.51 120.46,72.51 120.87,72.1 120.87,71.81 v2(121.37,71.31)
  BOTTOM w0.183: JDIMM2.116 154.17,29.2 153.81,29.56 153.81,29.96 v2(153.32,30.44)
  BOTTOM w0.254: UC1.AN43 120.97,71.7 v2(121.37,71.31)
DDR_B_BA0: length 84.1
  IN3 w0.076: 121,54.43 121,55.86 119.69,57.16 119.69,58.43 119.77,58.5 v2(120.04,58.5)
  IN3 w0.183: v2(163.41,31.98) 163.88,31.51 163.88,29.59 164.07,29.41 164.37,29.41 164.55,29.59 164.55,31.97 163.83,32.7 163.83,33.04 164.29,33.5 164.29,34.99 163.82,35.46 163.82,38.23 162.18,39.87 161.09,39.87 159.7,41.25 158.42,41.25 156.01,43.66 149.96,43.66 149.06,44.56 146.45,44.56 145.64,45.37 126.31,45.37 121,50.68 121,54.43
  BOTTOM w0.076: UC1.BB44 120.66,65.88 120.66,64.64 120.57,64.54 120.57,62.49 120.65,62.41 120.65,61.01 121.06,60.6 121.06,59.14 120.98,59.06 120.5,59.06 120.43,58.98 120.43,58.33 120.35,58.25 120.12,58.25 120.04,58.33 v2(120.04,58.5)
  BOTTOM w0.183: v2(163.41,31.98) 163.99,31.4 164.53,31.4 164.71,31.22 164.71,30.94 164.53,30.77 164.37,30.77 164.18,30.58 164.18,30.26 164.4,30.04 164.58,30.04 164.71,29.9 164.71,28.95 164.68,28.91 JDIMM2.150
DDR_B_BA1: length 86.1
  IN3 w0.076: 120.54,54.43 120.54,56.09 119.45,57.18 119.45,59.68 119.63,59.87 v2(120.04,59.87)
  IN3 w0.183: 120.54,54.43 120.54,50.49 126.12,44.91 145.45,44.91 146.26,44.1 148.87,44.1 149.77,43.2 155.82,43.2 158.23,40.79 159.51,40.79 161.23,39.07 161.49,39.07 161.76,39.34 162.05,39.34 162.3,39.09 162.3,38.83 162.01,38.55 162.01,38.29 162.26,38.04 162.54,38.04 162.81,38.31 163.07,38.31 163.36,38.02 163.36,37.77 163.08,37.48 163.08,37.23 163.36,36.94 163.36,35.27 163.83,34.8 163.83,33.69 163.64,33.51 v2(163.41,33.51)
  BOTTOM w0.076: UC1.BA44 120.5,66.37 120.5,64.71 120.4,64.62 120.4,62.36 120.48,62.28 120.48,60.75 120.56,60.67 120.75,60.67 120.85,60.57 120.85,60.42 120.78,60.35 120.49,60.35 120.41,60.27 120.41,60.12 120.49,60.04 120.82,60.04 120.9,59.96 120.9,59.37 120.8,59.28 120.61,59.28 120.54,59.35 120.54,59.63 120.46,59.71 120.21,59.71 v2(120.04,59.87)
  BOTTOM w0.183: JDIMM2.145 163.43,35.27 163.24,35.09 162.8,35.09 162.61,34.9 162.61,34.64 162.92,34.33 162.92,33.99 162.67,33.75 162.41,33.75 162.23,33.93 162.03,33.93 161.87,33.77 161.87,30.65 162.06,30.47 162.39,30.47 162.57,30.65 162.57,32.98 162.76,33.17 163.07,33.17 v2(163.41,33.51)
DDR_B_BG0: length 87
  IN3 w0.076: 113.19,62.32 113.19,62.74 115.07,64.62 115.07,68.17 115.38,68.49 115.38,70.2 115.86,70.67 v2(115.88,70.67)
  IN3 w0.183: 113.19,62.32 113.19,57.24 111.32,55.37 111.32,44.36 115.13,40.55 115.13,39.06 119.22,34.97 141.99,34.97 142.68,34.28 144.63,34.28 144.91,34 144.91,33.71 145.22,33.4 146.95,33.4 147.14,33.22 147.14,32.14 147.32,31.96 147.68,31.96 147.87,32.14 147.87,33.29 148.05,33.48 148.46,33.48 148.64,33.29 148.64,32.29 148.82,32.11 149.43,32.11 149.61,32.29 149.61,33.41 149.8,33.6 151.3,33.6 151.66,33.25 151.66,31.91 151.84,31.73 v2(152.3,31.73)
  BOTTOM w0.076: v2(115.88,70.67) 116.26,71.05 UC1.AP52
  BOTTOM w0.183: JDIMM2.115 153.93,35.32 152.83,34.23 152.83,32.26 v2(152.3,31.73)
DDR_B_BG1: length 86.3
  IN3 w0.076: v2(115.88,71.36) 116.26,70.98 116.26,67.92 115.46,67.12 115.46,64.48 113.65,62.68
  IN3 w0.178: 113.65,62.32 113.65,62.68
  IN3 w0.183: v2(152.3,33.25) 151.49,34.06 145.88,34.06 145.19,34.75 142.87,34.75 142.18,35.44 120.95,35.44 120.35,36.03 120.19,36.03 119.64,35.49 119.36,35.49 119.15,35.7 119.15,35.96 119.66,36.47 119.66,36.72 119.4,36.98 119.14,36.98 118.63,36.47 118.37,36.47 117.61,37.24 117.61,37.5 118.12,38.01 118.12,38.27 117.86,38.53 117.6,38.53 117.09,38.02 116.83,38.02 116.57,38.27 116.57,38.53 117.08,39.04 117.08,39.3 116.82,39.56 116.56,39.56 116.29,39.29 116.04,39.29 115.78,39.54 115.78,39.8 116.03,40.05 116.03,40.31 111.78,44.55 111.78,55.18 113.65,57.05 113.65,62.32
  BOTTOM w0.076: UC1.AN52 116.41,71.63 116.41,71.52 116.18,71.29 115.96,71.29 v2(115.88,71.36)
  BOTTOM w0.183: v2(152.3,33.25) 152.3,33.08 152.12,32.9 151.84,32.9 151.66,33.08 151.66,33.54 151.64,33.56 151.64,34.13 152.21,34.7 152.9,34.7 153.42,35.22 JDIMM2.113
DDR_B_CKE0: length 81
  IN3 w0.076: 112.5,62.32 112.5,62.67 113.74,63.9 113.74,65.78 114.57,66.62 114.57,70.73 v2(114.03,71.27)
  IN3 w0.183: v2(150.96,33) 150.96,32.83 150.32,32.18 150.32,32 149.59,31.27 147.03,31.27 145.59,32.71 144.93,32.71 144.27,33.37 142.2,33.37 141.28,34.28 118.68,34.28 114.44,38.52 114.44,40.26 110.63,44.07 110.63,55.65 112.5,57.52 112.5,62.32
  BOTTOM w0.076: UC1.AN56 v2(114.03,71.27)
  BOTTOM w0.183: JDIMM2.109 152.42,35.3 152.09,34.96 152.06,34.96 150.96,33.86 v2(150.96,33)
DDR_B_CKE1: length 81.1
  IN3 w0.076: 111.16,62.32 111.16,63.44 114.41,66.68 114.41,70.11 114.05,70.47 v2(114.05,70.61)
  IN3 w0.183: 111.16,62.32 111.16,56.84 110.17,55.84 110.17,43.88 113.98,40.07 113.98,38.33 118.62,33.69 118.87,33.69 124.16,28.41 147.46,28.41 147.77,28.72 148.27,28.72 149.14,29.59 150.36,29.59 150.72,29.95 v2(150.88,29.95)
  BOTTOM w0.076: UC1.AP55 114.51,70.99 v2(114.05,70.61)
  BOTTOM w0.183: JDIMM2.110 152.67,28.61 152.3,28.99 152.16,28.99 151.2,29.95 v2(150.88,29.95)
DDR_B_CKE2: length 1.2
  TOP w0.183: T5.1 115.4,71.52 v2(114.9,72.02)
  BOTTOM w0.076: v2(114.9,72.02) 114.58,71.7 UC1.AN55
DDR_B_CKE3: length 1.2
  TOP w0.183: T6.1 114.8,70.62 v2(114.96,70.62)
  BOTTOM w0.076: UC1.AP53 115.42,71 v2(114.96,70.62)
DDR_B_CLK0: length 82
  IN3 w0.076: 118.49,54.43 118.49,54.47 118.48,54.48 118.48,55.72 118.73,55.97 118.73,65.75 118.86,65.88 119.38,65.88 119.9,66.4 119.9,67.95 120.07,68.12 120.07,71.18 120.19,71.31 v2(120.45,71.31)
  IN3 w0.117: 118.49,54.43 118.49,49.64 125.27,42.86 144.6,42.86 145.41,42.05 147.92,42.05 148.82,41.16 154.97,41.16 157.77,38.36 157.94,38.36 158.33,38.74 158.67,38.74 159.68,37.73 159.68,37.39 159.29,37 159.29,36.83 159.58,36.55 159.74,36.55 160.13,36.94 160.47,36.94 161.06,36.35 161.06,32.9 160.83,32.66 160.72,32.66 v2(160.4,32.34)
  BOTTOM w0.076: UC1.AP45 120.25,71.31 v2(120.45,71.31)
  BOTTOM w0.104: JDIMM2.137 159.42,35.1 159.62,34.91 159.62,32.92 160.03,32.51 160.27,32.51 160.4,32.39 v2(160.4,32.34)
DDR_B_CLK1: length 81
  IN3 w0.076: v2(119.54,70.67) 119.29,70.92 119.17,70.92 119.09,70.84 119.09,70.83 119.02,70.76 119.02,70.12 119.16,69.98 119.16,67.06 118.32,66.22 118.32,56.5 117.76,55.94 117.76,54.43
  IN3 w0.117: v2(160.4,30.93) 160.4,30.86 160.22,30.67 159.64,30.67 159.49,30.82 159.49,31.28 160,31.78 160,35.09 159.93,35.16 159.93,35.16 154.67,40.42 148.51,40.42 147.61,41.32 145.1,41.32 144.29,42.13 124.96,42.13 117.76,49.33 117.76,54.43
  BOTTOM w0.076: UC1.AP46 v2(119.54,70.67)
  BOTTOM w0.104: JDIMM2.138 159.68,28.74 159.81,28.87 159.81,29.6 159.5,29.9 159.5,30.43 159.73,30.65 160.28,30.65 160.4,30.78 v2(160.4,30.93)
DDR_B_CLK#0: length 81.9
  IN3 w0.076: 118.28,54.43 118.28,54.44 118.29,54.45 118.3,54.45 118.3,54.45 118.3,54.5 118.31,54.51 118.31,55.79 118.56,56.04 118.56,65.82 118.79,66.05 119.31,66.05 119.73,66.47 119.73,68.02 119.9,68.2 119.9,71.45 119.79,71.56 119.64,71.56 119.54,71.46 v2(119.54,71.31)
  IN3 w0.117: v2(160.4,33.07) 160.59,32.87 160.74,32.87 160.85,32.99 160.85,36.26 160.38,36.73 160.22,36.73 159.83,36.34 159.49,36.34 159.08,36.75 159.08,37.09 159.47,37.48 159.47,37.64 158.58,38.53 158.41,38.53 158.03,38.14 157.69,38.14 154.88,40.95 148.73,40.95 147.83,41.84 145.32,41.84 144.51,42.65 125.18,42.65 118.28,49.56 118.28,54.43
  BOTTOM w0.076: UC1.AN45 119.6,71.31 v2(119.54,71.31)
  BOTTOM w0.104: v2(160.4,33.07) 160.4,32.82 160.29,32.71 160.11,32.71 159.82,33 159.82,34.99 159.93,35.1 JDIMM2.139
DDR_B_CLK#1: length 81
  IN3 w0.076: 117.55,54.43 117.55,54.43 117.57,54.46 117.57,54.5 117.59,54.52 117.59,56.01 118.15,56.58 118.15,66.29 118.99,67.13 118.99,69.91 118.85,70.05 118.85,70.83 118.92,70.9 118.92,71.04 118.65,71.31 v2(118.62,71.31)
  IN3 w0.117: v2(160.4,30.2) 160.15,30.46 159.55,30.46 159.28,30.73 159.28,31.36 159.79,31.87 159.79,35 159.72,35.07 159.72,35.07 154.58,40.21 148.42,40.21 147.53,41.11 145.02,41.11 144.21,41.92 124.87,41.92 117.55,49.25 117.55,54.43
  BOTTOM w0.076: UC1.AN46 v2(118.62,71.31)
  BOTTOM w0.104: v2(160.4,30.2) 160.4,30.34 160.3,30.45 160.28,30.45 160.28,30.45 159.81,30.45 159.7,30.34 159.7,29.98 160.01,29.68 160.01,28.97 160.18,28.8 160.18,27.9 JDIMM2.140
DDR_B_CS#0: length 81.6
  IN3 w0.076: v2(121.5,63.59) 120.31,63.59 120.04,63.33 120.04,62.61 119.64,62.2 119.64,61.64 119.75,61.53 120.65,61.53 120.78,61.4 120.78,58.78 121.96,57.6 121.96,54.83 122.15,54.64 122.15,54.43
  IN3 w0.183: 122.15,54.43 122.15,52.54 122.58,52.11 122.58,51.93 122.15,51.51 122.15,51.22 122.37,50.99 122.63,50.99 123.04,51.4 123.29,51.4 123.53,51.16 123.53,50.9 123.1,50.47 123.1,50.22 123.37,49.94 123.55,49.94 124.01,50.39 124.3,50.39 128.17,46.52 146.12,46.52 146.93,45.71 149.54,45.71 150.44,44.82 156.49,44.82 158.9,42.4 160.18,42.4 161.57,41.02 162.66,41.02 164.97,38.7 164.97,35.94 165.44,35.47 165.44,34.34 v2(165.24,34.14)
  BOTTOM w0.076: UC1.BB42 122.17,65.91 122.17,63.22 122.07,63.12 121.93,63.12 121.83,63.22 121.83,63.59 121.74,63.68 121.59,63.68 v2(121.5,63.59)
  BOTTOM w0.183: JDIMM2.149 164.43,34.75 164.08,34.41 164.08,32.29 164.28,32.09 164.57,32.09 164.69,32.22 164.69,34.02 164.82,34.14 v2(165.24,34.14)
DDR_B_CS#1: length 82.3
  IN3 w0.076: v2(121.87,62.23) 121.87,61.99 123.19,60.68 123.19,56.85 124.46,55.59 124.46,55.24 125.27,54.43
  IN3 w0.183: v2(167.51,33.52) 167.81,33.52 167.94,33.65 167.94,36.06 167.75,36.25 167.75,36.61 167.67,36.68 167.67,39.12 168.12,39.56 168.12,39.74 167.78,40.08 167.52,40.08 167.32,39.88 167.06,39.88 166.8,40.13 166.8,40.39 167,40.59 167,40.86 166.75,41.1 166.43,41.1 166.27,40.94 165.99,40.94 165.68,41.26 165.68,41.72 161.19,46.21 160.12,46.21 159.21,47.12 151.39,47.12 150.49,48.02 147.88,48.02 147.07,48.83 140.94,48.83 140.75,49.01 140.75,49.57 140.57,49.75 140.14,49.75 139.96,49.57 139.96,49.01 139.77,48.83 138.28,48.83 138.1,49.01 138.1,49.57 137.92,49.75 137.55,49.75 137.37,49.57 137.37,49.01 137.19,48.83 134.17,48.83 133.99,49.01 133.99,50.28 133.8,50.46 133.44,50.46 133.26,50.28 133.26,49.01 133.07,48.83 132.71,48.83 132.52,49.01 132.52,50.28 132.34,50.46 130.35,50.46 129.56,51.25 129.25,51.25 128.55,50.55 128.02,50.55 126,52.57 126,53.7 125.27,54.43
  BOTTOM w0.076: UC1.AY42 122.09,67.07 122.37,66.8 122.37,64.97 122.36,64.97 122.36,62.71 v2(121.87,62.23)
  BOTTOM w0.183: JDIMM2.157 166.43,35.33 167.09,34.67 167.09,33.94 v2(167.51,33.52)
DDR_B_D0: length 45.5
  IN1 w0.076: v2(124.08,57.43) 123.59,56.94 123.59,53.63
  IN1 w0.119: v2(126.07,29.29) 126.34,29.29 126.45,29.41 126.45,29.82 126.57,29.94 126.81,29.94 126.93,29.82 126.93,29.41 127.05,29.29 127.35,29.29 127.5,29.44 127.5,30.88 126.8,31.58 126.8,34.16 125.13,35.83 125.13,36 125.4,36.26 125.4,36.5 123.59,38.31 123.59,53.62 123.59,53.63
  BOTTOM w0.076: v2(124.08,57.43) 123.37,58.14 123.37,58.9 122.87,59.4 122.87,64.05 123.14,64.32 123.14,64.71 122.98,64.87 122.98,65.59 122.93,65.64 122.93,65.81 122.93,65.81 122.93,66.13 123,66.26 123,66.28 123.1,66.53 123.1,66.82 123.37,67.08 UC1.AY39
  BOTTOM w0.112: JDIMM2.8 127.18,28.89 126.78,29.29 v2(126.07,29.29)
DDR_B_D1: length 42.8
  IN1 w0.076: v2(124.08,63.39) 122.57,61.89 122.57,53.63
  IN1 w0.119: 122.57,53.63 122.57,35.86 126.07,32.36 v2(126.07,32.34)
  BOTTOM w0.076: UC1.AW39 124.02,67.94 124.28,67.67 124.28,67.1 124.3,67.06 124.3,66.88 124.24,66.72 124.24,66.58 124.31,66.36 124.31,66.24 124.26,66.13 124.26,65.75 124.46,65.55 124.46,63.78 v2(124.08,63.39)
  BOTTOM w0.112: JDIMM2.3 125.93,34.83 125.62,34.52 125.62,32.79 v2(126.07,32.34)
DDR_B_D2: length 44.7
  IN1 w0.076: v2(124.08,62.74) 124.44,62.74 124.86,62.33 124.86,53.63
  IN1 w0.119: 124.86,53.63 124.86,38.84 128.08,35.61 128.08,34.67 128.61,34.14 128.61,31.99 128.46,31.84 128.46,30.35 128.57,30.23 128.83,30.23 128.95,30.11 128.95,29.87 128.83,29.75 127.95,29.75 127.83,29.63 127.83,29.42 127.96,29.29 v2(129.34,29.29)
  BOTTOM w0.076: UC1.AY37 124.49,67.19 124.49,66.93 124.42,66.71 124.42,66.58 124.48,66.35 124.48,66.21 124.43,66.09 124.43,65.82 124.63,65.62 124.63,63.29 v2(124.08,62.74)
  BOTTOM w0.112: JDIMM2.16 129.18,29.13 v2(129.34,29.29)
DDR_B_D3: length 46.2
  IN1 w0.076: 125.19,53.63 125.19,55.5 125.09,55.6 125.09,59.07 125.51,59.49 v2(125.85,59.49)
  IN1 w0.119: v2(129.34,30.81) 129.34,30.69 129.2,30.55 128.91,30.55 128.79,30.67 128.79,31.7 128.95,31.85 128.95,34.47 128.83,34.59 128.69,34.59 128.58,34.7 128.58,34.87 128.7,34.99 128.77,34.99 128.89,35.11 128.89,35.28 128.74,35.42 128.54,35.42 128.42,35.54 128.42,35.75 125.89,38.28 125.89,38.44 126.25,38.8 126.25,38.97 126.08,39.14 125.91,39.14 125.56,38.78 125.39,38.78 125.22,38.95 125.22,39.12 125.58,39.48 125.58,39.65 125.19,40.03 125.19,53.63
  BOTTOM w0.076: v2(125.85,59.49) 125.12,60.22 125.12,65.62 125.12,66.64 124.9,66.86 124.9,67.41 124.59,67.72 UC1.AW37
  BOTTOM w0.112: v2(129.34,30.81) 129.71,30.81 130.18,30.35 JDIMM2.20
DDR_B_D4: length 43.6
  IN1 w0.076: 122.91,53.63 122.91,58.33 v2(124.08,59.49)
  IN1 w0.119: 122.91,53.63 122.91,38.04 123.72,37.23 123.72,36.99 122.91,36.17 122.91,36 123.11,35.8 123.28,35.8 124.13,36.65 124.3,36.65 124.49,36.47 124.49,36.3 123.63,35.44 123.63,35.28 123.93,34.98 124.1,34.98 124.44,35.32 124.61,35.32 124.76,35.17 124.76,35 124.42,34.66 124.42,34.49 124.59,34.32 124.76,34.32 125.1,34.67 125.27,34.67 125.43,34.51 125.43,34.34 125.08,33.99 125.08,33.83 125.25,33.66 125.42,33.66 125.76,34 125.93,34 v2(126.07,33.86)
  BOTTOM w0.076: UC1.BB39 123.37,65.75 123.31,65.69 123.31,65.01 123.47,64.85 123.47,64.02 123.22,63.77 123.22,60.34 v2(124.08,59.49)
  BOTTOM w0.112: v2(126.07,33.86) 126.93,34.72 JDIMM2.7
DDR_B_D5: length 44
  IN1 w0.076: 123.25,53.63 123.25,58.41 123.68,58.84 v2(124.08,58.84)
  IN1 w0.119: 123.25,53.63 123.25,38.17 124.96,36.47 124.96,36.3 124.67,36.01 124.67,35.81 126.46,34.02 126.46,31.45 127.16,30.74 127.16,30.55 126.99,30.38 126.82,30.38 126.31,30.89 126.14,30.89 v2(126.07,30.81)
  BOTTOM w0.076: v2(124.08,58.84) 123.04,59.88 123.04,63.96 123.31,64.23 123.31,64.78 123.15,64.94 123.15,65.66 123.1,65.71 123.1,66.09 123.22,66.34 123.22,66.34 123.23,66.35 123.37,66.49 UC1.BA39
  BOTTOM w0.112: v2(126.07,30.81) 125.63,30.37 125.63,29.13 126.18,28.58 JDIMM2.4
DDR_B_D6: length 45.5
  IN1 w0.076: v2(125.85,57.35) 125.58,57.35 125.5,57.28 125.5,56.01 126.05,55.46 126.05,53.81 125.86,53.63
  IN1 w0.119: 125.86,53.63 125.86,40.31 128.58,37.6 128.58,37.52 129.8,36.29 129.8,34.85 130.48,34.18 130.48,33.23 130.29,33.04 130.29,31.32 130.17,31.2 129.84,31.2 129.73,31.32 129.73,32.22 129.61,32.34 v2(129.34,32.34)
  BOTTOM w0.076: v2(125.85,57.35) 126.28,57.78 126.28,58.32 126.16,58.45 125.35,58.45 124.96,58.84 124.96,65.69 124.96,65.69 124.96,66.16 124.69,66.42 UC1.BA37
  BOTTOM w0.112: v2(129.34,32.34) 130.42,33.43 JDIMM2.21
DDR_B_D7: length 44
  IN1 w0.076: 125.53,53.63 125.53,55.68 125.33,55.87 125.33,57.9 125.49,58.06 v2(125.85,58.06)
  IN1 w0.119: v2(129.34,33.86) 129.61,33.59 129.61,33.37 129.74,33.25 130.02,33.25 130.14,33.37 130.14,34.04 129.22,34.96 129.22,35.2 129.46,35.44 129.46,35.63 129.34,35.75 129.18,35.75 129.12,35.69 128.95,35.69 128.84,35.81 128.84,35.98 129.16,36.3 129.16,36.47 128.99,36.63 128.82,36.63 128.5,36.31 128.33,36.31 128.16,36.48 128.16,36.65 128.48,36.97 128.48,37.14 128.31,37.31 128.14,37.31 127.82,36.99 127.65,36.99 127.46,37.19 127.46,37.36 127.81,37.71 127.81,37.88 127.22,38.47 127.05,38.47 126.7,38.12 126.53,38.12 126.37,38.27 126.37,38.45 126.73,38.8 126.73,38.97 125.53,40.17 125.53,53.63
  BOTTOM w0.076: UC1.BB37 124.69,65.79 124.79,65.69 124.79,58.63 125.36,58.06 v2(125.85,58.06)
  BOTTOM w0.112: v2(129.34,33.86) 129.51,33.86 129.87,34.22 129.87,34.73 129.42,35.18 JDIMM2.17
DDR_B_D8: length 45.2
  IN1 w0.076: 126.39,53.63 126.39,55.51 126.22,55.67 126.22,59.77 v2(125.85,60.14)
  IN1 w0.119: 126.39,53.63 126.39,40.53 129.1,37.81 129.1,37.74 130.33,36.51 130.33,35.07 131,34.4 131,33.01 130.82,32.83 130.82,29.97 130.7,29.85 130.01,29.85 129.89,29.73 129.89,29.41 130.01,29.29 v2(132.14,29.29)
  BOTTOM w0.076: UC1.AY35 125.92,67.19 125.92,66.92 125.99,66.74 125.99,66.53 125.95,66.44 125.95,66.18 125.99,66.09 125.99,65.52 125.78,65.31 125.78,64.27 126.41,63.64 126.41,61.36 126.24,61.18 126.24,60.53 v2(125.85,60.14)
  BOTTOM w0.112: v2(132.14,29.29) 132.17,29.26 JDIMM2.28
DDR_B_D9: length 46.4
  IN1 w0.076: 126.72,53.63 126.72,55.49 126.39,55.82 126.39,60.91 v2(125.85,61.44)
  IN1 w0.119: 126.72,53.63 126.72,40.67 129.34,38.06 129.51,38.06 129.65,38.2 129.82,38.2 130.2,37.82 130.2,37.65 130.02,37.46 130.02,37.29 130.66,36.65 130.66,35.21 131.34,34.54 131.34,32.87 131.15,32.69 131.15,31.58 131.27,31.46 131.63,31.46 131.75,31.34 131.75,31.1 131.63,30.98 131.27,30.98 131.15,30.86 131.15,30.55 131.27,30.43 131.99,30.43 132.14,30.58 v2(132.14,30.81)
  BOTTOM w0.076: v2(125.85,61.44) 125.29,62.01 125.29,65.55 125.29,65.55 125.29,66.67 125.5,66.88 125.5,67.42 125.82,67.75 UC1.AW35
  BOTTOM w0.112: JDIMM2.24 131.17,29.85 v2(132.14,30.81)
DDR_B_D10: length 45.5
  IN1 w0.076: 129.01,53.65 129.01,55.22 128.32,55.91 128.32,57.96 v2(127.63,58.65)
  IN1 w0.119: 129.01,53.65 129.01,43.03 131.89,40.14 131.89,39.84 133.86,37.88 133.86,37.53 133.61,37.28 133.61,33.74 134,33.35 134,31.56 134.12,31.44 134.42,31.44 134.54,31.32 134.54,31.08 134.42,30.96 134.12,30.96 134,30.84 134,30.6 134.12,30.48 134.65,30.48 134.83,30.66 v2(134.83,30.81)
  BOTTOM w0.076: UC1.AY33 127.05,67.08 127.32,66.81 127.32,66.47 127.37,66.36 127.44,66.22 127.48,66.13 127.48,65.76 127.35,65.64 127.35,65.64 127.3,65.58 127.3,65.31 127.52,65.09 127.52,63.96 128.14,63.34 128.14,59.16 v2(127.63,58.65)
  BOTTOM w0.112: v2(134.83,30.81) 135.26,30.39 135.26,29.18 135.67,28.76 JDIMM2.42
DDR_B_D11: length 44.6
  IN1 w0.076: v2(127.63,58.09) 128.15,57.57 128.15,55.78 128.67,55.26 128.67,53.63
  IN1 w0.119: 128.67,53.63 128.67,42.89 131.48,40.08 131.48,39.58 132.94,38.12 132.94,37.04 133.28,36.7 133.28,33.6 133.67,33.21 133.67,30.46 v2(134.83,29.29)
  BOTTOM w0.076: v2(127.63,58.09) 126.64,59.08 126.64,63.64 126.03,64.26 126.03,65.32 126.15,65.45 126.15,66.12 126.15,66.12 126.12,66.21 126.12,66.41 126.15,66.5 126.15,66.5 126.16,66.5 126.16,66.51 126.16,66.74 126.12,66.87 126.12,67.12 126.2,67.23 126.2,67.73 126.41,67.94 UC1.AW33
  BOTTOM w0.112: JDIMM2.38 134.67,29.13 v2(134.83,29.29)
DDR_B_D12: length 44.4
  IN1 w0.076: 127.06,53.63 127.06,55.46 126.55,55.96 126.55,61.39 v2(125.85,62.09)
  IN1 w0.119: v2(132.14,32.34) 132.07,32.34 131.95,32.22 131.95,32.02 131.81,31.88 131.6,31.88 131.49,31.99 131.49,32.55 131.67,32.73 131.67,34.68 131,35.35 131,36.79 130.47,37.32 130.47,37.43 130.65,37.61 130.65,37.85 129.84,38.65 129.67,38.65 129.53,38.51 129.36,38.51 129.2,38.67 129.2,38.83 129.74,39.38 129.74,39.55 129.56,39.73 129.39,39.73 128.85,39.18 128.68,39.18 127.06,40.81 127.06,53.63
  BOTTOM w0.076: v2(125.85,62.09) 126.25,62.49 126.25,63.57 125.62,64.2 125.62,65.42 125.62,65.42 125.62,65.88 UC1.BB35
  BOTTOM w0.112: JDIMM2.29 132.42,34.81 132.63,34.61 132.63,32.82 v2(132.14,32.34)
DDR_B_D13: length 44.6
  IN1 w0.076: 127.39,53.63 127.39,55.42 126.72,56.1 126.72,62.53 v2(125.85,63.39)
  IN1 w0.119: v2(132.14,33.86) 132.01,34 132.01,35.25 131.89,35.37 131.45,35.37 131.33,35.49 131.33,35.73 131.45,35.85 131.86,35.85 131.98,35.97 131.98,36.21 131.86,36.33 131.45,36.33 131.33,36.45 131.33,36.72 131.45,36.84 131.55,36.84 131.67,36.96 131.67,37.14 131.55,37.26 131.2,37.26 130.98,37.48 130.98,37.98 130,38.97 130,39.16 130.21,39.37 130.21,39.56 129.53,40.23 129.36,40.23 128.82,39.69 128.65,39.69 128.48,39.86 128.48,40.03 129.03,40.57 129.03,40.74 128.86,40.91 128.69,40.91 128.14,40.36 127.98,40.36 127.81,40.53 127.81,40.7 128.35,41.24 128.35,41.41 128.18,41.58 128.01,41.58 127.73,41.3 127.56,41.3 127.39,41.47 127.39,41.64 127.67,41.92 127.67,42.09 127.39,42.37 127.39,53.63
  BOTTOM w0.076: v2(125.85,63.39) 125.45,63.79 125.45,65.48 125.45,65.49 125.45,66.15 125.72,66.41 UC1.BA35
  BOTTOM w0.112: JDIMM2.25 131.42,34.58 v2(132.14,33.86)
DDR_B_D14: length 44.5
  IN1 w0.076: v2(127.63,62.19) 127.77,62.32 128.52,62.32 128.65,62.2 128.65,56.08 129.68,55.05 129.68,53.63
  IN1 w0.119: 129.68,53.63 129.68,43.3 132.73,40.25 132.73,39.96 132.92,39.77 133.22,39.77 133.41,39.58 133.41,39.28 133.6,39.09 133.89,39.09 134.05,38.93 134.05,38.64 134.24,38.45 134.53,38.45 134.69,38.29 134.69,38.09 134.57,37.97 134.57,37.94 134.57,37.94 134.57,37.62 134.57,37.61 134.57,37.56 134.69,37.44 134.74,37.44 134.79,37.39 134.81,37.39 134.91,37.29 134.91,37.08 134.79,36.96 134.4,36.96 134.28,36.84 134.28,36.6 134.4,36.48 135.14,36.48 135.26,36.36 135.26,36.11 135.14,35.99 134.4,35.99 134.28,35.87 134.28,35.63 134.4,35.51 135.14,35.51 135.26,35.39 135.26,35.12 135.14,35 135.03,35 134.91,34.88 134.91,34.56 135.03,34.44 135.36,34.44 135.55,34.24 135.55,33.97 135.23,33.65 135.02,33.65 v2(134.88,33.79)
  BOTTOM w0.076: UC1.BA33 127.05,66.49 127.19,66.35 127.19,66.34 127.2,66.34 127.31,66.09 127.31,65.83 127.14,65.65 127.14,65.24 127.34,65.04 127.34,62.48 v2(127.63,62.19)
  BOTTOM w0.112: v2(134.88,33.79) 134.88,33.82 134.42,34.27 JDIMM2.37
DDR_B_D15: length 43.4
  IN1 w0.076: v2(127.63,61.63) 127.82,61.63 128.48,60.96 128.48,55.98 129.34,55.12 129.34,53.64
  IN1 w0.119: 129.34,53.64 129.34,43.16 132.25,40.26 132.25,39.97 134.2,38.02 134.2,37.39 133.95,37.14 133.95,35.29 134.07,35.18 134.44,35.18 134.56,35.06 134.56,34.82 134.44,34.7 134.07,34.7 133.95,34.58 133.95,34.32 134.07,34.19 134.37,34.19 134.49,34.07 134.49,33.62 134.34,33.46 134.34,32.05 134.46,31.93 134.67,31.93 134.83,32.09 v2(134.83,32.34)
  BOTTOM w0.076: v2(127.63,61.63) 127.18,62.08 127.18,64.97 126.97,65.17 126.97,65.78 127.05,65.85 UC1.BB33
  BOTTOM w0.112: JDIMM2.41 135.42,32.93 v2(134.83,32.34)
DDR_B_D16: length 79.9
  IN3 w0.076: v2(122.35,68.69) 122.35,67.61 122.58,67.39 123.34,67.39 125.61,65.12 125.61,64.41 127.28,62.74 127.28,56.18 127.94,55.52 129.01,55.52 130.1,54.43
  IN3 w0.117: v2(170.42,29.49) 170.5,29.49 171.55,30.54 171.55,34.78 171.52,34.8 171.52,36.29 170.77,37.04 170.77,40.74 166.21,45.3 166.21,46.09 163.52,48.79 161.67,48.79 160.62,49.84 152.33,49.84 151.56,50.61 148.94,50.61 147.68,51.88 144.09,51.88 143.91,52.06 142.18,52.06 141.91,52.33 137.3,52.33 136.58,53.05 131.48,53.05 130.1,54.43
  BOTTOM w0.076: UC1.AU40 122.74,68.97 v2(122.35,68.69)
  BOTTOM w0.112: v2(170.42,29.49) 169.68,28.75 JDIMM2.170
DDR_B_D17: length 80.7
  IN3 w0.076: v2(122.31,69.4) 122.31,69.25 122,68.94 122,67.73 122.51,67.22 123.27,67.22 125.43,65.06 125.43,64.34 126.37,63.4 126.37,56.48 127.49,55.35 128.71,55.35 129.63,54.43
  IN3 w0.117: 129.63,54.43 131.34,52.72 136.44,52.72 137.16,52 141.77,52 142.05,51.72 143.77,51.72 143.95,51.54 147.54,51.54 148.81,50.27 151.43,50.27 152.19,49.51 160.48,49.51 161.53,48.46 163.38,48.46 165.88,45.95 165.88,45.16 170.44,40.6 170.44,36.9 171.19,36.15 171.19,34.66 171.22,34.64 171.22,31.93 170.42,31.13 v2(170.42,31.02)
  BOTTOM w0.076: v2(122.31,69.4) 122.65,69.75 UC1.AT40
  BOTTOM w0.112: JDIMM2.174 170.68,28.94 170.92,29.18 170.92,30.63 170.53,31.02 v2(170.42,31.02)
DDR_B_D18: length 81.7
  IN3 w0.076: v2(124.11,69.4) 124.11,69.33 124.49,68.95 124.49,67.41 128.81,63.08 128.81,56.76 130.05,55.52 131.05,55.52 131.88,54.69 132.48,54.69
  IN3 w0.117: 132.48,54.69 137.72,54.69 138.44,53.96 142.59,53.96 142.89,53.66 144.58,53.66 144.76,53.48 148.34,53.48 149.61,52.21 152.22,52.21 152.99,51.44 161.31,51.44 162.36,50.39 164.18,50.39 165.3,49.27 166.05,49.27 166.55,48.76 166.55,48.02 169.38,45.19 169.38,44.91 169.22,44.75 169.22,44.56 169.89,43.89 170.08,43.89 170.24,44.05 170.42,44.05 170.55,43.92 170.55,43.74 170.35,43.53 170.35,43.44 172.37,41.41 172.37,38.3 172.86,37.81 172.86,37.21 173.14,36.93 173.14,35.89 173.81,35.22 173.81,31.55 v2(174.2,31.17)
  BOTTOM w0.076: UC1.AT37 v2(124.11,69.4)
  BOTTOM w0.112: v2(174.2,31.17) 173.27,30.23 173.27,29.57 172.68,28.98 JDIMM2.182
DDR_B_D19: length 80.9
  IN3 w0.076: 131.88,54.45 130.98,55.35 129.98,55.35 128.65,56.69 128.65,63.01 124.11,67.55 v2(124.11,68.75)
  IN3 w0.117: v2(174.2,29.64) 173.48,30.36 173.48,35.08 172.81,35.75 172.81,36.8 172.53,37.07 172.53,37.67 172.04,38.16 172.04,41.27 168.73,44.58 168.73,44.71 168.92,44.9 168.92,45.08 168.8,45.21 168.61,45.21 168.45,45.05 168.27,45.05 168.12,45.2 168.12,45.39 168.27,45.54 168.27,45.72 168.12,45.87 167.93,45.87 167.84,45.78 167.67,45.78 167.48,45.96 167.48,46.61 166.22,47.88 166.22,48.63 165.91,48.93 165.17,48.93 164.04,50.06 162.19,50.06 161.14,51.11 152.86,51.11 152.09,51.88 149.47,51.88 148.2,53.14 144.62,53.14 144.44,53.33 142.75,53.33 142.45,53.63 138.3,53.63 137.48,54.45 131.88,54.45
  BOTTOM w0.076: UC1.AU37 v2(124.11,68.75)
  BOTTOM w0.112: JDIMM2.186 173.68,29.12 v2(174.2,29.64)
DDR_B_D20: length 81.5
  IN3 w0.076: v2(122.28,70.04) 121.93,69.69 121.93,69.22 121.83,69.12 121.83,67.66 122.46,67.04 123.22,67.04 125.26,64.99 125.26,56.8 125.7,56.36 126.25,56.36 127.42,55.19 128.4,55.19 129.16,54.43
  IN3 w0.117: 129.16,54.43 131.2,52.38 136.3,52.38 137.02,51.66 141.63,51.66 141.91,51.39 142.99,51.39 143.64,50.75 147.87,50.75 148.68,49.94 151.29,49.94 152.05,49.17 160.34,49.17 161.39,48.12 163.24,48.12 165.48,45.88 165.48,45.52 165.15,45.19 165.15,44.96 166.52,43.59 166.98,43.59 170.11,40.46 170.11,36.76 170.86,36.01 170.86,34.52 170.88,34.5 170.88,32.43 170.74,32.29 170.58,32.29 170.45,32.42 v2(170.45,32.53)
  BOTTOM w0.076: UC1.AR40 v2(122.28,70.04)
  BOTTOM w0.112: v2(170.45,32.53) 170.96,33.04 170.96,34.35 170.43,34.88 JDIMM2.173
DDR_B_D21: length 82.3
  IN3 w0.076: v2(122.28,70.67) 121.76,70.15 121.76,69.31 121.67,69.22 121.67,67.59 122.39,66.87 123.15,66.87 125.08,64.94 125.08,56.72 125.61,56.2 126.18,56.2 127.36,55.02 128.1,55.02 128.69,54.43
  IN3 w0.117: 128.69,54.43 131.07,52.05 136.16,52.05 136.88,51.33 141.5,51.33 141.77,51.06 142.86,51.06 143.5,50.41 147.73,50.41 148.54,49.6 151.15,49.6 151.91,48.84 160.2,48.84 161.25,47.79 161.85,47.79 162.13,47.5 162.14,47.5 162.23,47.42 162.38,47.42 162.75,47.79 162.96,47.79 163.09,47.66 163.09,47.5 162.71,47.12 162.71,46.93 162.89,46.76 163.1,46.76 163.47,47.13 163.68,47.13 163.8,47.02 163.8,46.85 163.39,46.44 163.39,46.25 163.52,46.12 163.7,46.12 164.15,46.57 164.32,46.57 164.45,46.44 164.45,46.27 164.02,45.84 164.02,45.62 164.15,45.49 164.33,45.49 164.59,45.75 164.78,45.75 164.91,45.61 164.91,45.44 164.64,45.18 164.64,45 166.38,43.26 166.84,43.26 169.78,40.32 169.78,36.62 170.53,35.87 170.53,34.14 v2(170.44,34.05)
  BOTTOM w0.076: UC1.AP40 v2(122.28,70.67)
  BOTTOM w0.112: v2(170.44,34.05) 170.44,34.38 169.43,35.4 JDIMM2.169
DDR_B_D22: length 83.2
  IN3 w0.076: v2(124.11,70.67) 124.11,70.67 124.66,70.12 124.66,69.25 124.84,69.07 124.84,67.52 129.14,63.22 129.14,56.89 130.19,55.85 131.35,55.85 132.11,55.08 138.06,55.08 138.51,54.63 139.8,54.63
  IN3 w0.117: v2(174.2,32.69) 174.66,33.15 174.66,35.31 173.81,36.17 173.81,37.21 173.53,37.49 173.53,38.26 173.31,38.48 173.22,38.48 173.1,38.59 173.1,38.83 173.22,38.94 173.31,38.94 173.43,39.06 173.43,39.3 173.31,39.42 173.22,39.42 173.1,39.53 173.1,39.77 173.22,39.88 173.31,39.88 173.43,40 173.43,40.23 173.31,40.35 173.22,40.35 173.1,40.47 173.1,40.7 173.22,40.82 173.31,40.82 173.43,40.94 173.43,42.08 171.93,43.58 171.76,43.58 171.55,43.37 171.36,43.37 171.23,43.5 171.23,43.68 171.39,43.84 171.39,44.12 167.22,48.29 167.22,49.04 166.33,49.93 165.58,49.93 163.4,52.11 153.27,52.11 152.5,52.87 149.88,52.87 148.61,54.14 146.03,54.14 145.85,54.33 143.17,54.33 142.86,54.63 139.8,54.63
  BOTTOM w0.076: UC1.AP37 v2(124.11,70.67)
  BOTTOM w0.112: JDIMM2.187 173.92,35.06 174.61,34.37 174.61,33.1 v2(174.2,32.69)
