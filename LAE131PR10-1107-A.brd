# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+0.9V_TBT_CIO: length 3
  BOTTOM w0.356: CT40.1 30.6,84.89 v2(30.56,84.86) 30.56,85.24 30.33,85.46 CT39.1
  BOTTOM w0.381: CT39.1 29.91,85.49 v2(29.91,86.16) 29.94,86.19 CT38.1
+0.9V_TBT_DP: length 2.9
  BOTTOM w0.381: v2(29.26,84.21) 29.16,84.11 CT25.1 ; CT27.1 28.65,86.2 v2(28.61,86.16) ; CT30.1 28.46,84.06 v2(28.61,84.21) 28.72,84.31 CT26.1
  vias: v2(31.21,86.81) v2(31.21,86.16) v3(32.11,86.68)
+0.9V_TBT_LVR_OUT: length 2.9
  BOTTOM w0.102: v2(24.51,92.17) 24.37,92.31 v3(24.37,92.63)
  BOTTOM w0.381: v2(27.31,88.76) v2(26.66,88.76) 26.04,88.76 CT61.1 ; CT62.1 26.85,86.08 27.31,85.63 v2(27.31,85.51)
  vias: v2(23.95,92.32) v2(27.96,86.16)
+0.9V_TBT_PCIE:
  vias: v1(29.15,89.31) v2(28.61,89.41) v2(28.61,88.76) v2(28.61,88.11) v2(28.61,87.46)
+0.9V_TBT_SVR:
  vias: v1(21,82.42) v2(17.66,76.68) v2(18.04,77.18) v2(18.16,78.58) v2(19.99,76.37) v2(26.01,88.11) v2(26.01,87.46) v2(26.01,86.81) v2(26.01,86.16) v2(27.96,85.51) v2(28.61,85.51)
+0.9V_TBT_USB: length 2.8
  BOTTOM w0.102: v3(32.12,89.68) CT32.1
  BOTTOM w0.254: CT33.1 30.09,88.11 v2(30.56,88.11) 31.1,88.65 CT32.1
+1.0V_AMPHYPLL: length 42.2
  TOP w0.254: v2(144.9,93.95) 144.9,93.2 145.9,92.2 149.76,92.2 150.01,92.45 v2(150.01,93.05) ; v2(161.47,87.42) 161.52,87.42 v1(162.48,88.38) 162.74,88.64 163.55,88.64
  TOP w0.508: CC264.1 137.91,82.94 v2(137.73,82.76)
  TOP w0.762: RC169.2 164.4,88.67 164.38,88.64 163.55,88.64
  IN1 w0.254: v2(137.73,82.76) 137.95,82.97 140.53,82.97 141.03,83.48 141.03,87.71 142.95,89.62 142.95,91.43 144.9,93.39 v2(144.9,93.95)
  IN2 w0.254: v2(150.01,93.05) 152.04,93.05 152.99,92.1 156.81,92.1 161.47,87.44 161.47,87.42 v2(161.47,87.42)
  BOTTOM w0.254: UC1.K15 137.73,82.84 v2(137.73,82.76) 137.73,82.68 UC1.L15
+1.0V_APLL: length 19.7
  TOP w0.305: LC2.2 147.86,96.24 CC314.1 147.08,95.89 147.26,95.72 147.26,94.99 146.82,94.56 v2(146.72,94.56)
  TOP w0.508: LC2.2 147.91,97.13 CC323.1
  IN1 w0.508: 143.17,81.29 143.47,81.58 143.47,83.18 143.87,83.58 143.87,85.1 143.46,85.51 143.46,87.15 144.95,88.64 144.95,91.83 146.72,93.6 v2(146.72,94.56)
  BOTTOM w0.254: UC1.V15 137.69,79.36 v2(137.69,79.45)
+1.0V_APLLEBB: length 32.6
  TOP w0.381: 134.43,80.28 135.11,80.96 v2(135.11,81.09)
  TOP w0.508: CC325.1 145.76,96.93 v2(145.61,97.08) 145.61,97.78 RC310.2 ; CC218.1 134.43,80.28
  IN2 w0.254: v2(135.11,81.09) 135.71,81.7 135.71,81.83 136.5,82.62 136.5,82.87 136.86,83.23 137.72,83.23 138.34,83.85 138.34,86.77 138.95,87.38 138.95,88.33
  IN2 w0.508: 138.95,88.33 138.95,88.91 140.22,90.17 140.22,98.01 141.37,99.16 145.77,99.16 146.28,98.65 146.28,97.76 v2(145.61,97.08)
  BOTTOM w0.254: UC1.N18 v2(135.11,81.09)
+1.0V_CLK1: length 12.6
  TOP w0.457: v2(141.41,93.2) 141.9,93.7 v1(141.9,95.92) 141.9,98.04 RC302.2
  BOTTOM w0.203: UC1.A14 137.72,88.3 137.72,89.11 137.97,89.35
  BOTTOM w0.254: 137.97,89.35 138.55,89.35 139.11,89.91 139.11,90.07 139.56,90.52 139.56,92.15 139.59,92.18 139.59,92.53 140.19,93.12 141.33,93.12 v2(141.41,93.2)
+1.0V_CLK2: length 19
  TOP w0.254: 134.7,84.96 134.67,84.93 134.67,83.97 v2(135.03,83.61)
  TOP w0.508: 135.6,86.6 136.64,87.65 136.64,93.64 v1(134.59,95.69) 132.4,97.87 CC220.1 130.58,99.28 RC170.2
  BOTTOM w0.254: v2(135.03,83.61) 135.03,83.42 UC1.K19
+1.0V_CLK3: length 23.2
  TOP w0.508: v2(133.99,97.86) 136.12,97.86 v3(136.26,98.01) 136.52,98.26 RC303.2
  IN1 w0.254: v2(133.82,82.78) 133.75,82.85 133.75,84.77 133.75,84.77 133.75,87.07
  IN1 w0.508: v2(130.02,90.47) 130.02,89.76 132.07,87.72 133.1,87.72 133.75,87.07
  IN2 w0.508: v2(130.02,90.47) 131.36,91.8 131.36,94.31 133.45,96.4 133.45,97.32 v2(133.99,97.86)
  BOTTOM w0.254: UC1.L21 133.82,82.77 v2(133.82,82.78)
+1.0V_CLK4: length 20.2
  IN1 w0.254: v2(137.87,94.16) 137.74,94.03 137.74,89.45 137.24,88.95 137.24,86.05 137.37,85.92 137.37,85.48 137.36,85.48 137.36,85.16 137.37,85.16 137.37,84.78 137.36,84.78 137.36,84.38 137.37,84.38 137.37,83.76 137.05,83.44
  BOTTOM w0.254: v2(133.12,81.08) 133.12,81.07 133.8,81.07 UC1.N20
  BOTTOM w0.508: v2(137.87,94.16) 137.69,94.34 137.46,94.34 v1(135.76,96.04) 134.7,97.1 134.7,98.18 CC226.1 134.33,99.03 RC173.2
+1.0V_CLK5: length 25.7
  TOP w0.508: RC52.2 134.2,82.18 v2(134.46,81.92)
  IN2 w0.254: v2(134.46,81.92) 135.08,82.54 135.08,82.7 135.74,83.35 136.48,83.35 136.71,83.58 137.11,83.58 137.37,83.84 137.37,86 137.11,86.25 137.11,87.39 137.66,87.94 137.66,89.26
  IN2 w0.508: 137.66,89.26 137.66,93.06 139.02,94.42 v2(139.02,98.13)
  BOTTOM w0.254: UC1.L19 v2(134.46,81.92)
  BOTTOM w0.508: v2(139.02,98.13) 139.49,98.13 140.1,98.74 CC221.1 139.98,99.02 v1(138.05,99.02) RC171.2
+1.0V_CLK6: length 10.3
  TOP w0.254: v2(140.02,89.07) 140.14,89.19 140.14,94.25 v3(140.27,94.39) 140.4,94.52 CC216.1
  TOP w0.508: CC216.1 140.4,97.43 RC300.2
  BOTTOM w0.203: v2(140.02,89.07) 140.19,88.89 UC1.A10
+1.0V_DTS: length 19.1
  TOP w0.508: v2(147.58,94.57) 147.77,94.75 RC301.2
  IN1 w0.508: v2(147.58,94.57) 147.58,92.83 147.26,92.5 147.26,89.1 146.69,88.53 146.69,85.44 145.19,83.94 145.19,81.59 145.86,80.92 146.78,80.92 v2(146.82,80.89)
  BOTTOM w0.102: v2(147.58,94.57) v3(148.16,94.57)
  BOTTOM w0.203: UC1.T1 145.28,80.56 146.61,80.56 146.82,80.76 v2(146.82,80.89)
+1.0V_MPHYAON: length 12.4
  TOP w0.508: 140.27,86.26 140.33,86.21 140.71,86.21 141.06,85.86 141.78,85.86 142.3,86.38 144.27,86.38 144.99,85.67 144.99,83.91 v2(145.79,83.11) ; 138.06,83.6 CC203.1 136.2,83.6 135.76,83.16 v2(135.76,82.71)
  BOTTOM w0.254: UC1.L1 v2(145.79,83.11) ; UC1.K17 136.09,83.13 v2(135.76,82.71)
  vias: v1(138.88,96.36) v2(137.76,100.51) v2(137.76,99.92) v2(138.34,100.51) v2(138.34,99.92) v2(138.92,100.51) v2(138.92,99.92)
+1.0V_MPHYGT: length 2.8
  BOTTOM w0.254: UC1.P15 137.08,80.97 v2(137.08,81.08) ; v2(137.71,81.92) 137.71,81.82 UC1.N15 ; UC1.P16 136.74,80.77 v2(136.43,81.08) 136.43,81.16 UC1.N17 ; v2(137.06,81.92) 137.06,81.83 UC1.N16
  vias: v1(149.67,89.95) v2(143.41,98.54) v2(143.42,97.97) v2(143.99,98.54) v2(144.03,97.96) v2(144.58,98.54) v2(144.6,97.96) v2(146.05,89.61) v2(146.08,88.91) v2(146.54,89.23) v2(146.65,89.79) v2(149.22,89.48) v2(149.2,88.71) v2(149.62,89.09) v2(149.61,88.31) v2(164.71,90.95) v2(165.27,90.94) v2(165.86,90.91) v2(166.18,90.44)
+1.0V_PRIM: length 37.2
  TOP w0.254: v2(135.76,80.24) v2(135.76,78.57)
  TOP w0.508: 148.29,93.9 145.88,93.9 144.38,95.4 CC225.1 ; CC206.1 133.84,77.69 134.46,77.07 v2(134.46,76.89)
  TOP w0.762: 130.18,102.84 128.3,104.72 118.63,104.72 117.22,103.3 112.86,103.3 111.89,102.34 111.89,100.34 v2(112.92,99.32)
  BOTTOM w0.254: UC1.AB17 135.85,77.55 UC1.Y18 v2(135.76,78.57) ; v2(133.22,73.55) 133.62,73.55 134.05,73.12 UC1.AK20 ; UC1.P18 v2(135.76,80.24) ; UC1.AB20 v2(134.46,76.89) UC1.AB19 v2(135.11,76.89)
  BOTTOM w0.508: RC216.1 112.77,99.47 v2(112.92,99.32)
  vias: v1(150.62,98.96) v2(136.53,104.26) v2(137.1,104.84) v2(137.1,104.26) v2(137.67,104.84) v2(137.67,104.26) v2(138.24,104.84) v2(138.26,104.27) v2(148.99,94.39) v2(149.28,95.46) v2(149.27,94.89) v2(149.56,94.4) v2(149.87,95.42) v2(149.91,94.84) v2(177.84,96.06) v2(177.87,96.73) v2(178.44,97) v2(178.41,96.42) v2(178.39,95.78) v2(178.4,95.12) v2(179.03,96.35) v2(179.02,95.69) v2(179,95.07) v2(179.07,97)
+1.0V_PRIM_CORE: length 2.6
  TOP w0.127: v1(162.21,93.41) 161.68,92.89 v2(161.68,92.89)
  TOP w0.508: v2(135.12,76.1) 135.11,76.1 135.01,76.21 CC205.1
  BOTTOM w0.254: v2(135.12,76.1) 135.12,76.09 ; 135.12,76.09 135.17,76.04 135.17,75.9 UC1.AF18 ; 135.12,76.09 135.12,76 134.79,75.66 UC1.AF19
  vias: v2(132.75,78.89) v2(132.91,79.85) v2(133.13,79.32) v2(133.07,78.44) v2(162.09,92.5) v2(162.5,92.12) v2(162.9,91.7)
+1.0V_PRIM_COREP: length 7.8
  BOTTOM w0.254: 171.38,104.64 169.98,104.64 v3(169.43,105.19) 167.48,107.14 167.48,108.49 168.18,109.19 PR423.2
+1.0V_PRIM_XDP: length 104.7
  TOP w0.508: 108.97,102.04 111.01,104.08 116.95,104.08 120.15,107.27 126.02,107.27 126.98,106.31 135.3,106.31 135.73,105.88 150.99,105.88 v1(151.69,105.18) 152.56,104.31 152.56,102.9 152.58,102.88 RC115.2 ; 108.97,102.04 107.72,103.29 101.32,103.29 100.05,102.02 93.76,102.02 v2(90.3,98.56) ; 108.97,102.04 108.97,100.87 109.48,100.37 110.52,100.37 112.39,98.5 113.14,98.5 113.68,99.03 v2(113.68,99.27)
  BOTTOM w0.305: JXDP1.44 75.91,103.93 76.21,103.63 JXDP1.43
  BOTTOM w0.356: CC28.1 114.43,100.44 RC216.2
  BOTTOM w0.381: CC29.1 88.85,99.66 88.34,99.15
  BOTTOM w0.508: 76.21,103.63 89.54,103.63 90.3,102.86 v2(90.3,98.56) 89.23,98.56 88.64,99.15 RC138.2 ; v2(113.68,99.27) 114.16,99.75 RC216.2
+1.0V_SRAM: length 3.7
  TOP w0.508: v2(133.81,76.05) 133.75,76.11 CC217.1
  BOTTOM w0.254: UC1.AF20 134.14,75.72 v2(133.81,76.05) 133.49,75.73 UC1.AF21 ; v2(147.16,97.08) 147.16,96.39 v3(147,96.23) ; UC1.T20 134.42,79.54 v2(134.42,79.43) 134.42,79.42 134.79,79.79 UC1.T19
  vias: v2(146.6,97.08)
+1.0V_VCCST: length 440.4
  TOP w0.254: v2(270.9,52.57) 271.46,52.01 RE59.2
  TOP w0.381: CC202.1 132.7,82.29 v2(133.16,82.76)
  TOP w0.508: v2(128.2,96.5) 128.21,96.5 131.68,96.5 133.95,94.23 133.95,89.99 134.69,89.26 v2(135.23,89.26) ; v2(240.68,33.88) 240.17,33.37 238.42,33.37 v2(237.22,34.57) 237.22,34.57 232.37,34.57 232.16,34.36 216.77,34.36 216.45,34.05 207.69,34.05 201.96,39.78 201.96,43.76 200.38,45.33 v1(200.38,47.02) 200.38,48.51 193.8,55.09 193.8,61.12 185.77,69.15 185.77,70.73 184.67,71.83 184.67,73.48 183.79,74.36 183.79,82.17 178.94,87.01 176.62,87.01 176.51,87.13 175.47,87.13 173.09,89.51 173.09,94.06 173.3,94.27 173.3,96.75 172.03,98.02 170.59,98.02 168.78,99.84 167.84,99.84 167.36,99.35 159.68,99.35 158.07,100.96 158.07,105.21 154.28,109 152.77,109 152.39,108.62 142.52,108.62 141.02,110.12 135.3,110.12 133.88,108.7 130.92,108.7 129.57,110.06 v2(129.42,110.06) ; v2(130.58,85.57) 130.58,86.07 129.86,86.8 129.86,87.54 v2(129.02,88.38)
  IN1 w0.254: v2(74.54,95.55) 74.11,95.12 74.11,94.73 74.38,94.46 74.38,93.78 74.55,93.61 74.55,92.17 74.04,91.66 70.3,91.66 69.49,90.86 69.49,89.48 69.03,89.02 69.03,88.74 67.31,87.03 67.31,77.63 65.86,76.18 65.86,74.3 65.85,74.41 65.85,73.61 65.86,73.6 65.86,73.11 65.85,73.1 65.85,72.3 66.41,71.74 66.66,71.74 67.38,71.02 67.38,69.63 v2(67.76,69.25)
  IN1 w0.508: v2(130.58,85.57) 130.58,84.91 131.39,84.11 132.25,84.11 133.16,83.2 v2(133.16,82.76)
  IN2 w0.254: v2(233.84,48.87) 234.28,49.31 243.69,49.31 249.91,55.52 256.25,55.52 256.37,55.64 263.65,55.64 263.89,55.88 266.94,55.88 267.36,55.45 268.36,55.45 270.9,52.91 v2(270.9,52.57)
  IN2 w0.508: v2(107.32,97.64) 107.32,97.75 108.12,98.55 111.64,98.55 111.82,98.37 120.7,98.37 v2(121.79,99.46) ; v2(74.54,95.55) 75.68,95.55 76.72,94.52 78.79,94.52 79.37,93.93 85.92,93.93 86.14,93.72 104.9,93.72 v2(105.37,94.19)
  IN3 w0.254: v2(67.76,69.25) 66.61,69.25 65.8,70.06 65.8,72.48 65,73.29 63.93,73.29 62,71.37 62,71.24 60.23,69.46 60.23,68.65 59.51,67.94 58.21,67.94 55.78,65.51 52.7,65.51 51.84,64.66 51.84,64.16 50.62,62.93 49.1,62.93 46.99,65.04 46.99,68.2 v2(46.48,68.71)
  IN3 w0.508: v2(129.42,110.06) 129.56,109.91 129.56,101.39 129.16,100.99 129.16,97.09 128.56,96.5 v2(128.2,96.5)
  BOTTOM w0.203: 135.51,89.26 v2(135.23,89.26) 135.23,88.29 UC1.A18
  BOTTOM w0.254: 135.51,89.26 135.89,89.64 135.89,90.68 136.19,90.98 CC195.1 ; v2(237.22,34.57) 236.72,35.07 231.31,35.07 229.82,36.56 223.63,36.56 222.4,37.79 222.4,42.95 221.11,44.25 221.11,46.4 223.58,48.87 v2(233.84,48.87) ; UC1.K20 134.11,83.18 134.03,83.25 133.66,83.25 133.58,83.18 UC1.K21 133.16,82.85 v2(133.16,82.76)
  BOTTOM w0.508: PR601.1 48.21,70.44 v2(46.48,68.71) ; PR601.1 PR604.1 PR605.1 ; PR601.1 48.47,70.78 48.9,71.21 PC602.1 ; RC218.2 74.92,95.93 v2(74.54,95.55) ; RZ151.2 133.33,94.34 136.07,94.34 136.82,93.59 136.82,92.3 136.43,91.91 CC195.1 ; v2(129.02,88.38) 129.02,89.08 128.69,89.41 128.69,91.47 127.72,92.44 127.72,95.78 128.2,96.27 v2(128.2,96.5) ; 128.01,109.58 127.91,109.58 126.31,107.98 126.31,105.27 124.89,103.85 123.57,103.85 121.79,102.08 v2(121.79,99.46) ; v2(240.68,33.88) 240.68,33.94 240.73,33.99 240.73,34.95 241.09,35.31 RE90.1
  vias: v2(128.76,110.07)
+1.0V_VCCST_C: length 0.5
  BOTTOM w0.102: 127.57,107.03 127.19,107.03 v1(127.13,107.09)
+1.0V_VCCSTG: length 115.6
  TOP w0.254: RC135.2 64.65,104.59 65.3,105.25 v2(65.3,105.6)
  TOP w0.457: v2(132.74,89.16) 131.93,89.16
  TOP w0.508: CC199.1 RC143.2 129.95,94.63 130.42,94.16 v2(130.42,92.04) 131,91.46 131,89.83 131.68,89.16 131.93,89.16 ; v2(124.59,103.09) 124.59,103.35 123.95,103.98 118.94,103.98 117.31,102.35 115.59,102.35 115.01,101.77 115.01,100.66 114.5,100.15 114.5,98.75 113.25,97.5 v2(113.09,97.5) 112.78,97.81 111.39,97.81 v2(111.3,97.9) 111.3,98.45 110.1,99.65 107.77,99.65 106.29,101.12 v1(105.54,101.12) 101.2,101.12 101.15,101.17 101.11,101.17 100.76,101.52 100.76,101.56 v2(100.65,101.67) ; RC134.2 60.17,101.57 60.68,101.57 RC131.2 61.1,101.59 v2(61.65,102.14)
  IN1 w0.508: v2(124.59,103.09) 125.54,103.09 125.88,102.75 128.65,102.75 130.57,100.83 130.57,98.56 v2(132.54,96.59)
  IN2 w0.254: v2(65.3,105.6) 65.3,105.75 64.81,106.24 63.02,106.24 62.22,105.44 v2(61.51,105.44)
  IN2 w0.508: v2(100.65,101.67) 98.07,101.67 96.53,103.22 76.91,103.22 75.51,101.82 71.35,101.82 70.63,102.54 62.04,102.54 v2(61.65,102.14)
  BOTTOM w0.203: UC1.A22 132.75,89.14 v2(132.74,89.16)
  BOTTOM w0.381: RC83.2 103.86,98.39 101.25,101.01 101.25,101.03 100.65,101.62 100.65,101.67 v2(100.65,101.67)
  BOTTOM w0.457: RC87.2 111.8,95.88 111.53,96.15 111.53,97.67 v2(111.3,97.9)
  BOTTOM w0.508: v2(61.65,102.14) 61.65,102.17 62.16,102.68 62.35,102.68 62.74,103.07 62.74,103.66 61.51,104.89 v2(61.51,105.44) ; RC130.2 112.4,97.5 v2(113.09,97.5) 113.29,97.31 RC82.2 ; RC81.2 111.8,94.66 RC87.2
+1.0V_VCCSTG_C:
  vias: v3(130.43,100.23)
+1.0V_VCCSTG_R: length 12.5
  TOP w0.254: v2(134.21,84.91) 133.75,85.37 133.75,88 133.25,88.5 133.25,93.85 v1(132.78,94.32) 131.58,95.52 RC143.1
  BOTTOM w0.254: UC1.G20 134.62,84.68 134.22,84.91 v2(134.21,84.91)
+1.0VO_DSW: length 1.9
  TOP w0.254: v2(145.9,72.57) 145.9,72.95 CC204.1
  BOTTOM w0.254: UC1.AL1 145.24,72.46 145.78,72.46 v2(145.9,72.57)
+1.0VS_VCCIO: length 198.9
  TOP w0.203: v2(115.87,86.18) 116.35,85.69 116.35,84.25 RC2.2
  TOP w0.508: v2(178.76,106.62) 181.6,103.78 181.82,103.78 182.73,102.86 186.98,102.86 187.6,102.24 188.2,102.24 188.71,101.73 188.71,100.69 190.08,99.32 190.08,97.77 192.28,95.57 192.28,74.9 191.9,74.52 190.48,74.52 189.94,73.98 189.94,71.52 200.59,60.87 201.26,59.87 v1(216.5,44.63) 217.58,43.55 224.88,43.55 225.75,44.42 v2(225.75,44.99)
  IN1 w0.254: v2(115.87,86.18) 115.42,85.73 115.42,84.55 115.78,84.19 117.98,84.19 117.98,84.19 119.77,84.19 119.91,84.05 119.91,82.75 119.85,82.69 119.85,77.02 118.49,75.66
  IN1 w0.508: v2(115.87,86.18) 115.47,86.57 114.46,86.57 113.17,87.86 111.07,87.86 109.84,89.09 109.84,91.6 109.33,92.11 v2(109.2,92.11)
  IN2 w0.508: v2(109.2,92.11) 107.99,93.31 107.1,93.31 105.57,94.84 104,94.84 103.49,94.33 97.64,94.33 96.77,95.2 92.17,95.2 91.32,94.35 86.37,94.35 86.18,94.54 80.08,94.54 78.13,96.49 v2(76.46,96.49)
  IN3 w0.508: v2(127.77,71.96) 127.15,72.58 122.9,72.58 122.35,72.03 v2(122.28,72.03)
  BOTTOM w0.203: UC1.AL30 v2(128.68,73.52) ; UC1.AL30 v2(128.68,71.96) ; UC1.AL30 128.22,72.37 UC1.AM30 ; v2(128.68,73.52) 128.45,73.52 UC1.AK30 ; v2(128.68,73.52) 128.91,73.52 UC1.AK28
  BOTTOM w0.254: v2(127.77,71.96) UC1.AM30 ; UC1.AM28 v2(128.68,71.96) ; v2(121.43,72.01) UC1.AM42 121.9,72.36 v2(122.28,72.03) UC1.AL42
  BOTTOM w0.381: RC132.2 76.22,99.04 76.41,98.85 76.41,96.54 v2(76.46,96.49)
  BOTTOM w0.508: v2(225.75,44.99) 226.95,46.2 235.37,46.2 235.76,45.81 237.27,45.81 241.23,41.85 242.34,41.85 244.02,40.17 244.02,36.26 QE11.1
  vias: v2(178.18,108.04) v2(178.18,107.41) v2(178.78,108.46) v2(178.77,107.85) v2(178.76,107.21)
+1.2V_DDR_B+:
  vias: v1(33.85,39.21) v2(33.83,38.56) v2(34.4,39.1) v2(34.42,38.51) v2(34.43,37.94)
+1.2V_DDRP: length 21.5
  IN2 w0.254: v2(37.64,24.16) 37.86,23.94 37.86,22.61 37.61,22.36 32.61,22.36 30.7,24.27 30.7,35.19 v2(31.31,35.79)
  vias: v1(37.91,23.4) v2(37.63,26.56) v2(37.61,25.95) v2(37.63,25.34) v2(37.64,24.76) v2(37.66,27.78) v2(37.66,27.16) v2(38.23,27.45) v2(38.22,26.88) v2(38.2,26.3) v2(38.19,25.71) v2(38.2,25.11) v2(38.22,24.48) v2(38.25,28.03)
+1.2V_LDO:
  vias: v2(296.47,48.96) v2(298.71,49.05) v3(297.79,49.56)
+1.2V_MEM: length 203.9
  TOP w0.254: 169.62,28.09 168.84,27.31 167.95,27.31 167.4,26.76 167.4,26.39 166.96,25.96 166.35,25.96 165.92,26.39 v2(165.92,26.69)
  TOP w0.381: RD15.1 170.18,27.54 169.62,28.09
  TOP w0.508: v2(78.4,34.61) 78.5,34.51 CD2.1 ; v2(182.17,26.49) 181.58,27.08 CD36.1 ; CD11.1 73.48,34.16 v2(73.84,34.52) ; v2(54.32,34.33) 54.35,34.3 CD9.1 ; CD15.1 79.61,33.98 79.82,34.19 79.82,34.51 v2(79.82,34.51) ; v2(187.29,37.56) 186.87,37.15 CD35.1 ; CD10.1 77.41,34.04 v2(76.96,34.49) ; v2(64.82,34.31) 64.78,34.27 CD14.1
  IN1 w0.508: v2(187.29,37.56) 187.17,37.56 186.39,38.34 177.87,38.34 v2(176.98,37.45)
  IN2 w0.508: v2(64.82,34.31) 65.05,34.31 69.09,38.34 v2(69.09,59.91)
  IN3 w0.305: v2(165.92,26.69) 165.9,26.71 v2(165.05,26.71)
  BOTTOM w0.152: UC1.BB41 122.73,65.49
  BOTTOM w0.178: UC1.BB51 116.62,65.42 v2(116.63,65.41) ; UC1.BB23 132.67,66.2 132.69,66.18 132.69,65.23 v2(132.87,65.05) ; v2(127.69,65.42) 127.69,66.38 UC1.BB32 ; v2(119.11,65.37) 119.07,65.41 UC1.BB47
  BOTTOM w0.254: UC1.AU42 121.34,69.42 v2(121.33,69.48) ; JDIMM1.33 v2(54.32,34.33) ; v2(158.69,29.68) 159.07,29.29 159.07,28.98 159.17,28.88 JDIMM2.136 159.17,26.98 159.43,26.73 160.4,26.73 160.68,27 JDIMM2.142 ; 122.73,65.49 122.72,65.47 v2(122.72,64.53) ; UC1.AU28 v2(128.68,69.4) ; UC1.AU23 v2(131.42,69.4) ; UC1.AU35 v2(125.02,69.4)
  BOTTOM w0.305: JDIMM1.220 v2(103.07,23.49) ; v2(64.82,34.31) JDIMM1.75 ; JDIMM1.123 76.82,34.35 v2(76.96,34.49) ; v2(75.18,34.49) 75.32,34.34 JDIMM1.117 ; JDIMM2.124 156.17,27.01 156.58,26.61 v2(157.45,26.61) 157.68,26.83 JDIMM2.130 ; JDIMM2.135 158.93,37.2 158.82,37.31 v2(158.82,37.37) 158.96,37.51 160.06,37.51 160.42,37.15 JDIMM2.141 ; JDIMM2.118 154.67,26.83 v2(154.45,26.61) 153.46,26.61 153.17,26.9 JDIMM2.112 ; v2(176.98,37.45) 176.92,37.39 JDIMM2.199 ; JDIMM1.148 85.08,24.06 v2(85.42,23.72) ; JDIMM2.117 154.42,37.4 v2(153.62,38.21) 153.66,38.25 155.04,38.25 155.93,37.36 JDIMM2.123 ; JDIMM2.160 167.18,26.13 166.96,25.92 166.19,25.92 165.88,26.23 165.88,26.66 v2(165.92,26.69) 165.68,26.93 JDIMM2.154 ; JDIMM2.75 143.93,37.04 143.89,37.07 143.89,37.62 v2(143.83,37.69) ; JDIMM1.142 81.57,23.83 v2(81.35,23.61) 80.33,23.61 80.07,23.87 JDIMM1.136 ; JDIMM1.241 v2(108.32,34.75) ; JDIMM1.178 92.57,23.86 v2(92.43,23.71) ; JDIMM2.12 128.18,26.49 128.86,25.81 133.65,25.81 134.26,25.2 137.73,25.2 138.65,26.11 v2(138.65,26.46) 138.67,26.49 JDIMM2.54 ; JDIMM1.12 v2(49.07,23.49) ; JDIMM1.160 88.08,24.09 87.72,23.73 87.48,23.73 v2(87.48,23.7) ; JDIMM1.96 v2(70.07,23.67) ; JDIMM2.220 182.18,26.49 v2(182.17,26.49) ; JDIMM2.153 165.43,37.44 166.09,38.1 v2(166.09,38.2) 166.09,38.32 165.96,38.45 164.78,38.45 163.92,37.59 JDIMM2.147 ; JDIMM2.241 187.43,37.22 187.29,37.35 v2(187.29,37.56) ; JDIMM1.135 v2(79.82,34.51) 80.96,34.51 81.32,34.15 JDIMM1.141 ; JDIMM2.159 166.92,36.91 166.41,37.43 v2(166.1,37.43) 166.48,37.81 167.32,37.81 167.92,37.21 JDIMM2.163 ; JDIMM1.130 78.57,23.83 v2(78.35,23.61) 77.48,23.61 77.07,24.01 JDIMM1.124 ; JDIMM2.129 157.42,37.63 157.86,38.07 v2(158.5,38.07) ; JDIMM2.178 v2(171.68,26.49) ; v2(59.19,23.52) 59.57,23.91 JDIMM1.54 ; v2(73.84,34.52) 73.82,34.5 JDIMM1.111 ; JDIMM1.159 v2(87.82,34.64) 88.52,34.64 88.82,34.33 JDIMM1.163 ; JDIMM2.148 164.18,27.09 164.58,26.69 165.04,26.69 v2(165.05,26.71) ; JDIMM2.96 v2(149.17,26.67) ; v2(97.74,34.58) 97.82,34.49 JDIMM1.199 ; JDIMM1.154 86.57,23.96 v2(86.82,23.71) ; JDIMM2.111 v2(152.93,38.18) ; v2(78.4,34.61) 78.32,34.54 JDIMM1.129 ; JDIMM1.153 v2(86.32,34.64) ; JDIMM2.33 v2(133.42,37.75) ; JDIMM1.118 75.57,23.83 v2(75.35,23.61) 74.36,23.61 74.07,23.9 JDIMM1.112 ; JDIMM1.147 v2(84.82,34.64)
  BOTTOM w0.381: v2(69.09,59.91) 74.23,59.91 74.49,59.66 88.27,59.66 89.07,60.46 89.07,60.99 88.76,61.3 CD32.1 88.51,61.31 UD1.5
  vias: v1(88.31,48.94)
+1.2V_MEM_CPUCLK: length 0.6
  BOTTOM w0.254: v2(123.19,71.96) 123.13,71.96 UC1.AM40
  vias: v3(122.75,71.7)
+1.8V_3.3V_ALW_VTR3: length 11
  TOP w0.102: v3(278.54,32.19) 278.34,31.99 RE340.2
  TOP w0.33: UE1.N5 272.75,39.99 272.86,39.88 v2(274.06,39.88)
  TOP w0.508: RE340.2 277.5,32.57 v2(277.22,32.84)
  BOTTOM w0.381: v2(277.22,32.84) 277.22,33.57 275.71,35.08 275.23,35.08 274.08,36.23 274.08,37.32 274.46,37.7 v2(274.66,37.7)
  vias: v2(274.68,39.85) v2(274.67,38.28)
+1.8V_PGPPF: length 8.7
  TOP w0.381: v2(137.08,76.05) 137.08,76.06 137.46,76.44 139.49,76.44 139.51,76.46 141.99,76.46 141.99,76.46 143.49,76.46 v3(143.79,76.16) 144.18,75.76 RC304.2
  BOTTOM w0.254: UC1.AF16 v2(137.08,76.05)
+1.8V_PRIM: length 139.5
  TOP w1.016: 164.57,66.36 163.57,67.36 161.75,67.36 160.51,68.6 160.49,68.65 160.49,69.9 158.04,72.35 158.04,74.49 157.41,75.12 155.7,75.12 ; v2(202.58,46.08) 203,45.66 203,40.56 v1(204.95,38.61) 208.65,34.91 216.1,34.91 216.41,35.23 231.8,35.23 232.39,35.81 236.24,35.81 236.97,36.55 238.38,36.55 239.26,35.67 242.1,35.67 244.02,33.75
  IN1 w1.016: 153.99,79.28 154,79.29 154,84.43 151.83,86.59 151.83,90.71 153.93,92.8 153.93,97.58 ; v2(202.58,46.08) 197.79,50.87 196.48,50.87 ; 165.61,64.36 167.13,62.83 167.13,61.21 171.3,57.04 180.43,57.04
  IN2 w1.016: v2(153.69,99.87) 151.26,102.3 149.42,102.3 146.99,104.73 140.07,104.73 138.76,103.42 134.89,103.42 132.77,101.29 132.28,101.29
  BOTTOM w0.203: UC1.AA1 145.31,77.69 146.41,77.69 v2(146.46,77.74)
  BOTTOM w0.508: v2(154.62,73.68) 154.62,73.38 RC234.1
  vias: v2(124.63,102.5) v2(125.22,102.5) v2(147.02,77.62) v2(154.13,78.3) v2(154.53,99.94) v2(154.73,78.3) v2(155.07,74.07) v2(165.02,65.69) v2(165.64,65.72) v2(243.98,31.51) v2(244.55,31.55) v2(276.08,30.46) v2(276.58,37.74) v2(276.95,30.46) v2(277.07,38.14)
+1.8V_PRIM_R: length 23.3
  IN3 w0.254: v2(114.8,91.18) 114.8,89.76 113.12,88.07 112.64,88.07 110.76,86.19 110.38,86.19 110.38,86.15 v2(110.37,86.15)
  BOTTOM w0.152: UC1.H63 110.65,84 110.85,84.21 UC1.G61 110.85,84.77 110.52,85.1 110.52,86 v2(110.37,86.15)
  BOTTOM w0.254: v2(114.8,91.18) 114.8,91.68 117.47,94.34 118.81,94.34 v1(121.89,97.41) 122.81,98.34 RC232.2
+1.8V_RUN: length 148.6
  TOP w1.016: 191.9,72.8 193.74,72.8 196.18,70.36 197.64,66.85 201.93,60.42 211.49,50.86 240.25,50.86 245.23,55.84
  IN1 w1.016: 185.42,69.31 187.29,69.31 190.43,72.45 v2(190.75,72.45) 190.73,72.47 v2(190.73,73.61)
  IN2 w1.016: 254.33,62.83 258.01,62.83 260.85,65.68 280.33,65.68 286.81,59.2 286.81,58.42 288.22,57.02 288.22,56.89 292.31,52.8 292.31,50.83 293.78,49.36 293.78,47.92 296.78,44.93 298.1,44.93
  BOTTOM w1.016: 167.87,71.67 167.87,71.67 167.87,69.74 170.89,66.72 179.55,66.72 181.58,68.75 182.4,68.75
  vias: v1(300.99,43.72) v2(166.94,71.87) v2(166.94,71.24) v2(183.11,69.06) v2(183.39,68.5) v2(246.09,55.84) v2(246.57,56.43) v2(299.21,44.93) v2(299.85,44.93)
+1.8V_RUN_AUDIO: length 4.8
  TOP w0.203: UA1.40 301.31,35.95 302.14,36.78 302.14,37.57 RA3.1 ; UA1.36 303.36,34.97 v2(303.79,35.4)
  TOP w0.508: RA3.1 302.78,37.65 v2(302.78,37.22)
  vias: v1(303.6,37.43) v2(304.42,36.54)
+1.8V_RUN_CARD: length 18.3
  TOP w0.203: v2(298.45,48.46) 298.45,48.71 298.05,49.12 UR1.13
  IN3 w0.762: 299.23,48.27 302.07,48.27 302.5,47.84 305.52,47.84 306.25,48.57 315.16,48.57 v2(315.35,48.39)
  vias: v3(315.41,47.59)
+1.8V_RUN_UZ8: length 1.1
  TOP w0.102: v3(164.4,68.13) 164.81,68.54 CZ120.1
+1.8VALWP: length 10.7
  BOTTOM w0.508: PC503.1 168.94,99.45 168.94,99.45 168.94,98.46 167.95,97.48 167.5,97.48 166.93,96.91 v1(166.63,96.91) 163.65,96.91 161.9,98.65 161.9,99.89
+1VALWP: length 15.2
  IN2 w0.254: v2(189.26,99.27) 189.26,99.32 188.43,100.15 186.49,100.15 186.16,100.48 181.44,100.48 179.35,98.39 178.01,98.39 177.57,97.96 v2(177.57,97.63)
  BOTTOM w0.254: PC307.1 188.54,98.4 PR306.1 189.24,99.26 v2(189.26,99.27)
  vias: v2(178.2,97.62) v2(178.78,97.63) v2(179.35,97.62)
+1VALWP_B+:
  vias: v1(181.1,102.71) v2(181.85,102.71) v2(182.25,102.22)
+1VS_VCCIOP: length 19
  IN2 w0.254: v2(184.24,112.6) 180.1,112.6 179.85,112.35 179.85,106.66 v2(180.32,106.19) 180.43,106.08 183.33,106.08 183.54,106.29 183.54,108.63 183.97,109.06 v2(184.04,109.06)
  BOTTOM w0.254: v2(184.24,112.6) 184.24,112.61 PR421.1 ; PU401.1 184.44,109.66 184.04,109.25 v2(184.04,109.06)
+2.5V_MEM: length 74.3
  BOTTOM w1.016: 122.79,33.74 122.79,36.33 126.92,40.46 189.9,40.46 191.93,38.43
  vias: v1(114.62,34.97) v2(113.39,35.11) v2(113.4,34.5) v2(122.24,33.2) v2(122.86,32.81) v2(192.15,34.65) v2(192.15,33.95) v2(193.85,26.61) v2(194.42,26.62)
+2.5V_VIN: length 2
  TOP w0.102: 199.2,27.02 198.58,27.02 197.93,27.67 v1(197.47,27.67)
+3.3V_1.8V_ESPI: length 29.7
  TOP w0.102: v1(168.4,61.02) 168.31,60.93 167.32,60.93
  TOP w0.254: v2(142.09,59.8) 142.09,60.4 RC21.2
  BOTTOM w0.254: v2(167.26,59.78) 167.16,59.78 164.36,56.99 160.85,56.99 160.27,56.41 156.72,56.41 156.15,56.99 147.35,56.99 144.81,59.53 142.58,59.53 142.35,59.76 142.12,59.76 v2(142.09,59.8)
+3.3V_1.8V_PGPPA: length 29.6
  TOP w0.254: v2(161.54,65.86) 161.54,66.48 159.92,68.1 159.75,68.5 159.75,69.43 v2(158.39,70.8)
  IN2 w0.254: v2(158.39,70.8) 158.14,70.55 151.16,70.55 150.73,70.12 147.65,70.12 146.93,70.84 v2(146.93,70.89)
  IN3 w0.254: v2(146.93,70.89) 146.54,71.28 144.43,71.28 142.97,72.74 140.71,72.74 140.4,73.06 139.37,73.06 139.11,73.31 138.31,73.31 137.82,72.83 v2(137.82,72.58)
  BOTTOM w0.254: UC1.AK15 v2(137.82,72.58)
  vias: v1(163.51,64.74) v2(162.14,65.84) v2(164.98,60.93) v2(165.56,60.93)
+3.3V_1.8V_PGPPG: length 21
  TOP w0.127: v3(149.15,71.82) 149.5,72.17 v2(149.57,72.17)
  IN1 w0.254: v2(149.57,72.17) 149.08,72.17 148.55,71.64 145.6,71.64 143.92,73.33 139.81,73.33 139.76,73.38 139.74,73.38 139.48,73.64 139.48,73.66 139.19,73.95 139.19,74.96 139.03,75.12 138.56,75.12 137.92,75.76 137.92,75.96 137.91,75.97 v2(137.91,75.92)
  BOTTOM w0.254: RC235.2 151.46,72.88 151.19,72.61 149.92,72.61 149.57,72.26 v2(149.57,72.17) ; UC1.AD15 137.89,75.97 137.91,75.97 v2(137.91,75.92)
  BOTTOM w0.381: RC235.2 152.03,73.11 152.23,72.91 RC234.2 153.32,72.84 153.32,72.08 CC326.1
+3.3V_ALW: length 568.2
  TOP w0.254: CE2.1 274.98,55.09 274.33,55.74 UE2.18 ; v2(54.91,103.46) 55.27,103.46 56.88,101.85 56.88,100.2 58.89,98.19 v2(58.89,98.04)
  TOP w0.305: PR1313.1 43.28,41.97 42.84,42.41 41.25,42.41 v1(40.62,41.78) 40.31,41.47 35.11,41.47 34.68,41.05 33.68,41.05 33.51,40.87 32.08,40.87 v2(31.54,41.41) ; UE4.5 258.17,58.56 RE300.2
  TOP w0.356: v2(245.89,28.42) 245.89,28.41 245.89,28.23 245.86,28.2 CZ91.1
  TOP w0.381: PR1231.2 34.66,93.55 35.12,94.01 35.56,94.01 35.69,93.88 35.75,93.88 v2(35.75,93.87) ; v2(153.56,115.63) CZ94.1 154.14,115.58 155.87,115.58 156.96,116.67 UZ1.2 ; v2(277.03,28.8) 277.03,29.3 276.65,29.69 UE6.5 ; v2(251.85,34.84) 251.87,34.82 CZ93.1 252.79,33.37 UZ10.5 ; 45.77,93.06 v2(44.4,94.43) ; 45.77,93.06 45.17,93.06 44.45,92.34 44.45,91.34 44.13,91.02 PR1235.2 ; 45.77,93.06 46.7,93.06 47.02,92.74 48.14,92.74 48.26,92.61 PR1230.2 ; RE79.1 269.88,50.35 269.88,50.92 v2(269.81,50.98) ; QZ2.2 v2(312.33,3.57) ; RE15.1 279.43,57.68 279.05,57.3 278.08,57.3 v2(278.04,57.34) ; v2(261.5,51.21) 261.5,51.1 RE301.2 262.32,50.28 262.35,50.28 262.51,50.13 RE5.2 ; PR1259.2 43.74,90.11 42.83,90.11 42.42,89.71 42.42,88.41 41.38,87.37 PR1232.2 ; CZ104.1 187.76,51.96 UZ34.5 ; v2(278.64,62.99) 279.79,62.99 280.06,62.72 280.06,62.01 279.55,61.5 RE6.1 279.69,61.21 280.21,61.21 280.59,60.83 280.59,59.84 280.35,59.59 279.54,59.59 RE17.1
  TOP w0.508: v2(46.74,76.23) 46.74,77.01 47.25,77.51 47.25,78.89 47.75,79.39 47.75,82.97 47.5,83.22 PR1224.2 PR1225.2 ; v2(69.57,110.88) 69.57,110.6 70.17,110 71.55,110 71.86,109.7 71.86,109.34 72.37,108.83 CV17.1 72.26,108.56 71.54,108.56 UV24.5 ; RE512.2 279.51,39.8 279.21,40.09 277.24,40.09 v2(277.09,39.94) ; RE37.2 277.05,36.01 v2(277.51,36.47) 277.74,36.25 RE98.2 ; v2(254.61,36.25) 254.61,35.9 RE21.2 253.78,35.49 RE302.2 RE303.2 ; RC68.2 171.85,48.33 172.82,47.36 175.6,47.36 179.4,51.16 182.52,51.16 182.74,50.95 v2(182.78,50.95) ; RE377.2 246.45,35.64 245.29,34.48 v2(245.27,34.48) ; CZ104.1 187.97,52.17 187.97,53.37 188.14,53.54 v2(188.14,53.73) ; RE300.2 258.09,58.67 v2(258.71,59.29) ; RE526.1 252.72,48.52 250.91,46.7 250.91,42.45 250.89,42.43 v2(250.89,42.32) 251.04,42.16 RE365.2 ; PR1234.2 40.26,87.09 PR1232.2 ; PR1235.2 44.13,89.84 PR1259.2 ; PR1306.1 48.87,62.49 48.73,62.35 PR1307.1 48.31,62.68 47.85,63.15 46.98,63.15 46.69,62.86 45.61,62.86 v2(45.43,63.04) 42.54,63.04 41.47,61.97 39.56,61.97 39.51,62.01 37.02,62.01 36.82,61.8 36.63,61.8 35.74,60.92 35.74,60.71 35.4,60.37 35.19,60.37 35.18,60.35 34.88,60.35 v2(34.81,60.43) RT68.2 ; UE3.5 258.8,54.62 CE53.1 259.04,55.42 259.69,54.76 v2(259.78,54.76) ; PR205.2 v2(31.31,36.67) ; v2(244.73,36.72) 242.88,38.57 v2(242.88,40.16) 242.88,42.64 243.58,43.34 244.59,43.34 244.95,42.98 CE6.1 244.83,42.61 244.02,41.81 UE7.5 ; RE25.1 279.78,45.74 280.3,45.22 RE532.1 ; v2(260.46,49.79) 260.17,50.08 259.2,50.08 258.71,50.57 CE52.1 258.12,50.72 UE5.5 ; PR1302.1 44.36,53.03 v2(43.86,53.03) ; v2(277.74,52.79) 278.07,53.12 RE524.2 RE525.2 ; CE2.1 CE1.1 273.56,54.76 273.18,54.38 273.18,53.66 273.69,53.16 v2(273.85,53.16) ; RE505.2 284.63,32.7 282.89,32.7 v2(282.28,32.08) 281.4,31.2 RE68.2 ; RT48.2 23.75,71.6 26.95,71.6 v2(27.1,71.44) ; v2(258.27,34.18) 257.91,34.54 RE8.2 257.93,35.72 CE61.1 ; RE83.2 RE84.2 266.78,50.31 RE63.2 v2(267.57,51.39) ; v2(31.29,107.23) 31.58,107.51 PR28.2 32.18,107.51 32.37,107.7 32.49,107.7 32.9,108.1 PR29.2 ; v2(41.68,92.47) 41.59,92.56 PR1233.2 ; v2(166.44,81.81) 167.15,82.51 167.15,86.37 167.8,87.03 167.8,89.17 167.45,89.53 167.45,95.06 v2(168.13,95.74) ; RC214.1 175.66,52.85 178.26,55.45 v2(178.28,55.45) ; v2(240.2,37.98) 240.21,37.99 RE348.2 ; v2(277.81,34.86) 277.81,34.84 277.19,34.23 RE12.2 RE43.2 ; RE10.2 274.82,34.3 v2(274.36,34.76) ; v2(31.66,100.77) 30.44,100.77 29.97,100.3 29.97,100.25 29.36,99.63 PR4.2 ; v2(277.84,55.05) RE13.1 ; RE38.2 RE35.2 273.22,50.59 v2(273.17,50.64) ; PR1.1 v2(209.23,27.59) ; v2(262.7,32.99) RE11.2
  IN1 w0.508: v2(168.97,108.47) 169.67,107.77 169.67,105.85 170.6,104.92 v2(170.6,103.03) ; v2(313.7,104.41) v2(315.76,104.41) 315.76,103.49 315.25,102.98 315.25,101.86 313.94,100.55 290.03,100.55 288.2,98.72 288.2,95.58 282.73,90.11 v2(282.73,78.12) ; v2(167.09,110.97) 157.12,110.97 153.56,114.53 v2(153.56,115.63) ; v2(277.81,34.86) 278.72,34.86 279.48,34.09 280.71,34.09 282.28,32.52 v2(282.28,32.08) ; v2(32.66,92.35) 32.49,92.18 31.5,92.18 30.99,92.69 30.99,93.41 28.64,95.76 28.64,96.48 29.62,97.45 29.99,97.45 31.61,99.08 31.61,100.73 v2(31.66,100.77) 31.22,101.21 31.22,107.16 v2(31.29,107.23)
  IN2 w0.508: v2(178.28,55.45) 178.27,55.45 178.22,55.41 178.22,54.68 181.74,51.16 182.52,51.16 182.74,50.95 v2(182.78,50.95) 182.78,50.9 183.01,50.67 183.01,50.26 193.34,39.94 193.34,34.47 195.03,32.77 195.03,30 195.54,29.5 197.27,29.5 v2(197.91,28.85) ; v2(245.89,28.42) 245.95,28.35 245.95,26.47 246.72,25.7 246.72,23.8 246.23,23.3 244.08,23.3 243.76,23.62 243.76,24.25 242.92,25.09 241.13,25.09 240.17,24.12 v2(239.64,24.12) ; v2(192.25,97) 191.72,97 190.4,98.32 190.4,100.01 188.65,101.76 188.65,103.51 188.19,103.97 v2(184.87,103.97) ; v2(43.86,53.03) 44.54,53.03 45.1,53.59 45.1,56.6 44.35,57.35 44.35,62.35 45.04,63.04 v2(45.43,63.04) 45.06,63.41 45.06,64.93 45.95,65.82 45.95,66.41 47.22,67.68 47.22,75.48 46.74,75.96 v2(46.74,76.23) ; v2(312.33,3.57) 312.28,3.62 312.28,5.13 310.91,6.5 v2(310.77,6.5) 308.24,9.03 304.89,9.03 302.29,11.62 300.36,11.62 294.13,17.85 292.88,17.85 289.11,21.63 289.11,22.42 288.55,22.98 v2(288.35,22.98) ; v2(189.42,113.7) 188.92,113.2 179.14,113.2 178.32,112.38 178.32,111.32 v2(178.5,111.14) 177.15,111.14 176.51,110.5 175.89,110.5 173.86,108.47 v2(168.97,108.47)
  IN3 w0.508: v2(184.87,103.97) 184.87,103.97 184.83,103.92 182.83,103.92 181.38,105.37 179.12,105.37 177.37,107.13 177.37,110 v2(178.5,111.14) ; v2(34.81,60.43) 34.4,60.43 33.96,60.88 33.96,61.46 35.46,62.96 35.46,65.24 34.29,66.4 34.12,66.4 33.69,66.84 v2(31.63,66.84)
  BOTTOM w0.203: PC206.1 32.81,34.04 33.13,33.72 33.61,33.72 33.77,33.87 PU200.13
  BOTTOM w0.254: PR113.1 31.52,41.43 v2(31.54,41.41) ; PC206.1 32.88,34.15 v2(33.39,34.15) ; JAPS1.7 315.35,103.99 v2(315.76,104.41) ; v2(313.7,104.41) 313.6,104.41 313.35,104.15 JAPS1.3
  BOTTOM w0.305: v2(245.89,28.42) 245.85,28.38 JKBTP1.15
  BOTTOM w0.381: UZ6.5 243.59,34.18 CZ82.1 244.97,34.18 v2(245.27,34.48) ; v2(134.51,108.14) 134.82,108.14 UZ35.5 ; PR410.1 178.32,110.95 v2(178.5,111.14)
  BOTTOM w0.457: PR404.1 184.27,105.26 184.87,104.66 v2(184.87,103.97)
  BOTTOM w0.508: JLED1.6 310.69,6.58 v2(310.77,6.5) ; PR307.1 191.76,97 v2(192.25,97) ; v2(277.03,28.8) 277.03,28.81 278.05,29.83 278.05,31.8 279.01,32.76 279.01,34.25 278.4,34.86 v2(277.81,34.86) ; v2(182.78,50.95) 182.79,50.93 183.3,50.93 185.96,53.59 188,53.59 v2(188.14,53.73) ; PR413.1 188.91,114.2 v2(189.42,113.7) 189.96,114.23 PR414.1 ; v2(258.71,59.29) 258.71,58.2 259.59,57.32 259.59,54.95 v2(259.78,54.76) 260.93,54.76 261.56,54.13 261.56,51.68 261.5,51.63 v2(261.5,51.21) ; v2(168.13,95.74) 168.55,95.74 170.33,97.52 173.03,97.52 173.57,98.07 173.57,99.96 v2(170.99,102.54) ; v2(239.64,24.12) 239.64,24.81 238.84,25.61 PR107.1 ; 240.21,39.31 239.93,39.31 UE9.8 ; 240.21,39.31 240.21,37.99 v2(240.2,37.98) ; 240.21,39.31 240.44,39.31 241.07,39.95 RE69.1 242.66,39.95 v2(242.88,40.16) ; v2(244.73,36.72) 244.63,36.82 RE376.2 ; v2(288.35,22.98) 288.35,24.52 286.47,26.4 285.29,26.4 283.38,28.31 RZ9.1 283.38,29.83 RZ8.1 283.36,30.99 v2(282.28,32.08) ; v2(300.23,77.18) 300.23,76.64 RE75.1 RE72.1 ; PR418.1 170.06,115.06 170.06,114.26 PR417.1 168.8,114.24 168.01,113.45 168.01,113.31 166.92,112.22 166.92,111.14 v2(167.09,110.97) ; v2(58.89,98.04) 58.23,97.38 PR933.1 ; RE73.1 297.59,76.56 RE74.1 v2(297.58,77.2)
  vias: v1(217.87,24.76) v2(198.59,28.87) v2(199.21,28.87) v2(199.78,29.32) v2(200.04,37.39) v2(200.59,37.29) v2(200.66,36.73) v2(201.17,37.37) v2(201.23,36.8) v2(201.84,36.76) v2(202.12,33.24) v2(202.23,33.82) v2(216.66,27.4) v2(217.3,27.4) v2(217.93,27.4) v2(218.57,27.4) v2(219.2,27.4) v2(219.84,27.4) v2(220.47,27.4) v2(265.56,29.91) v2(266.17,29.91) v2(268.47,29.04) v2(273.28,63.72) v2(276.52,39.94) v2(276.93,44.05) v2(276.92,43.49) v2(278.58,46.64) v2(279.15,46.58) v2(284.93,77.12) v2(284.93,76.55) v2(284.93,75.98) v2(285.5,76.87) v2(285.5,76.23) v2(285.5,75.6) v2(285.75,77.37) v2(286.07,76.87) v2(286.07,76.23) v2(286.07,75.6) v2(299.09,60.8) v2(299.09,60.17) v2(299.15,59.59) v2(299.72,60.8) v2(299.72,60.17) v2(299.79,59.59) v2(303.1,60.86) v2(303.66,60.86) v2(305.06,73.12)
+3.3V_ALW2: length 35.4
  TOP w0.508: RE57.2 261.37,30.94 257.61,27.18 257.61,25.28 v1(255.99,23.66) 254.84,22.52 v2(253.48,22.52)
  IN1 w0.508: v2(253.48,22.52) 252.28,22.52 251.45,23.34 250.67,23.34 249.08,21.76 244.47,21.76 243.81,22.43 241.66,22.43 240.87,21.63 237.44,21.63 236.64,22.43 236.46,22.43 236.38,22.51 235.27,22.51 234.71,23.07 234.68,23.07 234.34,23.41 234.34,23.44 234.19,23.59 v2(234.19,23.72)
  BOTTOM w0.508: v2(234.19,23.72) 233.89,24.02 PR104.2
+3.3V_ALW_DSW: length 136.5
  IN1 w0.254: v2(135.75,73.52) 135.75,73.48 135.25,72.98 134.86,72.98 133.71,71.82 133.71,68.29 133.94,68.07 133.94,65.84 135.55,64.23 138,64.23 141.41,60.82 141.41,59.45 143.11,57.76 143.11,57.32 143.72,56.71 144.53,56.71 145.32,57.5 148.66,57.5 152.3,53.85 152.3,53.58 156.59,49.3 164.08,49.3 164.55,49.77 170.33,49.77 v2(170.52,49.59)
  IN2 w0.508: v2(135.76,76.09) 135.76,75.34 135.4,74.98 ; 135.4,74.98 135.75,74.64 v2(135.75,73.52) ; 135.4,74.98 131.04,74.98 128.66,77.36 127.74,77.36 127.36,77.74 127.36,81.63 127.68,81.95 128.37,81.95 128.74,82.33 128.74,83.82 127.12,85.45 127.12,89.78 126.8,90.1 126.8,92.42 123.41,95.81 117.72,95.81 116.7,94.79 115.23,94.79 115.04,94.59 106.72,94.59 105.87,95.45 103.75,95.45 103.3,95.01 98.32,95.01 97.17,96.16 83.42,96.16 82.41,95.15 80.39,95.15 v2(79.44,96.11)
  BOTTOM w0.254: 135.76,76.1 135.73,76.11 UC1.AD18 ; 135.76,76.1 v2(135.76,76.09) ; 135.76,76.1 135.82,76.11 UC1.AD17 ; UC1.AJ17 v2(135.75,73.52)
  BOTTOM w0.508: RC241.2 78.87,96.68 v2(79.44,96.11)
  vias: v1(171.86,52.27)
+3.3V_ALW_PCH: length 430.5
  TOP w0.254: RC187.2 134.63,55.97 134.38,55.72 134.38,52.91 137.35,49.93 v2(141.77,49.93) ; 162.85,73.83 163,73.67 167.31,73.67 168.84,72.14 v2(170.15,72.14) ; v2(166.18,87.09) 165.6,86.51 RC400.2 ; v2(140.44,48.56) 140.56,48.68 148.47,48.68 v2(153.74,53.94)
  TOP w0.381: v2(161.27,53.73) 162.13,52.86 163.63,52.86 165.06,51.43 165.06,48.24 165.46,47.85 166.68,47.85 167.1,48.26 169.07,48.26 RC344.2
  TOP w0.457: v2(134.46,78.51) 134.46,78.43 134.71,78.17 CC209.1 ; v2(148.52,74.77) RC306.1
  TOP w0.508: v2(161.48,59.57) 161.48,59.72 161.14,60.07 RC183.2 RC74.2 ; v2(251.89,64.12) 250.72,62.95 v1(250.72,61.75) 250.72,58.08 246.31,53.66 244.9,53.66 240.73,49.5 236.92,49.5 v2(236.22,48.79) 235.45,48.03 235.45,46.04 231.44,42.02 216.99,42.02 v2(215.72,40.76) ; RC346.2 152.28,101.63 150.25,103.66 150.25,104.44 149.68,105.01 v2(149.15,105.01) ; v2(219.29,32.52) 218.98,32.21 217.22,32.21 217.22,32.21 207.11,32.21 205.66,30.76 v2(205.49,30.76) ; v2(163.64,59.57) 163.75,59.57 163.84,59.66 RC211.1
  IN1 w0.254: v2(134.46,78.51) 134.46,78.24 132.84,76.62 v2(132.84,74.26) ; v2(153.74,53.94) 154.37,53.94 154.63,54.2 161.14,54.2 161.27,54.08 v2(161.27,53.73)
  IN1 w0.508: v2(251.89,64.12) 251.89,64.15 252.52,64.78 255.37,64.78 256.93,66.33 260.9,66.33 266.21,71.64 266.21,97.44 273.12,104.36 v2(311.63,104.36) ; 161.48,60.45 v2(161.48,59.57) ; 161.48,60.45 162.25,60.45 162.29,60.48 163.01,60.48 163.64,59.85 v2(163.64,59.57) ; 161.48,60.45 161.1,60.83 161.1,62.8 161.48,63.19 161.48,63.98 160.8,64.67 160.8,67.38 161.59,68.17
  IN2 w0.254: v2(166.18,87.09) 165,85.91 165,84.58 163.64,83.22 162.83,83.22 162.63,83.02 152.67,83.02 151.56,84.12 v2(150.61,84.12)
  IN2 w0.508: 144.72,74.9 145.27,74.35 148.09,74.35 v2(148.52,74.77) ; v2(123.63,94.33) 123.31,94.66 117.83,94.66 117.07,93.9 117.07,93.47 116.31,92.7 115.19,92.7 114.55,93.34 113.37,93.34 112.36,92.34 112.36,89.73 112.01,89.39 111.21,89.39 109.76,90.84 107.95,90.84 107.39,91.4 107.37,91.43 107.22,91.58 107.18,91.6 106.87,91.92 105.41,91.92 104.22,93.11 87.5,93.11 86.68,92.3 86.62,92.3 86.6,92.28 85.68,92.28 85.05,92.91 82.15,92.91 81.05,91.81 79.48,91.81 77.88,93.41 74.49,93.41 71.86,96.04 v2(71.86,96.48) ; 199.32,30.85 200.43,30.85 201.52,29.77 204.67,29.77 205.49,30.59 v2(205.49,30.76)
  IN3 w0.508: v2(123.63,94.33) 124.47,95.18 128.1,95.18 129.77,96.84 129.77,100.73 133.9,104.87 134.72,104.87 v2(136.36,106.5)
  BOTTOM w0.254: v2(134.46,78.51) 134.46,78.66 UC1.V19 ; v2(140.44,48.56) 141.77,49.89 v2(141.77,49.93) ; v2(136.03,72.58) 136.11,72.66 136.11,73.1 UC1.AK17 ; v2(311.63,104.36) 312.35,103.64 JAPS1.1 ; RC330.2 154.04,74.35 153.28,74.35 RC317.2 152.64,73.71 150.96,73.71 150.55,73.3 RC235.1 ; UC1.AJ21 133.19,74.25 132.86,74.25 v2(132.84,74.26)
  BOTTOM w0.305: 167.13,90.14 167.97,90.97 167.97,91.6 168.35,91.98 168.8,91.98 170.32,93.5 172.95,93.5 UC7.5 ; 167.17,89.3 166.25,88.37 166.25,87.15 v2(166.18,87.09)
  BOTTOM w0.508: v2(136.36,106.5) 137.53,106.5 137.98,106.05 145.42,106.05 146.4,105.07 v2(146.4,103.88) ; v2(236.22,48.79) 236.22,47.71 237.1,46.83 RC222.2 ; v2(149.15,105.01) 150.13,105.01 150.55,104.59 RT391.2 ; RC331.2 155.94,77.29 v2(156.2,77.54) ; v2(215.72,40.76) 215.72,37.05 219.29,33.48 v2(219.29,32.52) ; RC25.2 148.91,78.31 v2(148.59,77.99) ; RC12.2 RC14.2 149.94,84.48 150.24,84.78 v2(150.62,84.78) ; v2(179.83,58.71) 178.96,58.71 173.11,52.85 164.48,52.85 163.76,53.57 163.76,53.96 163.21,54.51 161.54,54.51 161.29,54.26 161.29,53.76 v2(161.27,53.73) ; v2(148.52,74.77) 149.95,73.34 150.32,73.34 RC235.1 ; RC133.2 71.29,97.1 71.86,96.52 v2(71.86,96.48)
  vias: v2(139.92,73.83) v2(141.39,103.72) v2(142.04,103.71) v2(142.51,97.27) v2(142.61,96.71) v2(146.39,103.27) v2(146.98,103.26) v2(156.02,104.79) v2(156.54,104.52) v2(161.56,69.6) v2(161.94,69.09) v2(161.9,68.52) v2(180.34,58.13) v2(180.53,58.83) v2(180.98,58.39) v2(197.59,30.02) v2(198.22,30.03) v2(198.82,30.04) v2(199.39,29.94)
+3.3V_ALW_PCH_UZ3: length 1.4
  TOP w0.102: v1(196.6,32.99) 196.79,32.8 197.93,32.8
+3.3V_ALW_UE1: length 46.3
  TOP w0.127: v3(276.15,52.1) 276.06,52.19 CE13.1
  TOP w0.254: UE1.B7 263.17,41.59 v2(262.81,41.23) ; v2(270.01,37.12) 270.01,37.2 269.62,37.59
  TOP w0.33: UE1.M9 271.62,43.59 v2(271.62,43.61) ; v2(266.82,42.79) UE1.G8 ; v2(269.12,35.17) 269.12,35.22 268.02,36.31 UE1.H1
  IN2 w0.508: v2(262.81,41.23) 262.81,41.54 263.32,42.05 266.31,42.05 266.82,42.56 v2(266.82,42.79)
  IN3 w0.457: v2(266.82,42.79) 266.82,42.52 267.14,42.2
  IN3 w0.508: 267.14,42.2 271.12,42.2 271.62,42.71 v2(271.62,43.61) ; v2(273.97,49.3) 272.92,49.3 271.22,47.6 271.22,46.72 271.62,46.31 v2(271.62,43.61) ; v2(271.62,43.61) 271.85,43.38 272.79,43.38 274.14,44.74 275.15,44.74 275.79,44.09 275.79,41.79 274.58,40.58 273.67,40.58 272.74,39.65 272.74,38.74 271.19,37.19 270.08,37.19 v2(270.01,37.12)
  BOTTOM w0.508: v2(270.01,37.12) 269.96,37.12 269.94,37.1 269.93,37.1 269.12,36.28 v2(269.12,35.17) 267.36,33.42 v2(267.36,32.08)
+3.3V_ALWP: length 24.9
  TOP w0.254: PC107.1 234.71,28.96 235.54,28.14 235.54,25.38 234.89,24.73 234.89,23.69 v2(234.93,23.65) ; v2(227.38,27.62) 228.2,28.44 232.18,28.44 233.28,27.35 233.28,25.55 v2(234.27,24.56)
  BOTTOM w0.254: PR108.2 v2(234.93,23.65) ; PU100.14 234.18,24.64 v2(234.27,24.56)
  vias: v1(226.51,23.02) v2(222.43,25.75) v2(222.43,24.91) v2(222.4,24.05) v2(222.46,23.23) v2(223.04,25.75) v2(223.04,24.91) v2(223.01,24.05) v2(223.06,23.23) v2(223.67,27.65) v2(224.35,27.65) v2(225.22,27.62) v2(225.95,27.6) v2(226.77,27.62)
+3.3V_CAM: length 15.7
  TOP w0.508: CV22.1 62.14,113.26 CV23.1 61.92,114.12 61.57,114.47 60.71,114.47 60.35,114.11 58.69,114.11 58.08,114.73 v2(58.08,115.82)
  BOTTOM w0.102: v2(58.08,115.82) 58.08,116.31 56.42,117.97 v1(55.65,117.97)
  BOTTOM w0.254: JEDP1.6 61.2,115.51
  BOTTOM w0.508: 61.2,115.51 60.8,115.11 58.78,115.11 v2(58.08,115.82)
+3.3V_HDD_M2: length 2
  IN1 w0.305: JNGFF3.70 JNGFF3.74 20.1,13.9 JNGFF3.72
  vias: v1(26.55,16.67) v1(35.18,16.34) v1(38.88,16.02) v2(22.55,15.99) v2(22.55,15.42) v2(25.44,17.52) v2(26,17.52)
+3.3V_LAN: length 44.9
  TOP w0.508: JLOM1.12 311.58,99.43 310.83,100.17 ; v2(269.88,90.65) 270.4,91.17 RL4.2 ; 272.11,100.25 RL1.2 273.56,100.27 RC20.2 ; 272.11,100.25 v2(270.97,100.25) ; 272.11,100.25 RL2.2 ; v2(291.72,96.17) 291.72,100.23 292.29,100.81 307.22,100.81 307.74,100.29 CL18.1 ; v2(283.47,87.85) 283.21,88.11 RL70.2 ; RC19.2 v2(277.62,101.06)
  IN1 w0.508: 305.95,74.83 309.06,77.95 JLOM1.9 ; v2(270.97,100.25) 271.2,100.48 277.04,100.48 v2(277.62,101.06)
  vias: v1(302.45,66.36) v2(267.85,87.85) v2(268.43,87.28) v2(268.48,87.85) v2(291.09,87.85) v2(291.09,87.22) v2(291.09,86.58) v2(291.09,85.95) v2(296.04,86.2) v2(302.9,72.61) v2(303.47,72.61)
+3.3V_LAN_OUT: length 12.1
  TOP w0.203: 274.45,90.52 274.3,90.67 UL1.4 ; 274.45,90.52 274.07,90.14 ; 274.45,90.52 274.7,90.77 UL1.5 ; UL1.15 279.06,93.02 v3(279.53,92.55) CL7.1 ; CL30.1 279.88,94.62 UL1.19 ; UL1.29 275.9,99.34 CL29.1
  TOP w0.381: CL7.1 v2(279.66,91.66) ; CL30.1 280.16,94.58 v2(280.67,95.09)
  TOP w0.508: CL29.1 276.35,99.41 v2(276.8,99.85)
  vias: v2(270.32,86.43) v2(270.89,86.44)
+3.3V_LAN_UZ2:
  vias: v3(303.66,62.46)
+3.3V_M_TPM: length 29.3
  IN1 w0.508: v2(169.8,89.95) 170.11,90.26 v2(174.38,90.26) ; v2(174.16,82.59) 173.01,81.44 168.34,81.44 167.38,82.39 165.51,82.39 165,82.9 v2(165,83)
  IN2 w0.508: v2(174.38,90.26) 174.17,90.05 174.17,82.6 v2(174.16,82.59)
  BOTTOM w0.102: v2(165,83) 165.43,83 165.71,83.27 v3(165.71,83.48)
  BOTTOM w0.254: UZ12.22 173.5,83.55 CZ54.1
  BOTTOM w0.356: v2(174.16,82.59) 173.83,82.92 CZ54.1
  BOTTOM w0.508: RZ69.1 173.93,89.81 v2(174.38,90.26) ; v2(165,83) 164.57,83.43 QZ9.3
+3.3V_MMI_AUX: length 3
  TOP w0.254: RR19.2 294.46,55.42 294.73,55.68 295.82,55.68 295.83,55.7 296.48,55.7 296.94,56.16 R274.2
  vias: v3(297.12,57.69)
+3.3V_MMI_IN: length 0.8
  TOP w0.127: v2(293.22,56.43) v1(293.22,55.62)
  vias: v2(293.6,57) v2(297.12,48.88)
+3.3V_PDA_VOUT: length 2.6
  TOP w0.076: UT5.H2 27.01,63.56 27.01,64.43 26.59,64.84
  TOP w0.102: CT83.1 26.59,65.54 26.59,64.84
+3.3V_PGPPB: length 3
  TOP w0.457: v2(138.67,74.67) RC305.2
  TOP w0.508: CC265.1 138.05,75.31 RC305.2
  BOTTOM w0.254: v2(138.67,74.67) 137.58,74.67 137.46,74.79 UC1.AG15
+3.3V_PGPPC: length 19
  TOP w0.127: v2(147.45,74.95) v3(147.84,75.34)
  TOP w0.457: RC306.2 147.6,74.8 v2(147.45,74.95)
  TOP w0.508: v2(136.43,77.73) 136.43,77.25 CC207.1
  IN2 w0.254: v2(147.45,74.95) 147.45,75.66 148.17,76.38 148.17,77.8 v2(148.01,77.96)
  IN3 w0.254: v2(148.01,77.96) 147.72,78.25 144.23,78.25 143.95,78.52 140.92,78.52 140.84,78.45 138.69,78.45 138.6,78.54 136.86,78.54 136.43,78.1 v2(136.43,77.73)
  BOTTOM w0.254: UC1.Y16 v2(136.43,77.73)
+3.3V_PGPPD: length 14
  TOP w0.102: v3(138.19,77.34) 137.84,77.69 v2(137.71,77.69)
  TOP w0.381: RC307.2 147.85,76.41 v2(147.63,76.63)
  IN1 w0.076: v2(147.63,76.63) 146.27,76.63 145.89,77 142.57,77 141.96,76.39 137.68,76.39 137.22,76.85 137.22,77.25 137.67,77.69 v2(137.71,77.69)
  BOTTOM w0.076: UC1.Y15 137.39,78.01 v2(137.71,77.69)
+3.3V_PGPPE: length 11.6
  TOP w0.508: RC308.2 144.38,77.59 v3(143.59,78.38) 143.21,78.76 v2(143.21,79.03) ; v2(136.47,79.42) 136.43,79.38 136.43,78.76 CC208.1
  IN3 w0.254: v2(136.47,79.42) 136.47,79.66 136.91,80.1 137.67,80.1 138.28,79.49 140.68,79.49 141.08,79.09 141.78,79.09 142.15,79.46 142.9,79.46 143.21,79.15 v2(143.21,79.03)
  BOTTOM w0.254: UC1.T16 136.47,79.46 v2(136.47,79.42)
+3.3V_RTC_LDO: length 86.7
  TOP w0.508: v2(236.54,21.68) 236.18,22.04 v1(235.65,22.04) 234.75,22.04 v2(234.29,22.5) ; v2(307.8,11.02) 308.29,11.51 PD3.3
  BOTTOM w0.508: v2(236.54,21.68) 237.1,21.12 278.76,21.12 279.72,22.08 279.72,23.57 281.94,25.79 285.43,25.79 287.72,23.5 287.72,21.45 289.67,19.49 293.62,19.49 302.09,11.02 v2(307.8,11.02) ; PR105.2 233.76,23 234.26,22.5 v2(234.29,22.5)
+3.3V_RUN: length 496
  TOP w0.254: v2(95.12,115.96) 94.64,115.47 CV83.1 93.86,115.42 RV8.2 ; RC13.2 143.74,54.37 144.2,53.92 145.29,53.92 147.07,55.69 v2(147.07,56.05) 145.2,57.92 145.2,59.6 RC27.2 ; UC8.14 65.95,100.66 CC30.1 66.07,100.25 65.73,99.91 65.73,99.17 v2(65.52,98.96) ; v2(115.55,97.12) 115.55,96.82 114.52,95.79 110.81,95.79 110.36,95.34 v2(110.29,95.34) ; v2(150.6,81.92) 150.33,82.19 QC2.2
  TOP w0.381: RC176.2 RC177.2 145.64,80.88 RC178.2 ; QZ1.3 57.59,109.74 56.58,109.74 56.31,110.01 CA7.1 56.31,110.87 56.39,110.95 v2(56.39,111.61)
  TOP w0.508: RC413.2 150.72,95.48 150.72,96.2 v2(150.87,96.35) ; v2(266.37,26.12) 266.19,26.12 265.8,25.73 265.8,25.46 CZ67.1 CZ72.1 ; RD10.1 111.44,33.81 113.29,33.81 v2(113.48,33.62) 114.25,32.85 RD4.1 114.19,32.1 RD6.1 114.59,31.3 115.19,30.7 115.19,25.13 111.86,21.79 92.89,21.79 91.06,23.63 RD8.1 ; RE67.2 284.25,27.23 v2(283.88,26.85) ; v2(125.74,111.37) 125.74,111.72 124.79,112.67 118.89,112.67 v2(118.33,112.11) ; v2(178.49,73.8) 178.49,73.18 177.69,72.38 177.69,70.6 176.17,69.08 176.17,64.04 v2(175.52,63.39) 175.74,63.16 RC414.2 171.93,58.9 170.77,58.9 RC51.2 RC50.2 ; RC345.2 148.49,99.13 v2(149.01,98.62) ; v2(161.47,82.51) 161.09,82.9 161.09,86.06 162.53,87.5 v2(164.88,87.5) ; RC186.2 RC237.2 v2(162.94,59.57) ; RD24.1 171.13,24.8 171.47,24.46 v2(174.16,24.46) ; v2(191.32,30.45) 191.32,29.94 190.62,29.23 RD26.1 189.49,28.62 RD20.1 187.46,28.26 186.63,27.43 RC319.2 RC318.2 ; v2(116.21,105.82) 116.13,105.75 RV87.2 ; v2(157.16,73.44) 156.47,73.44 154.96,71.93 153.72,71.93 151.76,69.97 149.58,69.97 149.44,70.11 145.94,70.11 145.32,70.73 RC282.2 ; 15.19,81.22 14.15,81.22 13.39,80.47 13.39,77.84 17.57,73.66 QV5.2 17.96,73.98 RV20.2 18.76,73.34 18.35,72.93 RV18.1 RV19.2 19.49,72.38 20.18,71.7 20.86,71.7 v2(21.16,71.39) 21.21,71.34 v2(21.21,69.46) ; RD22.1 v2(196.36,30.41) ; v2(157.88,58.32) 157.88,58.31 157.88,57.54 159.93,55.49 163.3,55.49 163.93,54.86 RC47.2 RC189.2 167.26,54.83 RC59.2 ; RC175.2 RC178.2 ; v2(46.06,69.67) 47.06,69.67 PR612.1
  TOP w1.016: 245.89,24.73 243.61,24.73 241.83,26.52 241.83,29.8 240.69,30.93 237.31,30.93 234.81,33.43 234.7,33.43
  IN1 w0.508: v2(191.32,30.45) 191.07,30.7 191.07,32.65 189.93,33.79 189.93,37.18 ; v2(162.94,59.57) 162.94,59.15 163.13,58.96 165.15,58.96 168.24,55.87 v2(177.81,55.87) ; v2(113.48,33.62) 114.62,33.62 v2(118.62,37.62) ; v2(148.48,104.47) 148.48,102.92 149.01,102.38 v2(149.01,98.62)
  IN2 w0.254: v2(95.12,115.96) 96.15,114.93 106,114.93 v2(107.34,113.58)
  IN2 w0.508: v2(60.73,115.87) 60.73,115.67 59.31,114.25 58.39,114.25 56.39,112.25 v2(56.39,111.61) ; v2(266.37,26.12) 266.37,26.08 266.93,25.52 269.12,25.52 269.49,25.15 276.92,25.15 277.69,25.93 279.45,25.93 280.47,26.95 283.78,26.95 v2(283.88,26.85) 284.93,27.91 286.4,27.91 286.91,27.4 286.91,27.1 288.41,25.6 289.39,25.6 ; v2(149.61,75.02) 149.61,74.7 150.05,74.26 152.78,74.26 154.05,72.99 155.3,72.99 155.78,73.48 155.78,76.3 156.89,77.4 v2(156.89,77.58) ; v2(145.01,61.69) 147.07,59.63 v2(147.07,56.05) ; v2(21.16,71.39) 24.09,74.32 29.2,74.32 30.4,73.12 32.49,73.12 v2(33.44,74.07) ; v2(177.81,55.87) 176,57.68 176,59.02 175.52,59.5 v2(175.52,63.39)
  IN3 w0.381: v2(146.92,81.68) 148.49,81.68 148.83,81.34 150.01,81.34 v2(150.6,81.92)
  IN3 w0.508: v2(174.16,24.46) 179.47,24.46 180,24.99 v2(192.15,24.99) ; v2(50.61,41.31) 52.01,41.31 65.89,55.18 v2(65.89,58.56)
  BOTTOM w0.076: RC267.2 149.91,81.32
  BOTTOM w0.203: RV79.2 120.49,112.22 119.95,112.22 119.68,112.5 119.17,112.5 118.95,112.28 118.95,111.43 118.74,111.22 UV7.51 ; 122,107.51 121.62,107.89 121.34,107.89 121.03,108.2 119.92,108.2 119.3,108.82 UV7.57 ; v2(116.21,105.82) 116.13,105.9 UV7.5 ; UV7.21 108.92,107.62 108.71,107.41 CV84.1 108.59,105.57 108.08,105.06 108.08,104.11
  BOTTOM w0.254: v2(164.88,87.5) 164.65,87.28 RPC4.6 ; v2(164.88,87.5) 164.88,86.73 164.42,86.28 RPC4.8 ; v2(164.88,87.5) 164.6,87.78 RPC4.5 ; v2(145.01,61.69) 145.01,60.94 147.08,58.87 156.81,58.87 157.36,58.32 v2(157.88,58.32) ; v2(60.73,115.87) 60.7,115.9 JEDP1.5 ; UV7.30 109.21,111.22 107.79,112.64 107.79,113.14 v2(107.34,113.58) ; RV79.2 120.65,112.64 120.21,112.64 119.95,112.91 118.86,112.91 118.39,112.43 118.39,112.16 v2(118.33,112.11) ; 108.71,100.42 108.71,102.33 108.08,102.96 108.08,104.11 ; RC287.2 110.29,94.81 v2(110.29,95.34)
  BOTTOM w0.305: v2(266.37,26.12) 266.15,26.34 JUSH1.19
  BOTTOM w0.381: v2(21.21,69.46) 21.4,69.65 QV3.2 ; RV79.2 121.71,112.52 CV82.1 121.74,111.63 CV81.1 ; QV3.5 21.4,71.63 v2(21.16,71.39) ; 122.18,106.95 122.18,107.33 122,107.51
  BOTTOM w0.457: v2(116.54,99.1) RC137.2
  BOTTOM w0.508: RV81.2 120.86,109.59 RV83.2 122.09,109.87 123.75,109.87 124.56,110.69 124.56,111.98 ; v2(162.91,82.58) 163.26,82.93 163.26,84.61 163.69,85.05 RZ89.1 ; RZ362.1 169.93,78.83 v2(170.06,78.71) ; 149.91,81.32 150.09,81.32 150.6,81.83 v2(150.6,81.92) ; v2(151.24,82.91) 151.29,82.97 RC278.2 ; 156.4,76.35 156.89,76.83 v2(156.89,77.58) ; v2(149.61,75.02) 149.61,74.64 149.98,74.27 150.55,74.27 RC402.2 ; RD19.2 90.11,62.02 90.11,60.23 88.65,58.77 68.2,58.77 68.01,58.96 66.28,58.96 v2(65.89,58.56) ; RV93.2 120.17,103.4 120.8,104.03 ; v2(162.94,59.57) 162.94,59.4 162.5,58.96 158.05,58.96 157.88,58.79 v2(157.88,58.32) ; RV95.2 120.35,106.47 RV85.2 ; v2(192.15,24.99) 193.7,24.99 196.36,27.64 v2(196.36,30.41) 196.36,30.68 196,31.04 194.66,31.04 194.44,30.83 191.7,30.83 v2(191.32,30.45) ; RC225.2 148.33,104.32 v2(148.48,104.47) ; v2(110.42,101.02) 110.42,103.87 RV89.2 ; v2(65.52,98.96) 65.52,99.11 65.71,99.3 65.71,100.86 65.21,101.36 64.43,101.36 63.36,102.43 63.36,103.9 62.21,105.05 62.21,106.24 60.99,107.46 60.12,107.46 56.39,111.19 v2(56.39,111.61) ; RC292.2 v2(152.3,78.3) ; RC272.2 149.28,97.23 149.48,97.44
  vias: v1(292.99,23.72) v2(28.39,22.64) v2(28.45,22) v2(28.39,21.3) v2(29.02,22.26) v2(28.96,21.68) v2(42.74,36.99) v2(42.74,36.35) v2(42.74,35.72) v2(43.25,36.1) v2(43.31,36.73) v2(102.47,104.77) v2(103.82,104.76) v2(122.46,105.85) v2(123.07,105.86) v2(157.2,74.14) v2(181.52,72.53) v2(181.55,71.44) v2(181.67,71.98) v2(181.9,70.96) v2(188.41,39.58) v2(188.75,39.08) v2(189.03,39.59) v2(189.23,38.64) v2(189.49,39.21) v2(189.74,38.39) v2(189.8,37.75) v2(190.04,38.88) v2(190.38,38.39) v2(190.38,37.75) v2(223.2,39.84) v2(223.86,39.85) v2(233.97,33.51) v2(234.62,33.52) v2(288.2,38.59) v2(288.82,38.58) v2(289.54,38.57) v2(290.29,38.6) v2(291.73,24.44) v2(291.73,23.83) v2(291.73,22.24) v2(291.72,21.68) v2(294.16,46.26) v2(294.16,45.62) v2(294.16,44.99) v2(294.16,44.35)
