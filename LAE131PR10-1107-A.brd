# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_P12: length 202.7
  IN1 w0.119: v2(45.11,88.96) 45.42,89.27 45.52,89.27 45.65,89.14 45.65,88.66 45.39,88.4 45.07,88.4 44.61,87.94 44.61,87.24 45.13,86.73 45.13,81.03 44.42,80.32 44.42,78.61 43.54,77.73 43.54,70.29 44.12,69.71 44.12,69.48 44.54,69.06 44.54,66.89 46.25,65.17 46.25,58.33 45.55,57.62 45.55,54.45 46.25,53.75 46.25,49.32 43.19,46.25 43.19,46.14 38.49,41.45 36.34,41.45 35.29,40.4 33.7,40.4 31.7,38.4 30.76,38.4 27.94,35.59 27.94,32.9 25.85,30.81 25.85,22.26 26,22.11 26,21.47 v2(25.63,21.1)
  IN3 w0.135: v2(45.11,88.96) 45.46,89.3 45.78,89.3 47.29,90.81 47.93,91.45 47.93,92.24 49.29,93.59 49.29,102.64 51.58,104.93 53.24,104.93 55.05,106.73 56.53,106.73 57.52,107.73 61.4,107.73 61.77,108.11 68.45,108.11 68.83,107.73 91.98,107.73 94.07,109.82 100.31,109.82 101.83,108.3 106.1,108.3 106.49,107.91 109.69,107.91 110.35,108.58 120.97,108.58 123.7,105.85 124.93,105.85 126.63,104.14 126.63,103.71 v2(126.29,103.37)
  BOTTOM w0.076: 128.58,98.51 128.58,98.49 128.59,98.47 128.59,96.12 128.21,95.73 128.21,92.49 129.07,91.62 129.07,89.77 130.24,88.6 130.39,88.6 130.95,88.03 UC1.B25
  BOTTOM w0.104: v2(126.29,103.37) 126.67,102.99 126.67,102.37 127.04,102 127.72,102 128.58,101.14 128.58,98.51 ; v2(25.63,21.1) 25.79,20.95 25.79,20.51 CN72.2
PCIE_RCOMPN: length 1.4
  TOP w0.112: RC45.1 142.96,84.29 v2(142.41,84.84)
  BOTTOM w0.254: v2(142.41,84.84) 142.46,84.84 UC1.F5
PCIE_RCOMPP: length 2.7
  TOP w0.112: RC45.2 143.89,84.48 143.08,85.29 142.65,85.29 v2(142.4,85.54)
  BOTTOM w0.254: UC1.E5 142.51,85.54 v2(142.4,85.54)
PCIE_WAKE#: length 459.7
  TOP w0.076: JNGFF3.54 25.1,14.66 ; 32.49,80.28 32.49,80.44 32.31,80.61 32.31,81.03 32.15,81.19 UT1.W1
  TOP w0.112: 32.49,80.28 32.49,79.13 33.26,78.35 v2(33.38,78.35) ; RE275.2 174.07,49.21 RE274.1 174.08,49.24 175.26,49.24 179.58,53.57 182.48,53.57 182.57,53.65 v2(182.62,53.65) 183.2,53.65 183.77,53.08 183.77,38.9 184.95,37.72 184.95,25.54 182.27,22.85 181.35,22.85 180.28,23.92 178.79,23.92 178.49,23.62 171.33,23.62 170.87,24.07 168.71,24.07 167.77,25.01 166.49,25.01 165.34,26.17 165.34,26.18 164.96,26.18 164.21,26.46 164.2,26.48 161.24,26.48 158.89,24.12 115.17,24.12 112.14,21.1 69.05,21.1 65.48,24.67 63.92,24.67 62.94,24.67 61.32,24.67 58.88,22.24 45.75,22.24 40.75,17.24 35.98,17.24 35.18,18.04 35.18,19.53 33.73,20.98 32.06,20.98 29.45,23.59 v1(22.93,23.59) 22.47,23.59 v2(21.45,22.56) 20.83,21.95 20.83,21.3 22.43,19.7 22.43,17.44 22.74,17.14 22.74,16.84 24.52,15.05 24.82,15.05 25.1,14.77 25.1,14.66
  IN1 w0.119: v2(21.45,22.56) 20.08,23.93 20.08,24.97 19.36,25.7 19.36,44.85 20.32,45.81 21.15,45.81 23.35,48.02 23.35,52.25 25.43,54.33 27.06,54.33 27.21,54.18 28.08,54.18 28.64,54.73 28.64,55.62 27.79,56.47 27.79,57.45 28.6,58.26 28.82,58.26 30.35,59.79 30.35,63.01 29.2,64.15 27.18,64.15 26.21,65.12 26.21,66.26 23.67,68.8 23.67,72.23 27.21,75.76 27.21,76.38 28.85,78.03 33.05,78.03 v2(33.38,78.35) ; v2(182.62,53.65) 182.73,53.76 183.69,53.76 184.63,52.82 188.51,52.82 188.66,52.97 190.67,52.97 195.94,47.7 197.23,47.7 202.04,42.89 204.86,42.89 205.88,41.88 205.88,41.46 207.07,40.28 211.42,40.28 212.2,39.5 215.41,39.5 216.55,40.64 217.04,40.64 218.81,40.64 219.39,41.23 221.52,41.23 222.14,40.61 222.7,40.61 222.83,40.73 223.57,40.73 223.49,40.74 223.81,40.74 224.22,40.74 224.53,40.44 229.22,40.44 229.43,40.64 229.43,40.64 229.52,40.74 231.8,40.74 231.9,40.64 237.59,40.64 238.14,40.09 242.4,40.09 242.73,39.76 243.74,39.76 243.77,39.8 244.71,39.8 253.1,48.19 256.96,48.19 258.2,46.95 258.9,46.95 259.67,47.72 260.59,47.72 261.11,48.25 264.24,48.25 264.82,48.82 269.74,48.82 271.14,50.22 273.37,50.22 275.23,52.08 276.68,52.08 276.94,51.82 279.06,51.82 279.48,52.25 281.95,52.25 282.74,51.46 v2(282.74,51.43) 283.03,51.72 283.47,51.72 286.21,48.98 v2(286.55,48.98) ; v2(278.89,67.21) 278.89,66.39 279.41,65.87 280.82,65.87 281.62,65.07 281.62,60.39 v2(281.82,60.19)
  BOTTOM w0.112: v2(281.82,60.19) 281.69,60.06 281.69,57.49 278.57,54.37 278.57,53.25 279.27,52.55 JNGFF1.70 280.99,52.54 281.64,52.54 282.73,51.45 282.73,51.44 v2(282.74,51.43) ; JNGFF1.55 287.12,48.8 286.95,48.98 v2(286.55,48.98) ; v2(278.89,67.21) 278.87,67.21 274.85,71.24 274.85,72.27 275.2,72.62 JNGFF2.46
PCIE_WAKE#_R: length 115.1
  TOP w0.112: UE1.N13 272.29,46.66 272.29,47.38 272.82,47.91 272.82,48.37 v2(272.87,48.42) 273.22,48.77 RE35.1 ; v2(182.93,53.13) 182.85,53.05 180.05,53.05 v1(178.49,51.48) 175.32,48.32 RE275.1
  IN1 w0.119: v2(272.87,48.42) 272.84,48.42 272.59,48.17 267.82,48.17 267.68,48.03 266.83,48.03 266.55,47.75 261.32,47.75 260.45,46.87 259.53,46.87 259.11,46.45 257.9,46.45 256.65,47.69 253.31,47.69 244.91,39.29 244.23,39.29 244.2,39.26 242.52,39.26 242.19,39.59 237.94,39.59 237.38,40.14 231.69,40.14 231.59,40.24 229.86,40.24 229.56,39.94 224.32,39.94 224.02,40.24 223.69,40.24 223.69,40.23 223.03,40.23 222.74,39.94 216.56,39.94 215.62,39 211.99,39 211.21,39.78 206.86,39.78 205.57,41.07 204.54,41.07 203.28,42.33 201.89,42.33 197.02,47.2 195.73,47.2 190.46,52.47 188.87,52.47 188.72,52.32 184.25,52.32 183.44,53.13 v2(182.93,53.13)
PD1_GPIO0: length 4.6
  TOP w0.076: UT5.B2 30.51,63.56 30.51,63.93 30.75,64.17 30.93,64.17 31.6,64.84
  TOP w0.102: RT69.1 32.39,65.63 31.6,64.84
PD1_GPIO2: length 4.2
  TOP w0.076: 29.01,57.65 29.01,59.06 UT5.D10
  TOP w0.112: 29.01,57.65 29.01,57.51 29.15,57.37 v2(29.39,57.37)
  BOTTOM w0.102: RT71.1 28.7,57.8 v3(28.7,57.12) 29.14,57.12 v2(29.39,57.37)
PD1_GPIO5: length 4.1
  TOP w0.076: 28.51,57.71 28.51,59.06 UT5.E10
  TOP w0.112: v2(28.2,57.31) 28.51,57.62 28.51,57.71
  BOTTOM w0.102: RT74.1 27.09,57.36 26.77,57.04 v3(26.46,57.04)
  BOTTOM w0.112: RT74.1 27.61,57.31 v2(28.2,57.31)
PD1_GPIO6: length 7.7
  TOP w0.076: UT5.G10 27.51,59.06 27.51,58.19 26.97,57.65
  TOP w0.102: v3(24.37,54.39) 24.98,55 25.61,55 26.09,54.51 RT75.1
  TOP w0.112: 26.97,57.65 26.37,57.05 26.37,54.65 RT75.1
PD1_GPIO7: length 4.5
  TOP w0.076: v2(29.73,61.07) 29.52,61.07 UT5.D7
  BOTTOM w0.102: RT339.1 32.84,60.19 30.61,60.19 v3(30.2,60.6) v2(29.73,61.07)
PD1_GPIO8: length 3.4
  TOP w0.076: v2(26.79,61.65) 26.92,61.65 UT5.H6
  BOTTOM w0.102: v3(27.4,61.96) 27.09,61.65 v2(26.79,61.65) ; RT76.1 26.03,61.68 RT377.1
  BOTTOM w0.112: v2(26.79,61.65) 26.76,61.68 RT377.1
PD#: length 9.9
  TOP w0.102: UA1.47 298.51,35.91 297.82,36.6 296.93,36.6 v1(296.36,37.18) 295.59,37.94 294.77,37.94 CA31.1 293.25,38.45 RA18.1 292.79,37.99 RA50.2 RA48.2 291.31,37.93 DA8.2
PECI_EC: length 248
  TOP w0.112: RE60.2 270.5,50.59 270.5,51.24 269.41,52.33 v1(269.41,55.72) 269.41,59.18 269.08,59.5 v2(268.73,59.5)
  IN1 w0.119: v2(127.05,115.98) 127.06,115.99 144.06,115.99 154.48,105.57 155.89,105.57 157.53,107.2 164.2,107.2 166.23,105.17 166.23,102.26 163.64,99.66 163.64,93.76 164.31,93.09 164.31,89.56 164.78,89.08 164.79,89.08 165.9,87.97 165.9,87.4 165.04,86.54 165.04,84.62 165.32,84.33 167.57,84.33 168.11,84.87 171.9,84.87 172.23,85.2 174.23,85.2 174.71,84.72 174.71,84.47 176.2,82.97 177.24,82.97 177.5,82.71 177.5,77.95 176.3,76.75 176.3,73.93 175.83,73.47 175.83,70.5 177.62,68.71 177.62,67.44 179.8,65.26 190.17,65.26 191.14,64.29 194.46,64.29 207.52,51.24 207.93,51.24 209.41,49.75 239.91,49.75 241.75,51.59 244.32,51.59 253.91,61.17 264.22,61.17 265.04,60.35 267.97,60.35 268.73,59.6 v2(268.73,59.5)
  BOTTOM w0.076: UC1.A54 114.63,88.72 114.63,89.95 114.46,90.12 114.46,90.72 114.46,91.07 114.33,91.2 114.33,91.64 117.33,94.64 118.56,94.64 120.93,97.01 120.93,97.65
  BOTTOM w0.112: v2(127.05,115.98) 127.64,115.39 127.64,110.87 127.45,110.68 127.45,110.14 125.69,108.38 125.69,105.52 124.64,104.47 123.32,104.47 120.93,102.08 120.93,97.65
PECI_EC_R: length 3.4
  TOP w0.112: 269.62,46.39 269.62,47.03 v3(270.84,48.25) 270.98,48.39 RE60.1
PGOOD_3V: length 3.9
  BOTTOM w0.102: v3(236.4,24.31) 237.12,24.31 PR119.1
  BOTTOM w0.254: PU100.9 236.76,26.43 237.48,25.71 PR107.2 PR119.1
PGOOD_5V: length 4.3
  BOTTOM w0.203: PU102.9 34.76,43.73 34.46,43.43 v3(33.7,43.43) 33.09,43.43 32.98,43.32
  BOTTOM w0.254: 32.98,43.32 32.59,42.92 PR120.1 PR113.2
PLTRST_LAN#: length 178.4
  TOP w0.112: v2(176.28,90.09) 176.3,90.1 177.62,90.1 178.48,89.24 179.68,89.24 186.52,82.41 186.52,77.03 188.52,75.03 188.52,69.68 190.78,67.42 191.02,67.42 196.03,62.4 196.03,56.09 205.67,46.46 205.67,44.22 208.15,41.73 208.15,37.35 209.3,36.2 215.56,36.2 215.88,36.51 225.56,36.51 229.61,40.56 231.13,40.56 235.93,45.35 240.15,45.35 240.87,46.07 243.38,46.07 246.03,48.72 246.03,49.52 259.65,63.14 259.65,72.67 258.61,73.72 258.61,77.88 265.24,84.51 265.24,95.14 v1(266.93,96.83) 268.74,98.65 271.05,98.65 272.77,96.92 272.97,96.92 273.1,97.05 UL1.36
  BOTTOM w0.112: RC62.2 176.63,89.17 176.28,89.52 v2(176.28,90.09)
PLTRST_TPM#: length 10.1
  BOTTOM w0.112: UZ12.17 172.53,86.05 172.85,86.36 172.85,87.34 173.29,87.79 173.29,90.65 173.8,91.15 RC325.2 174.07,91.85 RC60.2 175.89,91.49 v3(175.33,91.49)
PM_LANPHY_ENABLE: length 195.6
  TOP w0.102: RL7.1 v2(270.39,88.49)
  IN2 w0.102: v2(190.79,71.57) 191.12,71.57 210.96,51.72 239.88,51.72 241.24,53.08 241.96,53.08 254.4,65.53 254.81,65.53 257.21,67.92 257.21,75.47 270.23,88.49 v2(270.39,88.49)
  BOTTOM w0.076: UC1.AW17 135.77,67.84 135.6,67.66 135.6,67.66 135.38,66.96 135.38,66.88 135.33,66.72 135.33,66.58 135.39,66.36 135.39,66.24 135.34,66.13 135.34,65.76 135.54,65.57 135.54,63.92 136.28,63.18 136.28,61.43 137.01,60.69 138.11,60.69 138.42,61.01 138.72,61.01 138.92,60.8 138.92,59.1 140.45,57.58 140.45,56.82
  BOTTOM w0.102: v2(190.79,71.57) 190.55,71.32 190.55,69.15 191.5,68.21 v3(191.5,67.13) 191.5,66.43 190.86,65.79 190.86,63.29 192.31,61.83 192.31,60.38 189.5,57.57 185.93,57.57 182.95,54.6 178.97,50.62 149.39,50.62 147.61,52.39 142.29,52.39 140.45,54.24 140.45,56.82
PME#: length 2.3
  TOP w0.102: v2(138.85,68.74) 138.29,69.3 138.29,69.92 T115.1
  BOTTOM w0.076: UC1.AU11 139.07,69.1 138.83,68.86 138.83,68.76 v2(138.85,68.74)
POA_WAKE#: length 24.8
  TOP w0.102: v2(266.14,29.13) 265.95,28.95 RE324.1 265.69,28.23 v3(264.92,27.46)
  TOP w0.107: UE1.E4 265.23,38.8 v2(265.23,38.79)
  IN1 w0.102: v2(266.14,29.13) 266.92,28.35 273.72,28.35 v2(274.08,28.71)
  BOTTOM w0.102: v2(274.08,28.71) 273.65,28.28 JUSH1.4 ; v2(266.14,29.13) 265.77,29.51 265.26,29.51 265.1,29.66 265.1,31.51 264.73,31.88 264.73,32.51 265.02,32.8 265.02,33.32 265.53,33.83 265.53,34.75 264.74,35.55 264.74,36.81 265.6,37.68 265.6,38.14 265.22,38.52 265.22,38.78 v2(265.23,38.79)
PORT80_DET#: length 89.1
  TOP w0.102: v2(283.35,39.81) 283.35,39.6 282.63,38.88 RE513.1 RE512.1 ; v2(274.99,62.99) 274.48,62.49 v3(274.28,62.49) 274.11,62.49 273.81,62.78 273.81,64.25 RZ131.1 ; v2(270.02,38.69) 270.02,38.71 269.62,39.11 269.62,39.19
  IN1 w0.102: v2(274.99,62.99) 275.78,63.79 275.78,70.86 276.38,71.46 v2(276.38,71.54) ; v2(270.02,38.69) 270.02,38.73 270.37,39.08 271.71,39.08 272.11,38.68 273.11,38.68 273.57,38.23 274.08,38.23 274.65,38.8 280.17,38.8 280.65,39.28 282.82,39.28 v2(283.35,39.81) 286.51,39.81 291.82,45.12 291.82,47.41 292.25,47.84 292.25,48.71 292.83,49.29 293.94,49.29 295.13,50.48 295.13,52.07 295.33,52.27 295.33,55.89 296.9,57.46 297.01,57.46 298.25,58.7 298.25,62 v2(298.26,62.01)
  IN2 w0.102: v2(276.38,71.54) 279.16,68.76 280.75,68.76 281.43,68.07 281.43,68.03 287.27,62.19 293.68,62.19 293.9,62.41 297.86,62.41 v2(298.26,62.01)
POWER_SW#_MB: length 160.6
  TOP w0.112: v2(250.07,33.6) CE10.1 250.05,32.98 RE33.2 249.33,32.06 v1(248.76,31.49) ; SW3.4 SW3.2 318.6,104.44 v2(317.35,104.44)
  IN3 w0.135: v2(250.07,33.6) 250.88,34.41 252.4,34.41 252.79,34.8 258.58,34.8 259.26,34.12 262.33,34.12 262.78,34.56 271.88,34.56 272.21,34.89 272.21,36.72 273.59,38.11 273.96,38.11 274.27,38.41 274.27,38.63 274.71,39.08 274.72,39.08 276.44,40.8 276.98,40.8 277.52,41.34 277.52,44.28 277.05,44.74 277.05,50.92 278.35,52.21 278.35,52.52 278.71,52.88 278.71,53.95 279.42,54.66 281.77,54.66 282.79,55.67 284.01,55.67 285.46,54.23 292.81,54.23 293.33,54.75 293.84,54.75 295.47,56.37 295.47,60.16 295.81,60.5 295.81,62.51 295.44,62.88 295.44,65.08 296.52,66.16 296.52,69.85 297.14,70.47 299.26,70.47 299.66,70.07 300.42,70.07 301.92,71.57 301.92,73.2 299.53,75.6 296.46,75.6 290.2,81.86 290.2,86.58 289.67,87.11 289.67,98.09 v2(289.13,98.62)
  BOTTOM w0.112: JAPS1.11 v2(317.35,104.44) 316.51,105.28 308,105.28 302.99,100.26 290.77,100.26 v2(289.13,98.62)
POWER_SW_IN#: length 22.2
  TOP w0.112: v2(258.14,38.03) 256.89,38.03 256.29,37.43 v1(256.29,37.05) 256.29,34.96 255.32,33.99 254.67,33.99 254.56,33.88 254.56,32.22 253.93,31.6 252.44,31.6 CE12.1 251.89,31.08 RE31.2 250.93,31.15 RE33.1 ; v2(264.42,39.59) UE1.D5
  BOTTOM w0.112: v2(264.42,39.59) 264.42,39.67 264.11,39.99 262.19,39.99 261.53,39.32 260.62,39.32 259.8,38.51 259.8,37.8 259.49,37.49 258.55,37.49 258.14,37.9 v2(258.14,38.03)
PRIM_PWRGD_GPIO024: length 8.2
  TOP w0.102: v3(261.63,30.26) RE362.1 RE361.1
  TOP w0.107: RE361.1 263.14,31.87 263.14,35.91 264.01,36.79 UE1.C1
PROCHOT#_ISL88738: length 45.3
  TOP w0.102: v2(58.23,93.75) 58.23,93.81 57.97,94.07 55.81,94.07 55.48,93.74 55.48,91.99 54.33,90.85 51.21,90.85 48.73,93.33 47.21,93.33 46.93,93.61 46.37,93.61 44.93,95.04 43.99,95.04 43.71,95.33 43.71,96.06 43.1,96.67 42.04,96.67 40.85,95.47 39.15,95.47 38.91,95.71 36.4,95.71 36.01,96.11 35.62,96.11 35.5,96.23 35.5,97.46 v2(35.88,97.84)
  TOP w0.254: v2(58.23,93.75) 58.55,94.07 58.55,94.51 58.68,94.63 PR926.2
  IN2 w0.102: v2(36.83,90.98) 36.24,90.98 35.45,91.76 35.45,92.84 36.2,93.59 36.2,94.52 36.32,94.65 36.32,97.4 v2(35.88,97.84)
  BOTTOM w0.102: v2(36.83,90.98) 36.97,90.84 38.1,90.84 v1(38.42,90.52) 39.37,89.57 PQ1216.1
  BOTTOM w0.203: PU901.23 59.15,93.02 58.41,93.75 v2(58.23,93.75)
PS_ID: length 298.2
  TOP w0.102: v2(30.3,99.14) 30.3,99.11 30.4,99.02 PR5.2 29.46,98.48 PR4.1
  TOP w0.107: v2(270.84,45.18) 270.44,44.79 UE1.L11
  IN2 w0.102: v2(30.3,99.14) 31.62,99.14 37.24,104.75 37.24,105.08 41.13,108.96 58.35,108.96 62.63,113.24 70.78,113.24 71.56,112.46 76.95,112.46 78.65,110.76 92.18,110.76 92.46,111.04 102.49,111.04 102.78,111.33 117.39,111.33 117.57,111.16 120.58,111.16 123.11,113.68 151.21,113.68 157.99,106.9 158.56,106.9 158.85,106.61 159.61,106.61 160.06,106.16 160.06,105.91 160.9,105.07 v2(162.07,105.07) 162.43,104.71 165.45,104.71 166.15,104.01 166.15,102.8 170.71,98.24 171.13,98.24 174.77,94.61 174.77,92.82 176.86,90.72 176.86,89.84 176.74,89.71 176.74,88.29 176.02,87.58 176.02,82.99 186.19,72.83 187.3,72.83 188.4,71.73 188.4,70.55 190.05,68.9 190.05,67.96 190.66,67.35 191.56,67.35 209.73,49.18 232.27,49.18 233.25,48.2 237.01,48.2 237.48,48.67 243.95,48.67 250.32,55.04 256.47,55.04 256.59,55.15 263.92,55.15 264.16,55.39 264.9,55.39 265.54,54.76 267.41,54.76 270.35,51.83 270.35,47.6 270.94,47.01 270.94,45.28 v2(270.84,45.18)
PWM1_GT: length 16.8
  TOP w0.203: v2(56.35,69.58) 56.1,69.58 55.52,70.16 PU602.12
  IN2 w0.254: v2(63.54,75.61) 62.58,74.66 61.41,74.66 v2(61.01,74.26)
  IN3 w0.254: v2(56.35,69.58) 56.46,69.58 58.24,71.36 58.24,72.4 60.1,74.26 v2(61.01,74.26)
  BOTTOM w0.102: v3(67.82,77.17) 67.62,77.37 66.05,77.37 65.78,77.1 PR680.1
  BOTTOM w0.203: 64.94,76.03 63.96,76.03 v2(63.54,75.61)
  BOTTOM w0.254: 65.84,76.03 64.94,76.03
PWM2_GT: length 5.8
  TOP w0.203: v2(56.34,70.15) 56.03,70.45 55.65,70.45 55.55,70.56 PU602.13
  BOTTOM w0.254: PU613.8 57.24,67.6 57.06,67.78 57.06,68.77 57.25,68.97 PR681.1 57.63,69.51 v1(57.03,70.12) 57,70.15 v2(56.34,70.15)
PWM_IA: length 30.1
  TOP w0.102: PR662.1 v3(78.64,78.64)
  TOP w0.203: v2(56.19,76.85) 55.73,76.4 55.73,75.99 55.53,75.79 54.78,75.79 54.49,75.49 54.49,75.15 53.99,74.65 PU602.22 ; PR662.1 77.56,78.58 76.51,78.58 76.3,78.78 PU610.8
  TOP w0.254: v2(77.12,79.32) 77.62,78.81 PR662.1
  IN2 w0.254: v2(56.19,76.85) 57.13,76.85 58.41,78.13 60.87,78.13 61.5,78.76 64.72,78.76 65.11,78.37 76.16,78.37 v2(77.12,79.32)
PWM_SA: length 3.7
  BOTTOM w0.203: PU614.3 72.6,90.77 73.09,91.26
  BOTTOM w0.254: 73.09,91.26 v1(73.95,91.26) PR606.1
PWM_VSA: length 47.8
  TOP w0.203: v2(50.33,75.62) 50.33,75.44 50.79,74.98 PU602.30
  IN1 w0.254: v2(73.31,93.49) 73.31,93.67 72.42,94.56 72.06,94.56 69.91,96.71 55.21,96.71 50.68,92.18 50.68,89.15 49.61,88.08 49.61,85.08 49.33,84.8 49.33,80.23 49.43,80.13 49.43,77.71 50.33,76.81 v2(50.33,75.62)
  BOTTOM w0.254: v2(73.31,93.49) 73.31,93.32 v1(73.62,93.01) 74.46,92.17 PR606.2
REM_DIODE1_N: length 166.1
  TOP w0.127: v2(131.05,76.27) 130.97,76.35 QE3.3 129.72,76.8 CE35.1 ; UE1.A8 262.15,42.11 261.14,42.11 260.99,41.97 260.53,41.97 CE24.1 259.59,42.3 v2(259.57,42.27)
  IN1 w0.127: v2(256.9,51.4) 256.74,51.56 252.58,51.56 244.22,43.2 232.96,43.2 232.86,43.3 230.39,43.3 229.93,43.75 226.82,43.75 226.52,43.45 222.91,43.45 222.58,43.79 221.64,43.79 221.64,43.79 207.7,43.79 206.99,44.5 205.7,45.79 204.44,45.79 198.07,52.16 197.68,52.16 192.28,57.56 190.18,57.56 188.83,58.91 188.67,58.91 183.91,58.91 183.33,58.33 182.06,58.33 180.56,59.83 179.5,59.83 179.05,59.38 175.59,59.38 172.92,62.05 172.92,64.82 169.24,68.5 167.09,68.5 164.82,70.78 163.32,70.78 162.99,71.11 161.13,71.11 160.12,70.11 158.05,70.11 157.43,70.73 152.01,70.73 151.12,69.84 150.31,69.84 150.05,70.1 150.05,70.37 v2(149.84,70.58)
  IN2 w0.127: v2(256.9,51.4) 257.03,51.52 257.29,51.52 257.43,51.38 257.43,50.31 257.05,49.93 257.05,47.92 259.63,45.34 259.63,43.99 260.14,43.47 260.14,42.18 260.02,42.05 259.79,42.05 v2(259.57,42.27)
  IN3 w0.127: v2(131.05,76.27) 131.28,76.04 131.28,75.69 131.79,75.19 139.34,75.19 140.34,74.19 140.34,73.51 140.74,73.11 144.21,73.11 145.46,71.86 147.08,71.86 147.61,71.33 149.77,71.33 150.08,71.03 150.08,70.81 v2(149.84,70.58)
REM_DIODE1_P: length 168.5
  TOP w0.127: v2(259.57,41.65) 259.94,41.65 CE24.2 260.53,41.71 261.1,41.71 261.24,41.86 262.15,41.86 UE1.A7 ; v2(131.81,76.27) 132.07,76.53 QE3.1 130.82,77 QE3.2 130.11,77.71 CE35.2
  IN1 w0.127: v2(150.54,70.58) 150.31,70.35 150.31,70.2 150.42,70.09 151.01,70.09 151.9,70.98 157.54,70.98 158.16,70.36 160.02,70.36 161.02,71.37 163.09,71.37 163.43,71.03 164.92,71.03 167.2,68.76 169.35,68.76 173.17,64.93 173.17,62.16 175.7,59.64 178.95,59.64 179.4,60.08 180.67,60.08 182.17,58.58 183.22,58.58 183.8,59.16 188.78,59.16 188.94,59.16 190.28,57.82 192.39,57.82 197.78,52.42 198.17,52.42 204.55,46.04 205.8,46.04 205.89,45.96 207.81,44.04 221.53,44.04 221.54,44.04 222.68,44.04 223.02,43.71 226.42,43.71 226.71,44.01 230.04,44.01 230.49,43.55 232.97,43.55 233.06,43.45 244.12,43.45 252.47,51.81 256.81,51.81 v2(256.95,51.95)
  IN2 w0.127: v2(256.95,51.95) 257.13,51.78 257.39,51.78 257.69,51.49 257.69,50.21 257.3,49.83 257.3,48.02 259.89,45.44 259.89,44.09 260.4,43.58 260.4,42.07 260.12,41.79 259.72,41.79 v2(259.57,41.65)
  IN3 w0.127: v2(131.81,76.27) 131.54,76 131.54,75.79 131.89,75.45 139.44,75.45 140.59,74.3 140.59,73.62 140.85,73.36 144.31,73.36 145.56,72.11 147.19,72.11 147.71,71.59 149.87,71.59 150.33,71.13 150.33,70.79 v2(150.54,70.58)
REM_DIODE2_N: length 116.8
  TOP w0.127: CE26.1 260.06,43.78 261.02,43.78 v2(261.16,43.92) 261.35,43.74 262.17,43.74 UE1.A10
  IN1 w0.127: v2(261.16,43.92) 261.37,43.72 261.71,43.72 263.04,42.39 271.88,42.39 272.61,41.66 272.61,41.17 272.86,40.91 277.12,40.91 278.66,42.46 279.85,42.46 280.19,42.12 283.9,42.12 284.58,42.8 286.01,42.8 286.69,42.12 v2(286.98,42.12)
  IN3 w0.127: v2(208.75,37.37) 208.99,37.37 209.06,37.43 209.06,37.43 209.36,37.74 210.81,37.74 211.37,37.18 230.27,37.18 230.8,37.71 231.48,37.71 231.76,37.43 238.4,37.43 239.73,36.09 242.78,36.09 244.9,38.21 246.7,38.21 247.48,38.99 247.71,38.99 250.36,41.64 251.73,41.64 251.74,41.65 253.3,41.65 253.32,41.64 253.78,41.64 253.99,41.43 256.03,41.43 258.47,43.87 259.86,43.87 259.97,43.76 261,43.76 v2(261.16,43.92)
  BOTTOM w0.127: CE37.2 294.38,37.43 293.18,37.43 292.89,37.13 292,37.13 QE5.3 291.09,37.02 290.76,37.02 v4(290.5,37.29) 290.04,37.74 288.05,37.74 287.07,38.73 287.07,41.46 286.98,41.55 286.98,42.12 v2(286.98,42.12) ; v2(208.75,37.37) 208.75,37.18 208.43,36.86 204.24,36.86 202.9,38.19 199.85,38.19 199.77,38.12 199.02,38.12 198.89,38.25 198.89,38.52 CE46.2 198.91,39.2 198.91,39.74 199.17,40 QE7.2 199.45,40.8 198.8,41.45 QE7.1
REM_DIODE2_P: length 114.7
  TOP w0.127: UE1.A9 262.12,43.48 261.31,43.48 v2(261.18,43.35) 261,43.53 260.03,43.53 CE26.2
  IN1 w0.127: v2(286.45,41.73) 286.45,42.01 285.91,42.54 284.68,42.54 284.01,41.87 280.08,41.87 279.74,42.2 278.77,42.2 277.22,40.66 272.76,40.66 272.36,41.06 272.36,41.56 271.77,42.14 262.93,42.14 261.61,43.46 261.29,43.46 v2(261.18,43.35)
  IN3 w0.127: v2(261.18,43.35) 261.02,43.5 259.87,43.5 259.76,43.62 258.58,43.62 256.14,41.18 253.88,41.18 253.68,41.38 253.21,41.38 253.2,41.4 251.85,41.4 251.83,41.38 250.46,41.38 247.82,38.74 247.59,38.74 246.8,37.95 245.01,37.95 242.89,35.84 239.63,35.84 238.29,37.17 231.66,37.17 231.38,37.45 230.91,37.45 230.38,36.92 211.26,36.92 210.7,37.48 209.47,37.48 209.23,37.25 v2(209.23,37)
  BOTTOM w0.127: CE37.1 294.64,36.88 QE5.1 292.25,36.88 QE5.2 291.07,36.76 290.66,36.76 289.94,37.49 287.95,37.49 286.81,38.62 286.81,41.36 v2(286.45,41.73) ; QE7.3 198.41,40 198.66,39.75 198.66,39.2 CE46.1 198.63,38.56 198.63,38.14 198.91,37.86 199.88,37.86 199.95,37.94 202.8,37.94 204.13,36.6 208.53,36.6 208.93,37 v2(209.23,37)
REM_DIODE4_N: length 251.4
  TOP w0.127: v2(83.72,91.99) 83.57,92.14 83.57,92.56 80.77,95.36 80.77,98.35 83,100.57 83,101.72 85.13,103.85 87.97,103.85 90.56,106.44 95.69,106.44 96.65,107.41 98.73,107.41 100.48,109.17 100.48,112.76 101.45,113.73 104.88,113.73 105.77,114.62 133.11,114.62 135.26,112.47 155.21,112.47 159.45,108.22 160.34,108.22 161.81,106.76 161.81,106.13 162.74,105.19 164.65,105.19 164.75,105.29 166.32,105.29 166.74,104.87 168.17,104.87 v2(168.33,104.7) ; v2(258.33,48.43) 258.12,48.23 258.12,47.83 259.23,46.72 259.23,45.84 259.49,45.58 259.82,45.58 CE27.1 260.48,45.55 260.67,45.55 261.35,44.88 261.73,44.88 261.93,44.67 262.31,44.67 UE1.A11
  IN1 w0.127: v2(193.28,70.95) 193.42,70.81 193.6,70.81 193.73,70.94 193.73,71.43 192.37,72.79 192.37,80.55 179.99,92.93 178.32,92.93 176.79,94.46 171.63,94.46 168.87,97.22 167.1,97.22 166.62,97.69 166.62,100.07 168.84,102.28 168.84,104.69 168.66,104.87 168.5,104.87 v2(168.33,104.7)
  BOTTOM w0.127: v2(193.28,70.95) 193.42,70.81 193.98,70.81 196.38,68.4 196.38,65.92 211.85,50.45 233.78,50.45 235.05,51.72 238.06,51.72 238.33,51.72 240.82,54.22 244.84,54.22 247.48,51.57 253.37,51.57 255.19,49.75 257.34,49.75 258.14,48.96 258.14,48.62 v2(258.33,48.43) ; v2(83.72,91.99) 83.72,92.44 83.91,92.63 84.82,92.63 85.04,92.42 QE6.3 85.95,91.27 CE39.1
REM_DIODE4_P: length 254.7
  TOP w0.127: UE1.B10 263.05,43.99 262.62,44.42 261.82,44.42 261.62,44.62 261.24,44.62 260.57,45.3 260.46,45.3 CE27.2 259.79,45.33 259.38,45.33 258.98,45.73 258.98,46.61 257.87,47.73 257.87,48.27 v2(257.7,48.44) ; v2(83.13,91.99) 83.31,92.17 83.31,92.46 80.52,95.25 80.52,98.46 82.74,100.68 82.74,101.82 85.03,104.11 87.86,104.11 90.45,106.7 95.58,106.7 96.55,107.66 98.62,107.66 100.23,109.27 100.23,112.87 101.35,113.99 104.78,113.99 105.67,114.88 133.21,114.88 135.37,112.72 155.31,112.72 159.56,108.48 160.45,108.48 162.06,106.86 162.06,106.23 162.85,105.45 164.54,105.45 164.63,105.54 166.43,105.54 166.85,105.12 168.17,105.12 v2(168.33,105.29)
  IN1 w0.127: v2(193.28,70.37) 193.46,70.55 193.7,70.55 193.98,70.83 193.98,71.54 192.63,72.89 192.63,80.66 180.09,93.19 178.42,93.19 176.9,94.71 171.73,94.71 168.97,97.47 167.21,97.47 166.88,97.8 166.88,99.96 169.09,102.18 169.09,104.79 168.76,105.12 168.5,105.12 v2(168.33,105.29)
  BOTTOM w0.127: v2(83.13,91.99) 83.14,92 QE6.1 83.79,93.48 QE6.2 85.83,92.69 85.83,92.59 CE39.2 ; v2(193.28,70.37) 193.46,70.55 193.87,70.55 196.13,68.3 196.13,65.81 211.75,50.2 233.89,50.2 235.16,51.47 237.79,51.47 238.06,51.47 238.43,51.47 240.93,53.96 244.73,53.96 247.38,51.32 253.26,51.32 255.08,49.5 257.24,49.5 257.88,48.85 257.88,48.63 v2(257.7,48.44)
RES_BIAS: length 5.3
  TOP w0.102: UL1.12 278.24,91.44 279.23,90.46 279.59,90.46 280.7,89.35 v3(280.88,89.35) RL13.1
RESET_OUT#_R: length 4.1
  BOTTOM w0.112: JXDP1.47 75.01,100.83 74.11,99.93 CC33.1 73.98,99.07 RC129.2 RC128.2
RING2: length 13.2
  BOTTOM w1.27: 303.6,20.41 303.6,22.45 304.36,23.21 304.36,27.4 302.77,28.99 299.15,28.99
  vias: v1(298.33,28.99) v2(298.33,28.14) v2(298.93,28.12) v2(302.64,19.45) v2(302.64,18.87) v2(302.64,18.28)
RING2_R: length 30.9
  TOP w0.127: 309.44,17.93 309.82,17.93 v1(310.29,17.46)
  IN3 w0.762: JHP1.4 320.92,23.8 317.79,26.94
  IN3 w1.27: 317.79,26.94 317.79,29.28 316.52,30.55 310.64,30.55 309.74,29.65 308.01,29.65 306.72,28.35 306.72,18.36
  vias: v2(307.68,18.4) v2(308.32,18.4) v2(308.95,18.4)
RJ45_MDIN0: length 7.8
  BOTTOM w0.267: TL1.23 304.87,80.73 305.31,80.29 306.21,80.29 v4(307.14,81.21) 308.64,82.72 309.29,83.41 309.28,83.77 309.15,83.9 JLOM1.2
RJ45_MDIN1: length 7.1
  IN1 w0.203: JLOM1.6 307.86,86.87 307.86,85.69 307.74,85.57 306.08,85.57 v2(306.02,85.63)
  BOTTOM w0.267: v2(306.02,85.63) 305.96,85.57 304.88,85.57 304.63,85.81 TL1.19
RJ45_MDIN2: length 7
  BOTTOM w0.267: TL1.17 305.09,88.35 305.28,88.17 306.86,88.17 v4(307.2,87.83) 308.07,86.96 310.07,86.96 JLOM1.5
RJ45_MDIN3: length 8.3
  BOTTOM w0.267: JLOM1.8 308.97,89.61 308.71,89.35 307.9,89.35 v4(307.07,90.18) 306.4,90.85 306.4,92.2 306.05,92.55 305.44,92.55 304.55,93.43 TL1.13
RJ45_MDIP0: length 7.8
  BOTTOM w0.267: TL1.24 304.87,79.46 305.31,79.91 v4(306.06,79.91) 306.37,79.91 307.35,80.89 307.35,80.89 307.41,80.94 308.91,82.45 309.05,82.59 309.33,82.88 JLOM1.1
RJ45_MDIP1: length 7.1
  IN1 w0.203: v2(306.01,84.87) 306.39,85.24 307.87,85.24 308.19,84.92 JLOM1.3
  BOTTOM w0.267: TL1.20 304.23,84.54 304.87,85.18 305.79,85.18 306.01,84.97 v2(306.01,84.87)
RJ45_MDIP2: length 6.9
  BOTTOM w0.267: TL1.18 304.5,87.08 305.21,87.79 306.7,87.79 307.91,86.58 308.99,86.58 309.15,86.42 309.15,86.12 JLOM1.4
RJ45_MDIP3: length 8.5
  BOTTOM w0.267: TL1.14 305.89,92.16 306.02,92.04 v4(306.02,91.33) 306.02,90.69 307.74,88.97 310.04,88.97 310.05,88.97 JLOM1.7
RTCRST_ON: length 10.4
  TOP w0.102: QE12.2 253.49,38.14 254.64,36.98 255.31,36.98 255.61,37.28 255.61,37.95 256.34,38.69 RE515.2 RE514.2 257.24,38.82 v1(257.49,38.56) 257.86,38.56 258.21,38.91 258.85,38.91 RE93.1
RTCRST_ON_GPIO122: length 13.5
  TOP w0.102: UE1.F11 266.42,44.81 v2(266.02,45.22) ; v2(259.03,43.22) v3(258.41,43.22) 257.77,43.22 256.34,41.79 RE515.1
  IN1 w0.102: v2(259.03,43.22) 259.03,43.89 260.57,45.42 262.36,45.42 262.56,45.62 263.27,45.62 263.4,45.75 265.48,45.75 v2(266.02,45.22)
RTCRST_ON_GPIO141: length 6.8
  TOP w0.102: UE1.B6 263.2,40.79 v2(262.83,40.42) ; v2(258.9,40.3) 258.36,40.85 v3(258.21,40.85) RE514.1
  IN1 w0.102: v2(262.83,40.42) 262.79,40.42 262.14,39.77 259.44,39.77 v2(258.9,40.3)
RTD3_CIO_PWR_EN: length 239.9
  TOP w0.102: v3(163.05,81.31) 162.63,80.88 v2(162.63,80.36)
  IN1 w0.102: v2(162.63,80.36) 161.12,80.36 160.74,80.74 160.74,84.95 161.29,85.5 162.06,85.5 163.64,87.09 163.64,92.6 163.02,93.22 163.02,95.03 161.16,96.89 161.16,100.06 160.15,101.07 160.15,103.88 161.5,105.23 v2(161.5,105.53)
  IN2 w0.102: v2(161.5,105.53) 160.73,105.53 160.27,105.99 160.27,106.24 159.59,106.92 158.83,106.92 158.54,107.21 157.97,107.21 151.29,113.89 123.03,113.89 120.5,111.36 117.66,111.36 117.48,111.54 102.69,111.54 102.4,111.25 92.36,111.25 92.08,110.97 78.73,110.97 77.04,112.66 71.65,112.66 70.86,113.44 62.54,113.44 58.26,109.17 41.04,109.17 37.04,105.16 37.04,104.84 33.46,101.26 31.07,101.26 29.66,99.86 29.66,98.82 31.5,96.99 31.5,94.97 34.19,92.27 34.19,85.74 36.64,83.29 36.64,81.13 37.44,80.33 37.44,79.24 36.97,78.77 35.36,78.77 34.56,79.57 32.54,79.57 30.86,77.89 26.26,77.89 v2(25.97,78.18) ; v2(162.63,80.36) 162.34,80.07 156.85,80.07 155.81,81.11 153.53,81.11 152.33,82.31 150.35,82.31 148.45,80.4 146.65,80.4 146.12,79.87 146.12,77.94 146.08,77.9 146.08,77.34 v2(147.16,76.26)
  BOTTOM w0.076: v2(147.16,76.26) 147.16,76.27 146.81,76.62 146.2,76.62 145.97,76.85 144.91,76.85 UC1.AC2
  BOTTOM w0.102: RT25.1 RT372.1 26.39,77.76 v2(25.97,78.18) RT392.2
RTD3_CIO_PWR_EN_R: length 2.2
  TOP w0.076: UT1.F1 26.17,80.77 v2(25.97,80.56)
  BOTTOM w0.102: RT392.1 v2(25.97,80.56) v3(25.97,81.04)
RTD3_USB_PWR_EN: length 2.6
  TOP w0.102: UT1.D4 v2(25.36,82.9)
  BOTTOM w0.102: v3(24.58,82.9) 25.35,82.9
  BOTTOM w0.112: v2(25.36,82.9) 24.69,82.24 RT26.1
RUN_ON: length 600
  TOP w0.102: v2(43.84,56) 43.96,55.87 PR1301.1 ; v2(202.24,35.71) 202.21,35.71 201.99,35.49 UZ3.5 ; v2(277.32,22.51) 277.42,22.51 278.17,23.26 278.44,23.26 283.4,28.23 QE2.2 ; RZ345.1 169.38,63.59 169.61,63.37 170.74,63.37 171.93,64.56 171.93,66.86 172.25,67.17 172.25,70.78 172.89,71.42 172.89,76.38 174.45,77.94 v2(174.45,79.68) ; UE5.4 256.35,51.49 256.25,51.59 255.54,51.59 RE292.1 254.41,51.35 RE280.2 253.4,50.37 253.4,50.12 ; v2(249.46,42.91) 249.1,43.26 249.1,46.89 252.34,50.12 253.4,50.12 ; 253.4,50.12 v2(253.43,50.12) ; v2(153.01,108.39) 152.79,108.17 142.39,108.17 141.25,109.31 140.58,109.31 140.11,108.84 134.6,108.84 133.87,108.11 v2(133.06,108.11) ; v2(275.72,77.44) 275.72,77.62 v1(276.96,78.86) 277.24,79.14 285.75,79.14 285.98,78.91 UZ4.3 ; v2(204.62,30.69) 204.62,25.46 v2(202.85,23.69)
  IN1 w0.102: v2(275.72,77.44) 275.29,77.01 275.29,75.02 272.72,72.45 272.72,60.48 272.09,59.85 272.09,57.29 269.2,54.4 269.2,53.67 269.05,53.51 268.34,53.51 266.1,51.27 264.49,51.27 263.57,50.34 263.06,50.34 262.69,50.7 257.61,50.7 257.42,50.51 255.22,50.51 254.83,50.12 v2(253.43,50.12)
  IN2 w0.102: v2(43.84,56) 43.46,56.37 43.46,64.73 44.88,66.14 44.88,70.8 43.96,71.72 43.96,75.34 43.22,76.07 43.22,83.82 43.11,83.93 43.11,86.55 41.27,88.38 41.27,91.78 40.43,92.62 40.43,95.19 38.66,96.96 38.66,101.73 39.77,102.84 40.63,102.84 41.52,101.95 43.22,101.95 46.09,104.82 52.38,104.82 54.33,102.87 58.65,102.87 59.78,104.01 71.21,104.01 71.95,103.27 74.91,103.27 76.55,104.91 96.96,104.91 97.79,104.08 106.48,104.08 106.9,104.5 106.96,104.5 106.97,104.5 108.81,104.5 118.69,104.5 119.41,105.23 120.11,105.23 122.4,107.51 126.07,107.51 126.74,106.85 128.2,106.85 129.47,108.11 v2(133.06,108.11) ; v2(202.85,23.69) 220.39,23.69 223.01,21.07 233.8,21.07 234.55,21.81 235.27,21.81 236.02,21.07 276.42,21.07 277.32,21.97 v2(277.32,22.51) ; v2(253.43,50.12) 251.34,50.12 247.24,46.02 244.59,46.02 243.93,45.36 232.96,45.36 231.69,46.64 208.91,46.64 198.54,57.02 197.75,57.02 197.26,57.51 197.26,57.63 187.84,67.04 187.84,67.99 180.99,74.84 180.89,74.84 177.96,77.77 176.19,77.77 175.66,78.29 175.66,78.47 v2(174.45,79.68) 174.45,80.93 172.94,82.44 172.94,84.65 173.29,84.99 173.3,84.99 173.55,85.25 173.55,86.11 172.98,86.68 172.98,93.68 169.56,97.11 166.92,97.11 165.72,98.31 164.91,99.12 160.51,99.12 159.74,99.89 159.74,101.82 159.1,102.46 158.41,102.46 157.38,103.49 157.38,104.89 153.88,108.39 v2(153.01,108.39)
  IN3 w0.102: v2(168.25,116.43) 174.83,116.43 177.8,113.46 188.77,113.46 v2(191.52,110.71)
  BOTTOM w0.102: v2(191.52,110.71) 191.37,110.56 PR402.1 ; v2(153.01,108.39) 153.01,109.13 154.6,110.73 164.34,110.73 167.16,113.54 167.16,115.33 v2(168.25,116.43) ; v2(249.46,42.91) 251.67,40.7 251.67,36.91 252.39,36.19 252.39,33.81 251.53,32.95 251.53,30.87 252.9,29.5 254.25,29.5 255.43,28.31 255.43,26.67 257.05,25.05 257.05,22.67 258.2,21.53 276.43,21.53 277.32,22.41 v2(277.32,22.51) ; v2(133.06,108.11) 133.34,107.83 133.34,107.22 134.56,106 UZ35.2 134.56,105.31 134.38,105.14 RZ320.1 ; v2(204.62,30.69) 204.15,31.16 204.15,34.41 204.05,34.51 204.02,34.51 202.82,35.71 v2(202.24,35.71)
RUN_ON#: length 4.7
  TOP w0.102: QE2.5 v3(283.4,32.18) 282.97,32.18 282.75,31.96 QE2.6 282.58,30.92 282.58,30.45 282.41,30.28 RE68.1
RUN_ON_EC: length 59.3
  TOP w0.102: v3(254.78,53.65) v2(254.78,53.15) 254.78,52.79 RE292.2 256.45,52.27 257,52.81 UE5.2 ; v2(275.48,47.91) 275.67,48.09 276.15,48.09 276.42,48.35 RPE10.4
  TOP w0.107: v2(265.22,42.79) UE1.E8
  IN2 w0.102: v2(275.48,47.91) 275.48,47.91 276.46,48.89 276.46,50.44 275.74,51.16 275.23,51.16 274.18,52.2 273.79,52.2 272.93,53.06 272.93,54.24 272.06,55.11 270.94,55.11 268.99,57.06 265.14,57.06 263.07,59.13 261.01,59.13 260.09,58.21 257.12,58.21 256.42,57.51 v2(256.42,56.57)
  BOTTOM w0.102: v2(256.42,56.57) 254.78,54.92 v2(254.78,53.15) 255.3,53.67 260.64,53.67 261.11,53.2 261.11,52.74 260.95,52.57 260.95,51.19 261.32,50.82 261.32,45.44 262.21,44.55 262.21,43.61 263.31,42.5 264.97,42.5 265.22,42.75 v2(265.22,42.79)
RUNPWROK: length 312.4
  TOP w0.112: UC8.4 63.62,103 64.04,103.42 64.04,104.67 64.7,105.33 v2(64.7,105.6) ; QE2.3 284.51,28.74 RE67.1 284.49,28.16 284.18,28.16 277.57,21.55 276.17,21.55 276.06,21.67 276.06,22.79 276.21,22.94 276.21,26.22 276.45,26.47 276.45,27 276.41,27.04 276.41,27.09 275.36,28.14 275.36,28.98 275.44,29.05 275.44,30.75 275.27,30.92 273.31,30.92 v2(273.26,30.97) ; 65.53,101.16 UC8.1 ; 65.53,101.16 66.07,101.16 66.78,100.45 66.78,98.67 66.45,98.34 65,98.34 v2(64.5,98.85) 64.62,98.96 UC8.13 ; 65.53,101.16 66.88,102.5 66.88,103.3 67.01,103.42 v2(67.01,105.56) ; UC8.10 v2(63.12,98.83) ; v2(266.82,37.99) UE1.G3
  IN1 w0.119: v2(64.5,98.85) 64.45,98.89 63.18,98.89 v2(63.12,98.83)
  IN2 w0.124: v2(267.03,29.7) 267.01,29.72 267.01,29.94 266.3,30.64 264.88,30.64 264.77,30.53 263.58,30.53 262.61,31.5 261.64,31.5 260.94,32.2 260.94,33.38 259.27,35.05 259.27,35.05 258.53,35.79 256.78,35.79 256.07,36.51 255.06,36.51 254.86,36.71 254.36,36.71 254.02,36.37 249.61,36.37 248.76,37.22 248.76,38.88 247.14,40.5 243.73,40.5 243.27,40.96 242.26,40.96 241.98,40.69 240.21,40.69 239.63,41.27 237.19,41.27 236.53,41.93 222.72,41.93 220.96,43.69 207.46,43.69 197.54,53.61 196.67,53.61 191.2,59.08 190.83,59.08 189.05,60.85 189.05,61.58 185.83,64.8 185.36,64.8 182.03,68.13 182.03,68.6 178.83,71.81 178.83,72.84 172.02,79.65 171.9,79.65 170.74,80.81 170.74,86.94 170.89,87.09 170.89,90.95 171.39,91.44 171.39,93.24 170.69,93.95 167.76,93.95 166.81,94.9 166.01,94.9 165.24,95.66 164.33,95.66 163.53,96.46 162.33,96.46 161.11,97.69 159.92,97.69 157.56,100.04 157.56,101.23 150.45,108.35 142.34,108.35 140.75,109.94 129.97,109.94 127.7,107.67 127.08,107.67 126.41,108.34 122.04,108.34 119.75,106.05 119.07,106.05 118.34,105.32 109.16,105.32 108.93,105.32 108.15,106.1 105.06,106.1 104.83,106.33 100.65,106.33 100.59,106.39 93.22,106.39 92.45,107.17 77.36,107.17 74.94,104.75 72.19,104.75 71.7,105.24 69.92,105.24 69.79,105.1 67.46,105.1 v2(67.01,105.56)
  BOTTOM w0.112: v2(266.82,37.99) 266.82,34.45 266.28,33.9 266.28,31.43 266.92,30.79 266.92,29.91 267.03,29.79 v2(267.03,29.7) 267.56,29.7 268.34,30.49 272.94,30.49 273.26,30.81 v2(273.26,30.97) ; v2(67.01,105.56) 66.61,105.16 65.02,105.16 64.7,105.48 v2(64.7,105.6)
SA_SNUB: length 0.8
  TOP w0.102: 78.2,87.67 78.22,87.67 v3(78.75,87.14)
SA_SW: length 7
  IN2 w0.762: 71.62,87.94 71.64,87.96 73.18,87.96 73.78,88.55 78.4,88.55
  vias: v1(80.84,86.9) v2(70.97,87.96) v2(70.97,87.37) v2(79.16,88.08) v2(79.16,87.5) v2(79.5,88.68) v2(79.5,87.02)
SATA_LED_EN: length 103.3
  TOP w0.102: v2(270.79,57.19) 270.79,57.31 271.19,57.71 UE2.14 ; v2(310.39,3.52) 311.15,3.52 QZ2.5 ; v2(284.06,35.21) 284.11,35.16 284.37,35.16 v1(284.72,34.81) 285.22,34.31 285.22,26.79 286.01,26 286.84,26 287.87,24.97 287.87,21.58 290.39,19.07 293.41,19.07 294.1,18.38 294.39,18.38 294.65,18.12 294.79,18.12 294.83,18.08 299.59,13.32 v2(303.07,13.32)
  IN2 w0.102: v2(284.06,35.21) 284.47,35.62 284.47,37.37 291.39,44.29 291.39,48.72 290.93,49.17 290.93,52.23 288.22,54.95 287.77,54.95 286.93,55.79 286.19,55.79 284.59,57.39 284.59,60.49 280.12,64.96 278.44,64.96 272.79,59.31 272.79,58.01 271.57,56.79 271.19,56.79 v2(270.79,57.19)
  IN3 w0.102: v2(303.07,13.32) 303.07,12.49 307.22,8.35 307.22,7.71 310.39,4.54 v2(310.39,3.52)
SATALED#: length 443.7
  TOP w0.102: v2(168.67,73.57) 168.67,74.16 167.75,75.07 166.63,75.07 166.21,75.5 164.5,75.5 164.24,75.76 164.24,76.16 164.44,76.37 164.44,77.97 161.99,80.42 161.99,84.04 162.18,84.23 162.18,86.33 v2(162.37,86.52) ; v2(101.12,104.78) 102.36,106.02 105.26,106.02 106.38,107.14 117.87,107.14 119.24,108.51 127.61,108.51 128.42,107.71 134.8,107.71 135.37,108.28 140.44,108.28 v2(141.09,108.93) ; v2(287.02,25.02) 287.66,24.38 287.66,21.5 290.34,18.82 293.37,18.82 294.03,18.16 294.32,18.16 294.61,17.88 294.74,17.88 299.51,13.11 302.39,13.11 302.77,12.73 v1(303.13,12.73) v2(303.66,12.73) ; v2(42,22.47) 42,20.65 41.55,20.19 RN100.2 ; QZ2.4 311.07,2.95 v2(310.39,2.95)
  IN1 w0.102: v2(141.09,108.93) 141.09,108.02 143.66,105.45 143.66,103.37 146.21,100.82 146.21,96.87 148.19,94.88 148.19,92.58 147.92,92.3 v2(147.92,87)
  IN2 w0.102: v2(287.02,25.02) 286.46,25.58 280.96,25.58 279.32,23.93 272.5,23.93 271.75,23.18 269.53,23.18 268.57,24.14 262.69,24.14 262.07,24.76 261.18,24.76 260.55,25.39 256.18,25.39 253.71,27.86 253.71,28.68 252.77,29.62 252.33,29.62 248.75,33.2 247.98,33.2 245.96,35.23 242.83,35.23 242.34,35.71 238.61,35.71 238.19,35.29 237.55,35.29 237.25,35.58 221.65,35.58 219.82,37.41 212.42,37.41 210.9,38.93 205.54,38.93 203.13,41.34 203.13,41.95 191.07,54.01 190.02,54.01 181.71,62.31 180.44,62.31 179.5,63.26 179.5,64.2 178.45,65.25 176.9,65.25 172.99,69.16 172.99,69.65 171.55,71.09 170.47,71.09 168.67,72.89 v2(168.67,73.57) ; v2(101.12,104.78) 100.81,104.46 97.82,104.46 97.04,105.24 76.59,105.24 74.83,103.47 72.03,103.47 71.3,104.21 59.67,104.21 58.54,103.08 54.41,103.08 52.47,105.02 46.01,105.02 43.14,102.16 41.65,102.16 40.7,103.1 39.68,103.1 38.43,101.85 38.43,96.9 40.11,95.22 40.11,92.65 41.07,91.7 41.07,88.3 42.9,86.46 42.9,83.85 43.02,83.73 43.02,75.99 43.76,75.25 43.76,71.63 44.68,70.71 44.68,66.23 43.26,64.81 43.26,61.12 40.48,58.34 40.48,40.29 39.5,39.31 39.5,38.25 38.39,37.14 38.39,35.11 39.73,33.78 39.73,28.45 40.61,27.56 40.61,23.86 v2(42,22.47)
  IN3 w0.102: v2(303.66,12.73) 303.66,12.35 307.66,8.35 307.66,7.65 310.83,4.48 310.83,3.4 v2(310.39,2.95)
  BOTTOM w0.076: UC1.H1 146.15,84.44 147.54,85.84 147.54,86.62 v2(147.92,87) 147.96,86.96 149.47,86.96
  BOTTOM w0.102: RPC4.1 162.61,86.28 v2(162.37,86.52) 162.18,86.33 159.94,86.33 158.16,84.55 153.6,84.55 151.18,86.96 149.47,86.96
SBIOS_TX: length 228.1
  IN1 w0.102: v2(279.38,45.08) 279.57,45.27 283.23,45.27 283.86,44.64 285.94,44.64 286.57,45.27 287.89,45.27 290.35,47.73 290.35,49.19 292.21,51.05 292.21,53.74 294.51,56.04 294.51,56.23 296.56,58.27 296.67,58.27 297.44,59.04 297.44,61.19 297.27,61.36 297.27,62.83 295.71,64.39 295.71,65.67 296.43,66.39 296.43,73.11 v2(295.66,73.88)
  IN2 w0.102: v2(279.38,45.08) 279.22,44.93 279.22,44.05 279.71,43.57 279.71,31.69 277.88,29.87 273.59,29.87 273.54,29.82 268.72,29.82 267.73,28.84 266.39,28.84 266.29,28.74 264.49,28.74 262.4,30.83 261.19,30.83 259.85,32.18 259.85,33.53 258.24,35.13 256.56,35.13 256.43,35 253.13,35 252.38,35.75 249.29,35.75 246.47,38.56 242.43,38.56 242.2,38.8 238.3,38.8 237.92,39.17 226.98,39.17 226.95,39.15 222.74,39.15 220.08,41.8 210.75,41.8 209.89,40.95 208.98,40.95 208.13,41.8 207.95,41.8 206.68,41.8 203.54,44.94 202.89,44.94 200.84,46.99 200.84,47.35 196.67,51.52 196.09,51.52 191.39,56.22 190.32,56.22 190.15,56.39 190.15,56.52 185.92,60.75 185.84,60.75 179.21,67.38 178.36,67.38 171.2,74.55 171.2,76.71 170.39,77.52 169.32,77.52 168.48,78.37 167.41,78.37 167.06,78.72 167.06,79.39 166.62,79.83 153.34,79.83 152.58,79.07 152,79.07 151.63,78.69 v2(151.63,78.3)
  BOTTOM w0.076: 149.65,77.93 148.94,77.22 146.06,77.22 145.86,77.41 145.41,77.41 145.28,77.36 145.07,77.36 UC1.AB2
  BOTTOM w0.102: 149.65,77.93 149.91,78.19 151.5,78.19 151.61,78.3 v2(151.63,78.3) ; v2(295.66,73.88) 295.66,74.14 294.77,75.02 v3(294.77,75.91) 294.77,76.42 296.42,78.07 298.2,78.07 299.39,76.88 RE306.1
SD/MMCCD#: length 39.1
  TOP w0.112: v1(308.57,35.66) v1(309.8,34.43) 310.05,34.18 v2(311.27,34.18) JSD1.9 ; v3(295.57,55.13) 295.64,55.2 296.05,55.2 296.07,55.21 v2(296.14,55.21) 296.24,55.21 296.85,54.6 296.97,54.6 297.25,54.32 UR1.30
  BOTTOM w0.112: v2(296.14,55.21) 296.24,55.21 296.9,54.55 296.9,53.56 297.14,53.32 297.14,50.7 296.64,50.19 296.37,50.19 295.72,49.54 295.72,48.11 296.02,47.8 296.02,46.69 296.9,45.82 296.9,44.17 298.06,43.01 300.22,43.01 302.75,40.48 303.15,40.48 303.53,40.1 305.69,40.1 307.09,38.7 307.09,36.72 307.62,36.19 308.84,36.19 310.85,34.18 v2(311.27,34.18)
SD/MMCCLK: length 2.7
  TOP w0.112: UR1.17 300.17,50.55 300.28,50.43 300.28,49.77 301.34,48.71 RR5.1
SD/MMCCLK_R: length 17.5
  TOP w0.112: JSD1.5 310.55,38.48 310.27,38.19 v2(310.08,38.19) ; v2(303.85,46.45) 303.85,46.79 CR21.1 302.32,48.32 RR5.2
  IN1 w0.119: v2(303.85,46.45) 304.19,46.45 306.3,44.34 307.29,44.34 310.9,40.73 310.9,39.02 v2(310.08,38.19)
SD/MMCCMD: length 1.9
  TOP w0.112: UR1.19 300.55,51.35 RR6.1
SD/MMCCMD_R: length 22.5
  TOP w0.112: v2(309.6,43.09) v1(309.6,42.39) 309.6,42.34 311.67,40.28 JSD1.3 ; v2(302.95,50.07) 302.54,50.48 RR6.2
  IN1 w0.119: v2(309.6,43.09) 309.59,43.09 309.2,43.49 309.2,44.61 307.99,45.82 307.07,45.82 306.95,45.95 306.95,46.13 308.1,47.29 308.1,47.46 307.94,47.63 307.77,47.63 306.55,46.41 306.39,46.41 306.22,46.58 306.22,46.75 307.43,47.96 307.43,48.13 307.26,48.3 307.09,48.3 305.88,47.09 305.71,47.09 302.95,49.85 v2(302.95,50.07)
SD/MMCDAT0/RCLK+: length 3.1
  TOP w0.089: RR10.1 300.54,48.13 300.54,48.65 v4(300.37,48.83) 299.77,49.42 299.35,49.42 299.25,49.53 UR1.16
SD/MMCDAT0/RCLK+_R: length 18.8
  TOP w0.089: JSD1.7 311.66,36.68 311.29,36.3 310.05,36.3 v2(309.84,36.51) ; v2(300.79,45.71) 300.79,45.71 300.61,45.89 300.61,46.49 RR10.2
  IN1 w0.089: v2(309.84,36.51) 309.49,36.15 307.86,36.15 307.16,36.85 307.16,38.69 300.56,45.29 300.56,45.49 300.79,45.71 v2(300.79,45.71)
SD/MMCDAT1/RCLK-: length 3.1
  TOP w0.089: RR9.1 300.29,47.99 300.29,48.55 299.67,49.17 299.25,49.17 298.85,49.58 UR1.15
SD/MMCDAT1/RCLK-_R: length 18.8
  TOP w0.089: v2(300.23,45.7) 300.36,45.82 300.36,46.53 RR9.2 ; v2(309.87,35.95) 309.97,36.05 311.35,36.05 311.63,35.78 JSD1.8
  IN1 w0.089: v2(309.87,35.95) 307.77,35.95 306.96,36.76 306.96,38.6 300.36,45.21 300.36,45.56 300.23,45.69 300.23,45.7 v2(300.23,45.7)
SD/MMCDAT2: length 2
  TOP w0.112: UR1.21 301.79,52.15 RR8.1
SD/MMCDAT2_R: length 19.9
  TOP w0.112: v2(310.81,42.52) 311.26,42.08 JSD1.1 ; RR8.2 303.11,52.56 303.86,52.56 304.13,52.29 v3(304.13,52.01) 304.13,51.65 v2(303.81,51.33)
  IN1 w0.119: v2(303.81,51.33) 303.93,51.2 303.93,50.85 304.05,50.73 304.27,50.73 304.41,50.87 304.41,51.24 304.53,51.35 305.41,51.35 305.77,50.99 305.77,50.83 305.49,50.54 305.49,50.38 305.66,50.21 305.82,50.21 306.1,50.49 306.27,50.49 306.44,50.32 306.44,50.15 306.16,49.87 306.16,49.7 306.33,49.53 306.5,49.53 306.78,49.81 306.95,49.81 310.81,45.95 v2(310.81,42.52)
SD/MMCDAT3: length 1.7
  TOP w0.112: RR7.1 301.13,51.35 300.74,51.75 UR1.20
SD/MMCDAT3_R: length 22.1
  TOP w0.112: v2(310.21,42.81) 310.21,42.53 311.56,41.18 JSD1.2 ; v2(303.3,50.77) 302.92,50.77 RR7.2
  IN1 w0.119: v2(303.3,50.77) 303.38,50.77 303.51,50.64 303.51,49.89 304.1,49.29 304.27,49.29 305.04,50.06 305.2,50.06 305.37,49.89 305.37,49.72 304.61,48.96 304.61,48.79 304.78,48.62 304.95,48.62 305.71,49.38 305.88,49.38 306.05,49.21 306.05,49.04 305.29,48.28 305.29,48.11 305.45,47.95 305.62,47.95 306.56,48.89 307.27,48.89 309.72,46.44 309.72,44.02 310.21,43.53 v2(310.21,42.81)
SD_GPIO: length 1.7
  TOP w0.102: RR3.2 297.88,54.77 298.06,54.59 298.06,54.01 UR1.28
SD_RCOMP: length 1.6
  TOP w0.381: RC96.1 141.69,78.43 v2(141.69,78.06)
  BOTTOM w0.254: UC1.AB7 141.69,77.88 v2(141.69,78.06)
SD_UHS2_D0N: length 55.3
  TOP w0.089: v2(323.97,37.59) 323.97,37.64 324.36,38.04 324.54,38.04 324.69,37.9 JSD1.19 ; v2(299.52,54.74) 299.25,54.74 299.11,54.61 299.11,54.48 299.25,54.34 UR1.25
  IN3 w0.089: v2(299.52,54.74) 299.41,54.85 299.41,55.44 299.63,55.65 300.18,55.65 302.25,53.59 302.25,50.98 300.9,49.64 296.31,49.64 295.81,49.14 295.81,44.38 298.31,41.88 300.38,41.88 300.9,42.4 305.78,42.4 309.5,38.68 309.5,37.82 310.45,36.87 316.81,36.87 317.02,37.07 317.02,37.37 317.11,37.46 317.37,37.46 317.46,37.37 317.46,37.07 317.66,36.87 322.16,36.87 323.12,37.82 323.73,37.82 v2(323.97,37.59)
SD_UHS2_D0P: length 55.3
  TOP w0.089: UR1.26 298.85,54.7 299.04,54.89 v2(299.04,55.11) ; JSD1.18 324.6,38.81 v2(323.97,38.17)
  IN3 w0.089: v2(323.97,38.17) 323.81,38.02 323.04,38.02 322.08,37.06 317.74,37.06 317.65,37.15 317.65,37.45 317.45,37.65 317.03,37.65 316.82,37.45 316.82,37.15 316.73,37.06 310.53,37.06 309.69,37.9 309.69,38.76 305.86,42.59 300.82,42.59 300.3,42.07 298.39,42.07 296,44.46 296,49.06 296.39,49.44 300.98,49.44 302.44,50.9 302.44,53.51 302.44,53.51 302.44,53.55 302.44,53.55 302.44,53.67 300.26,55.85 299.55,55.85 299.22,55.52 299.22,55.29 v2(299.04,55.11)
SD_UHS2_D1N: length 55.3
  TOP w0.089: v2(300.99,53.18) 300.89,53.18 300.66,52.95 UR1.23 ; v2(324.06,35.63) 324.5,36.08 JSD1.21
  IN3 w0.089: v2(324.06,35.63) 323.78,35.35 322.85,35.35 322.55,35.05 317.32,35.05 317.23,35.14 317.23,35.38 317.03,35.58 316.61,35.58 316.4,35.38 316.4,35.14 316.31,35.05 309.85,35.05 309.07,35.83 309.07,37.37 307.17,39.27 306.88,39.27 304.35,41.8 301.19,41.8 300.61,41.22 300.61,39.64 300.52,39.55 300.25,39.55 300.16,39.64 300.16,41.02 299.96,41.23 298.08,41.23 295.18,44.14 295.18,49.38 296.03,50.23 300.48,50.23 301.45,51.21 301.56,51.32 301.56,52.74 301.36,52.94 301.12,52.94 300.99,53.06 v2(300.99,53.18)
SD_UHS2_D1P: length 55.2
  TOP w0.089: v2(300.84,52.6) 300.81,52.6 300.72,52.69 300.4,52.69 300.26,52.55 UR1.22 ; JSD1.22 324.79,35.17 324.6,35.35 324.45,35.35 v2(324.07,34.97)
  IN3 w0.089: v2(300.84,52.6) 300.92,52.6 301.06,52.74 301.28,52.74 301.37,52.66 301.37,51.4 300.4,50.43 295.95,50.43 294.98,49.46 294.98,44.06 298,41.04 299.88,41.04 299.97,40.94 299.97,39.56 300.17,39.36 300.6,39.36 300.8,39.56 300.8,41.14 301.27,41.61 304.27,41.61 306.8,39.08 307.09,39.08 308.88,37.29 308.88,35.75 309.77,34.86 316.39,34.86 316.6,35.06 316.6,35.3 316.69,35.39 316.95,35.39 317.04,35.3 317.04,35.06 317.24,34.86 322.63,34.86 322.93,35.16 323.88,35.16 v2(324.07,34.97)
SDWP: length 19.4
  TOP w0.112: UR1.29 297.65,54.42 297.18,54.89 v2(297.18,55.03) ; QR1.1 v2(310.62,50.8)
  IN3 w0.135: v2(297.18,55.03) 298.88,56.72 302.24,56.72 303.63,55.33 306.09,55.33 v2(310.62,50.8)
SHD_CLK: length 54.8
  TOP w0.107: v2(269.22,42.79) UE1.J8
  IN3 w0.102: v2(246.25,34.39) 246.25,34.59 249.18,37.51 249.18,38.5 249.79,39.11 251.03,39.11 251.98,40.06 251.98,40.08 252.27,40.37 252.77,40.37 253,40.14 257.67,40.14 258.21,40.68 260.09,40.68 261.1,41.7 265.25,41.7 265.46,41.9 265.84,41.9 266.42,42.49 266.42,43.02 266.57,43.17 268.84,43.17 v2(269.22,42.79)
  BOTTOM w0.102: RE374.1 234.17,45.11 237.33,45.11 241.08,41.36 242.26,41.36 243.41,40.21 243.41,35.78 243.64,35.55 244.6,35.55 245.06,36.01 247.12,36.01 247.59,36.48 v3(248.29,36.48) 248.55,36.48 249.05,35.99 249.05,35.07 248.36,34.39 v2(246.25,34.39)
SHD_CLK_R1: length 1.8
  BOTTOM w0.102: RE374.2 233.15,45.21 UE9.6
SHD_CS#: length 74.4
  TOP w0.102: UE1.M5 271.22,39.96 271.53,39.66 272.29,39.66 272.51,39.43 277.22,39.43 277.47,39.68 279.05,39.68 279.3,39.43 279.3,36.3 RE98.1 278.56,35.57 RE364.1 278.44,34.69 277.91,34.17 277.91,33.69 278.2,33.41 278.87,33.41 279.81,32.46 279.81,30.22 279.97,30.06 v1(279.97,29.33) 279.02,28.38 276.88,28.38 v2(276.45,28.82)
  IN2 w0.102: v2(276.45,28.82) 276.45,28.8 275.88,28.23 266.64,28.23 266.49,28.08 264.22,28.08 262.21,30.08 260.13,30.08 259.31,30.91 258.65,30.91 257.69,31.87 257.69,34.37 257.54,34.52 256.82,34.52 256.68,34.39 253.9,34.39 253.8,34.28 251.17,34.28 250.7,34.75 248.44,34.75 247.35,35.85 247.35,36.69 246.23,37.81 241.27,37.81 241.06,37.6 237.45,37.6 236.78,38.26 235.75,38.26 v2(235.37,37.88)
  BOTTOM w0.102: UE9.1 235.69,37.55 235.37,37.87 v2(235.37,37.88)
SHD_IO0: length 82
  TOP w0.102: v2(257.58,87.78) CE503.1 RE530.1 257.65,86.01 QE13.5 ; v2(249.97,38.67) 249.7,38.67 249.19,39.19 RE366.1 247.25,41.33 247.25,49.92 260.07,62.74 v2(260.07,72.54)
  TOP w0.107: v2(269.25,41.25) 269.16,41.25 UE1.J7
  IN3 w0.102: v2(269.25,41.25) 268.85,40.86 268.26,40.86 268.04,40.63 268.04,40.26 266.98,39.2 263.36,39.2 262.99,39.58 260.13,39.58 259.38,38.82 253.26,38.82 252.99,39.09 251.78,39.09 251.43,38.74 250.04,38.74 v2(249.97,38.67)
  BOTTOM w0.102: v2(260.07,72.54) 260.07,73.43 256.5,76.99 256.5,86.7 v2(257.58,87.78)
SHD_IO0_R1: length 23.2
  TOP w0.102: RE366.2 248.27,39.67 v1(247.54,40.4) 246.76,41.18 246.76,43.21 244.32,45.66 241.04,45.66 240.2,44.82 236.23,44.82 233.89,42.47 RE367.1
SHD_IO0_R2: length 8.2
  TOP w0.102: v3(232.07,38.89) RE367.2 232.97,38.12 v2(232.73,37.88)
  BOTTOM w0.102: UE9.5 231.88,42.7 232.94,41.64 232.94,38.09 v2(232.73,37.88)
SHD_IO1: length 25.8
  TOP w0.102: RE368.1 249.54,38.08 v2(249.89,38.08) 249.98,38.08 v3(250.51,38.61) ; 270.82,40.48 270.51,40.79 270.49,40.79
  TOP w0.107: UE1.L6 270.49,40.79 ; 270.82,40.48 v2(270.83,40.47)
  IN3 w0.102: v2(270.83,40.47) 270.83,40.44 270.45,40.06 268.13,40.06 267.24,39.18 267.24,37.87 266.9,37.52 254.15,37.52 253.58,36.95 251.27,36.95 250.14,38.08 v2(249.89,38.08)
SHD_IO1_R1: length 23
  TOP w0.102: RE368.2 247.46,39.25 247.46,39.85 246.36,40.95 v1(246.36,42.7) 246.36,43.33 244.23,45.46 241.12,45.46 239.99,44.33 236.64,44.33 235.66,43.35 RE369.1
SHD_IO1_R2: length 3.7
  TOP w0.102: v2(234.75,37.88) RE369.2 234.75,39.21 v3(235.23,39.69)
  BOTTOM w0.102: v2(234.75,37.88) 234.42,37.55 UE9.2
SHD_IO2: length 37.6
  TOP w0.102: v3(250.43,37.2) 250.11,37.53 v2(249.98,37.53) 249.29,37.53 249.19,37.43 RE370.1 ; RE360.1 277.28,41.43 v2(276.8,41.43)
  TOP w0.107: UE1.L7 270.75,41.26 v2(270.81,41.26)
  IN3 w0.102: v2(270.81,41.26) 271.1,41.26 271.56,40.81 271.74,40.81 272.02,40.53 272.02,39.35 270.98,38.31 269.67,38.31 269.58,38.4 267.8,38.4 267.65,38.25 267.65,37.7 267.07,37.12 254.32,37.12 253.74,36.54 249.77,36.54 249.54,36.77 249.54,37.27 249.82,37.54 249.96,37.54 v2(249.98,37.53)
  BOTTOM w0.102: v2(276.8,41.43) 275.25,41.43 274.18,40.37 272.18,40.37 271.77,40.79 271.58,40.79 271.1,41.26 v2(270.81,41.26)
SHD_IO2_R1: length 15.3
  TOP w0.102: RE370.2 v1(246.19,37.42) 245.7,37.42 v2(245.6,37.32) 245.6,36.46 245.18,36.04 243.78,36.04 243.01,36.81 239.77,36.81 239.08,37.5 236.33,37.5 236.07,37.24 RE371.1
  BOTTOM w0.102: v2(245.6,37.32) 245.6,37.98 RE376.1
SHD_IO2_R2: length 2.8
  TOP w0.102: v2(234.04,37.88) 234.62,37.29 RE371.2
  BOTTOM w0.102: UE9.3 233.15,36.99 v2(234.04,37.88)
SHD_IO3: length 26
  TOP w0.102: v2(249.92,36.96) 249.52,36.96 249.25,36.69 RE372.1 ; v2(271.64,40.37) 271.64,40.37 UE1.M6
  IN3 w0.102: v2(271.64,40.37) 271.64,40.36 271.64,39.5 271.32,39.18 267.77,39.18 267.44,38.86 267.44,37.78 266.98,37.32 254.23,37.32 253.66,36.74 250.28,36.74 250.06,36.96 v2(249.92,36.96)
