# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MSDATA: length 72.4
  TOP w0.112: v2(266.84,43.56) UE1.G9
  IN3 w0.135: v2(266.84,43.56) 267.28,44 267.28,46.06 268.48,47.26 268.48,51.72 268.94,52.18 271.07,52.18 271.91,53.03 272.13,53.03 272.13,53.03 272.99,53.03 273.66,52.36 276,52.36 277.18,53.53 277.18,55.32 277.62,55.76 280.18,55.76 281.12,56.69 284.75,56.69 286.2,55.24 292.39,55.24 292.91,55.76 293.42,55.76 294.34,56.67 294.34,59.64 293.81,60.17 293.81,63.35 294.24,63.78 294.24,66.51 292.97,67.78 292.97,70.42 294.16,71.62 296.23,71.62 296.73,72.12 298.4,72.12 298.9,71.62 299.96,71.62 300.1,71.75 300.1,71.91 v2(299.94,72.07)
  BOTTOM w0.112: RE75.2 300.63,75.32 300.63,75.21 300.14,74.72 300.14,74.02 300.01,73.89 JDEG1.7 300.01,72.93 300.14,72.8 300.14,72.28 v2(299.94,72.07) 300.11,71.9 300.11,71.74 299.93,71.56 298.5,71.56 297.07,72.99 297.07,73.54 RE86.1
MSM_N: length 83.5
  TOP w0.254: v2(113.13,71.38) 113.59,70.92 113.59,70.49 113.49,70.39 113.49,69.46 110.5,66.46 110.5,64.74 109.86,64.1 107.6,64.1 106.38,62.88 106.38,59.54 102.44,55.6 82.05,55.6 79.98,53.53 59.45,53.53 57.93,55.05 56.87,55.05 56.84,55.02 56.77,55.02 56.68,54.93 56.68,54.92 56.68,54.92 v2(56.68,54.92) ; v2(45.85,52.07) 45.85,51.39 PR1318.1 PR1317.1
  IN3 w0.254: v2(45.85,52.07) 46.07,52.29 46.61,52.29 48.9,54.57 54.06,54.57 54.52,55.03 56.57,55.03 v2(56.68,54.92)
  BOTTOM w0.076: UC1.AP56 113.46,71.05 v2(113.13,71.38)
NB_PSID: length 11.5
  BOTTOM w0.102: PJPDC1.1 48.85,103.6 49.16,103.3 PD4.2 PD4.3 50.75,105.87 PL3.2 49.32,106.72 48.48,105.89 47.73,105.89 46.41,107.21 v1(46.26,107.21)
NRB_BIT: length 26.6
  TOP w0.102: RC186.1 161.28,62.08 159.59,62.08 v1(158.69,61.18) 158.49,60.99 154.17,60.99 152.3,62.22 151.58,62.95 151.25,62.95 147.85,66.34 146.69,66.34 146.59,66.24 146.28,66.24 146.05,66.46 144.81,67.7 144.57,67.7 144.12,68.15 144.12,68.66 143.55,69.23 143.04,69.23 142.72,68.92 142.15,68.92 141.89,69.17 141.89,69.81 141.74,69.96 v2(141.48,69.96)
  BOTTOM w0.076: v2(141.48,69.96) 141.92,70.4 UC1.AR7
NTC_IA: length 2.1
  TOP w0.203: PU602.15 55.61,71.36 55.81,71.16 57,71.16 PR635.2
NVME_LED#: length 8.6
  TOP w0.102: RN100.1 41.02,18.5 v3(40.64,18.13) v2(40.26,17.75)
  IN1 w0.076: JNGFF3.10 36.1,14.79
  IN1 w0.102: v2(40.26,17.75) 39.33,17.75 36.92,15.33 36.32,15.33 36.1,15.11 36.1,14.79
ONE_DIMM#: length 40.8
  IN2 w0.102: v2(158.89,74) 158.73,73.85 158.73,71.94 157.63,70.83 152.15,70.83 151.98,71 148,71 147.71,71.29 145.5,71.29 143.73,71.29 143.19,71.29 142.87,70.97 142.12,70.97 141.74,70.59 v2(141.47,70.59)
  BOTTOM w0.076: 150.16,79.87 150.09,79.8 149.39,79.8 148.89,80.31 RC268.1 148.91,80.46 RC267.1 ; v2(141.47,70.59) UC1.AP7
  BOTTOM w0.102: v2(158.89,74) 158.89,75.33 157.72,76.5 157.72,78.31 157.24,78.78 154.66,78.78 v1(154.17,79.27) 153.07,80.38 153.07,81.84 152.64,82.27 152.23,82.27 151.87,81.92 151.87,81.36 152.3,80.93 152.3,80.46 152.04,80.19 150.49,80.19 150.16,79.87
OTGEN/CMIN: length 2.9
  TOP w0.102: PR960.2 59.25,92.35 PR919.2 59.02,91.55 v2(58.54,92.03)
  BOTTOM w0.203: v2(58.54,92.03) 58.57,92.03 58.78,91.82 PU901.20
PANEL_BKEN_EC: length 259
  TOP w0.102: DV2.2 66.65,111.31 v2(66.38,111.58) 66.38,111.63 66.51,111.77 66.85,111.77 67.01,111.61 v3(67.01,111.49)
  TOP w0.107: UE1.J9 269.23,43.59 v2(269.26,43.59)
  IN2 w0.102: v2(66.38,111.58) 66.64,111.85 76.7,111.85 78.52,110.03 92.38,110.03 92.62,110.27 102.17,110.27 102.86,109.58 105.77,109.58 106.03,109.84 120.13,109.84 123.29,113 150.95,113 158.65,105.3 160.32,105.3 161.25,104.37 164.46,104.37 165.95,102.89 165.95,102.72 170.63,98.04 170.97,98.04 174,95.01 174,92.72 174.48,92.24 175.06,92.24 176.66,90.63 176.66,89.93 176.53,89.8 176.53,88.38 175.18,87.03 175.18,84.54 175.77,83.95 175.77,82.71 176.3,82.18 176.3,81.39 177.16,80.52 177.16,79.71 178.01,78.86 179.46,78.86 183.28,75.04 183.28,73.99 188.86,68.41 188.86,67.46 191.48,64.84 192.34,64.84 209.3,47.89 231.88,47.89 232.8,46.97 237.48,46.97 237.99,47.48 245.62,47.48 251.99,53.85 258.92,53.85 259.13,53.64 263.77,53.64 264.29,53.12 267,53.12 267.98,52.14 267.98,49.45 268.82,48.62 268.82,44.03 v2(269.26,43.59)
PANEL_BKLEN: length 97.9
  TOP w0.102: DV2.3 68.7,107.69 68.7,103.54 67.49,102.33 67.49,99.04 67.69,98.84 v2(67.69,98.28)
  IN1 w0.076: 126.56,84.57 126.62,84.51 128.18,84.51 128.88,83.81 130.66,83.81 132.11,82.36 132.11,80.89 132.48,80.52 133.94,80.52 134.46,80 134.75,80 135.01,79.74 135.63,79.74 136.34,79.03 137.89,79.03 138.6,79.74 v2(138.6,80.18)
  IN1 w0.102: 126.56,84.57 126.34,84.79 126.34,85.07 125.36,86.05 124.85,86.05 121.81,89.09 121.81,94.91 118.86,97.86 114.81,97.86 114.64,98.03 112.47,98.03 112,98.49 106.91,98.49 106.35,97.93 91.42,97.93 91.29,97.8 91.29,97.8 91.14,97.65 73.89,97.65 73.63,97.91 71.93,97.91 71.45,97.43 68.55,97.43 v2(67.69,98.28)
  BOTTOM w0.076: v2(138.6,80.18) 138.88,80.46 UC1.R12
  BOTTOM w0.102: v2(67.69,98.28) v3(67.69,97.11)
PANEL_ID: length 33.4
  TOP w0.102: v2(258.65,56.6) 258.6,56.65 258.6,57.22 RE300.1 258.03,57.71 CE47.1 256.78,57.71 v3(256.05,56.98) ; UE1.J10 v2(269.21,44.37)
  IN2 w0.102: v2(273.37,51.52) 273.37,51.98 272.52,52.84 272.52,53.94 271.73,54.73 270.41,54.73 268.57,56.56 264.82,56.56 262.81,58.57 261.02,58.57 259.05,56.6 v2(258.65,56.6)
  IN3 w0.102: v2(273.37,51.52) 273.57,51.32 273.57,50.03 273.39,49.85 272.9,49.85 270.7,47.65 270.7,45.8 270.45,45.55 270.45,44.87 270.34,44.76 269.6,44.76 v2(269.21,44.37)
PBAT_CHARGER_SMBCLK: length 369.1
  TOP w0.102: v2(212.14,26.52) PD2.3 212.4,27.39 212.64,27.63 212.64,28.28 212.46,28.46 PRP1.3 ; v2(49.43,91.68) 49.98,91.68 51.01,90.65 54.42,90.65 55.68,91.91 55.68,93.15 PR922.1
  TOP w0.107: UE1.N2 272.71,37.59 273.76,36.54 274.55,36.54 v2(275.23,35.85) RE43.1
  IN1 w0.102: v2(49.43,91.68) 49.43,91.05 49.65,90.84 49.65,90.08 49.12,89.55 49.12,85.28 48.84,85 48.84,80.03 48.95,79.93 48.95,77.32 49.25,77.01 49.25,74.59 49.89,73.95 49.89,73.19 50.08,73 50.08,69.76 51.08,68.77 51.08,67.7 52.96,65.82 52.96,63.69 52.45,63.18 52.45,62.85 52.44,62.83 52.44,52.07 50.72,50.36 50.72,46.79 43.27,39.33 v2(43.27,37.65) ; v2(273.96,22.51) 273.32,21.87 272.63,21.87 272.16,22.34 260.9,22.34 260.56,22.68 259.44,22.68 259.27,22.86 254.3,22.86 253.66,23.5 253.3,23.5 253.23,23.44 252.92,23.44 252.85,23.5 252.68,23.5 252.62,23.44 252.3,23.44 252.24,23.5 252.16,23.5 251.68,23.98 248.5,23.98 247.92,23.4 244.09,23.4 243.99,23.3 238.03,23.3 237.67,23.65 237.43,23.65 236.05,25.03 235.22,25.03 233.59,26.66 232.66,27.59 231.51,28.74 222.78,28.74 222.42,28.39 214.56,28.39 212.69,26.52 v2(212.14,26.52)
  BOTTOM w0.102: v2(273.96,22.51) 274.76,23.31 274.76,24.39 277.63,27.25 279.89,27.25 280.24,27.6 280.24,28.17 279.67,28.74 279.67,37.64 278.69,38.62 276.59,38.62 275.89,37.92 275.89,36.38 275.36,35.85 v2(275.23,35.85) ; v2(43.27,37.65) 43.66,37.26 47.64,37.26 48.67,38.29 48.67,41.69 50.12,43.15 64.58,43.15 65.76,44.33 118.33,44.33 120.64,42.03 120.64,29.04 124.66,25.02 133.47,25.02 134.23,24.26 141.06,24.26 141.82,25.02 160.22,25.02 161.63,26.43 164.04,26.43 164.44,26.03 165.14,26.03 166.09,25.08 184.21,25.08 184.79,25.67 190.25,25.67 191.76,24.16 195.96,24.16 196.51,24.71 200.49,24.71 202.8,22.4 202.8,21.28 203.05,21.04 211.06,21.04 211.46,21.43 211.46,25.84 v2(212.14,26.52)
PBAT_CHARGER_SMBDAT: length 369.5
  TOP w0.102: PR920.1 55.88,92.47 55.88,91.82 54.5,90.44 50.61,90.44 49.86,91.19 v2(49.86,91.26) ; v2(211.11,26.49) PD1.2 211.38,27.39 211.68,27.69 211.68,28.22 211.96,28.5 PRP1.2
  TOP w0.107: UE1.M3 271.66,37.95 272.64,37.95 273.67,36.92 273.85,36.74 v2(275.23,36.74) RE37.1
  IN1 w0.102: v2(274.52,22.52) 273.48,21.47 260.37,21.47 259.18,22.66 254.22,22.66 253.67,23.21 252.17,23.21 251.59,23.78 248.58,23.78 247.99,23.18 244.16,23.18 244.01,23.03 236.71,23.03 233.51,26.24 233.51,26.46 232.46,27.5 231.43,28.53 222.86,28.53 222.51,28.18 214.64,28.18 212.59,26.13 211.47,26.13 v2(211.11,26.49) ; v2(43.66,38.04) 43.66,39.17 51.03,46.54 51.03,50.11 52.65,51.73 52.65,63.09 53.85,64.29 53.85,65.31 52.05,67.11 52.05,68.08 50.28,69.85 50.28,73.08 50.18,73.19 50.14,73.24 50.14,73.98 49.46,74.67 49.46,77.09 49.15,77.4 49.15,80.01 49.05,80.12 49.05,84.92 49.33,85.2 49.33,88.33 50.22,89.22 50.22,90.9 v2(49.86,91.26)
  BOTTOM w0.102: v2(274.52,22.52) 275.17,23.16 275.17,24.5 277.5,26.84 v3(278.93,26.84) 279.8,26.84 280.44,27.49 280.44,28.25 279.87,28.82 279.87,38.07 279.07,38.88 276.38,38.88 275.23,37.72 v2(275.23,36.74) ; v2(43.66,38.04) 44.25,37.46 47.55,37.46 48.47,38.37 48.47,41.78 50.04,43.35 64.49,43.35 65.7,44.56 118.56,44.56 120.96,42.16 120.96,29.17 124.79,25.34 133.44,25.34 134.2,24.58 140.74,24.58 141.5,25.34 160.08,25.34 161.5,26.75 164,26.75 164.52,26.24 165.28,26.24 166.11,25.4 184.07,25.4 184.54,25.87 190.5,25.87 191.87,24.5 195.54,24.5 195.96,24.92 200.6,24.92 203.01,22.51 203.01,21.37 203.13,21.24 210.98,21.24 211.11,21.37 v2(211.11,26.49)
PBAT_PRES#: length 356.2
  TOP w0.102: v2(210.11,26.52) PD1.3 210.15,27.43 PR1.2 211.2,28.54 PRP1.1
  TOP w0.107: v2(266.02,43.57) 266.04,43.57 UE1.F9
  IN1 w0.102: v2(210.11,26.52) 210.77,25.85 212.6,25.85 214.73,27.98 222.59,27.98 222.94,28.33 231.34,28.33 233.3,26.37 233.3,26.16 236.63,22.83 236.84,22.83 244.47,22.83 v2(244.62,22.67)
  IN2 w0.102: v2(266.02,43.57) 266.02,43.92 266.45,44.35 266.45,45.54 262.37,49.62 261.82,49.62 259.48,51.97 258.92,51.97 257.88,53 256.58,53 255.37,51.78 251.97,51.78 246.62,46.43 244.42,46.43 243.76,45.77 233.13,45.77 231.79,47.11 209.02,47.11 196.85,59.28 196.18,59.28 188.25,67.21 188.25,68.16 181.15,75.25 181.05,75.25 178.13,78.17 177.78,78.17 174.74,81.22 174.74,83.87 174.57,84.04 174.57,87.78 174.9,88.11 174.9,90.66 173.39,92.17 173.39,93.85 169.72,97.51 167.1,97.51 165.08,99.53 160.68,99.53 160.15,100.06 160.15,101.99 160,102.14 160,103.57 159.26,104.31 158.54,104.31 150.63,112.22 123.42,112.22 119.94,108.74 102.11,108.74 101.35,109.51 93.16,109.51 93.03,109.38 77.97,109.38 77.17,110.18 62.72,110.18 58.49,105.95 v2(58.49,105.62)
  IN3 w0.102: v2(58.49,105.62) 58.49,104.38 57,102.89 57,101.75 55.16,99.91 55.16,95.96 v2(55.47,95.65) ; v2(266.02,43.57) 266,43.57 265.62,43.2 265.62,42.64 265.49,42.51 265.49,42.51 265.38,42.41 265.06,42.41 264.96,42.51 264.59,42.51 264.58,42.5 264.26,42.5 264.25,42.51 263.79,42.51 263.78,42.5 263.46,42.5 263.45,42.51 259.87,42.51 259.73,42.65 259.31,42.65 257,40.34 253.1,40.34 252.93,40.52 252.91,40.52 252.86,40.57 252.19,40.57 252.13,40.52 251.94,40.52 250.76,39.34 249.63,39.34 248.87,38.58 248.87,37.87 246.53,35.53 245.02,35.53 244.09,34.6 240.57,34.6 v2(240.05,34.08)
  BOTTOM w0.102: v2(55.47,95.65) 55.68,95.65 PR931.1 ; v2(240.05,34.08) 240.05,33.2 v3(240.53,32.72) 241.59,31.66 241.59,27.7 243.97,25.32 243.97,23.33 v2(244.62,22.67)
PBAT_PRES#_C: length 3.5
  TOP w0.102: v3(210.29,30.63) v2(211.25,30.63) 211.33,30.63 211.46,30.51 PRP1.8
  BOTTOM w0.102: v2(211.25,30.63) 211.23,30.63 210.75,31.11 PBATT1.6
PBAT_SMBCLK_C: length 4.2
  TOP w0.112: v1(213.43,31.4) 213.25,31.4 v2(212.57,30.72) 212.52,30.67 212.51,30.67 212.3,30.47 212.3,30.35 212.46,30.2 PRP1.6
  BOTTOM w0.112: PBATT1.4 213.75,31.6 212.88,30.72 v2(212.57,30.72)
PBAT_SMBDAT_C: length 3.4
  TOP w0.112: PRP1.7 211.96,30.33 212.06,30.43 212.06,30.65 v2(211.99,30.72) 211.65,31.06 v1(211.65,31.59)
  BOTTOM w0.112: PBATT1.5 212.25,30.95 212.06,30.76 212.02,30.76 v2(211.99,30.72)
PBATT+_C: length 3.4
  BOTTOM w0.102: v1(208.75,35.01) 209.02,35.27 PC1.1
  BOTTOM w0.508: PL1.1 211.63,35.27 PC1.1
  vias: v1(216.26,35.53) v1(217.62,34.25)
PCH_ALW_ON: length 147.4
  TOP w0.102: v2(293.58,39.16) 290.72,42.02 290.35,42.02 289.86,42.51 v1(289.86,43.91) v2(289.86,45.16) ; RZ65.1 204.61,33.95 205.94,32.61 217.05,32.61 217.37,32.93 229.97,32.93 232.51,30.4 234.67,30.4 236.01,29.06 238.06,29.06 238.95,28.16 238.95,25.6 239.32,25.23 240.59,25.23 241.3,24.52 241.3,22.16 242.55,20.92 277.6,20.92 v2(279.09,22.41) ; UE1.M8 271.7,42.86 272.16,42.86 272.38,43.09 v2(273.48,43.09) ; RPE10.3 275.93,48.85 275.82,48.74 275.82,48.66 275.47,48.3 275.22,48.3 275.02,48.1 275.02,47.89 v2(274.64,47.51)
  IN1 w0.102: v2(279.09,22.41) 279.09,22.48 282,25.39 286.11,25.39 287.83,27.12 288.84,27.12 289.32,27.59 289.32,28.62 290.16,29.46 290.58,29.46 290.88,29.76 290.88,30.28 291.07,30.48 291.07,31.12 292.55,32.6 292.55,33.55 291.78,34.32 291.78,35.73 293.69,37.63 293.69,39.05 v2(293.58,39.16) ; v2(289.86,45.16) 289.48,45.16 288.58,44.27 283.88,44.27 283.08,45.07 279.96,45.07 279.02,44.12 277.92,44.12 277.54,44.51 276.83,44.51 275.07,42.74 273.83,42.74 v2(273.48,43.09)
  BOTTOM w0.102: v2(273.48,43.09) 273.48,45.2 273.83,45.55 273.83,46.69 v2(274.64,47.51)
PCH_BATLOW#: length 45.6
  TOP w0.102: v2(142.77,65.37) 142.77,65.52 143.13,65.88 145.19,65.88 145.85,65.22 147.6,65.22 150.69,62.13 151.24,62.13 153.71,59.66 155.39,59.66 156.09,58.96 156.09,58.07 159.54,54.62 163.26,54.62 163.75,54.12 165.91,54.12 166.05,53.98 169.63,53.98 171.34,55.68 v3(173.51,55.68) 173.78,55.68 RC72.1
  IN1 w0.076: v2(137.96,68.73) 137.96,68.56 139.45,67.07 140.59,67.07 142.28,65.37 142.77,65.37 v2(142.77,65.37)
  BOTTOM w0.076: v2(137.96,68.73) 137.96,68.78 UC1.AU13
PCH_CL_CLK1: length 199.7
  IN1 w0.119: v2(269.71,63.35) 268.03,65.03 261.32,65.03 259.53,63.24 253.06,63.24 252.01,62.19 250.97,62.19 245.11,56.33 245.11,56.07 242.63,53.59 240.8,53.59 239.12,51.9 210.09,51.9 208.76,53.24 208.35,53.24 194.31,67.27 193.46,67.27 191.44,69.29 188.98,69.29 187.66,67.97 182.12,67.97 180.55,69.53 180.55,74.41 181.84,75.7 181.84,87.13 178.13,90.84 175.52,90.84 175.29,90.61 175.29,90.11 173.6,88.41 169.54,88.41 168.98,88.98 168.98,90.46 169.2,90.68 169.2,91.64 168.67,92.17 168.06,92.17 166.35,93.88 166.35,93.94 165.98,94.3 v2(165.92,94.3)
  BOTTOM w0.076: UC1.G3 144.5,85.39 144.63,85.39 144.83,85.59 144.83,85.85 145.2,86.21 145.2,87.8 145.36,87.96 145.36,88.26 145.07,88.54 145.07,88.85 144.78,89.15 144.78,90.28 145.47,90.97
  BOTTOM w0.112: JNGFF1.42 280.15,45.55 279.58,46.12 278.49,46.12 278.03,46.58 278.03,50.01 276.32,51.72 276.32,53.34 275.77,53.89 275.77,57.31 272.71,60.38 271.08,60.38 270.97,60.49 270.97,63.24 270.86,63.35 v2(269.71,63.35) ; 145.47,90.97 146.19,91.69 150.99,91.69 153.89,94.6 v3(158.21,94.6) 159.03,94.6 159.56,94.07 160.8,94.07 161.29,94.56 164.97,94.56 165.23,94.3 v2(165.92,94.3)
PCH_CL_DATA1: length 199.2
  IN1 w0.119: v2(164.26,94.09) 164.38,94.09 164.4,94.08 164.74,94.08 167.16,91.66 167.16,88.21 168.22,87.15 174.01,87.15 175.21,88.35 178.89,88.35 180.83,86.41 180.83,77.51 179.55,76.23 179.55,69.11 182.4,66.26 190.59,66.26 190.71,66.13 194.03,66.13 207.93,52.24 208.34,52.24 209.83,50.75 239.38,50.75 241.22,52.59 243.82,52.59 253.48,62.24 264.57,62.24 265.38,61.43 266.74,61.43 v2(268.64,63.33)
  BOTTOM w0.076: 145.82,90.62 145.61,90.62 145.04,90.05 145.04,89.19 145.27,88.95 145.27,88.62 146.42,87.47 146.42,85.98 145.81,85.37 145.36,85.37 145.09,85.1 UC1.G2
  BOTTOM w0.112: 145.82,90.62 146.38,91.19 151.18,91.19 154.1,94.11 158.82,94.11 159.35,93.57 v3(160.34,93.57) 161,93.57 161.5,94.07 164.24,94.07 v2(164.26,94.09) ; JNGFF1.40 279.95,45.05 279.37,45.63 278.29,45.63 277.54,46.37 277.54,49.81 275.83,51.52 275.83,52.12 275.41,52.54 275.41,52.89 274.74,53.57 274.74,53.83 274.85,53.94 275.17,53.94 275.28,54.05 275.28,54.28 275.17,54.39 274.85,54.39 274.74,54.5 274.74,54.73 274.85,54.84 275.17,54.84 275.28,54.95 275.28,55.17 275.17,55.28 274.85,55.28 274.74,55.4 274.74,55.62 274.85,55.73 275.17,55.73 275.28,55.84 275.28,56.07 275.17,56.18 274.85,56.18 274.74,56.29 274.74,57.1 272.27,59.57 270.82,59.57 270.34,60.06 270.34,61.99 268.99,63.33 v2(268.64,63.33)
PCH_CL_RST1#: length 198.6
  IN1 w0.119: v2(164.58,93.58) 164.58,93.53 166.29,91.82 166.29,91.06 166.57,90.77 166.57,88.08 168.01,86.65 174.21,86.65 175.42,87.85 178.41,87.85 180.33,85.93 180.33,77.72 179.05,76.43 179.05,68.9 182.19,65.76 190.38,65.76 191.34,64.79 194.67,64.79 207.72,51.74 208.14,51.74 209.62,50.25 239.59,50.25 241.42,52.09 244.09,52.09 253.71,61.7 264.4,61.7 265.22,60.88 267.01,60.88 v2(268.87,62.74)
  BOTTOM w0.076: 146.17,90.27 145.67,90.27 145.33,89.93 145.33,89.26 145.46,89.12 145.46,88.71 146.67,87.5 146.67,85.97 145.8,85.1 UC1.G1
  BOTTOM w0.112: v2(268.87,62.74) 269.79,61.82 269.79,58.62 270.79,57.62 271.6,57.62 272.52,56.7 273.05,56.7 274.25,55.51 274.25,53.36 274.55,53.06 274.55,52.59 275.01,52.12 275.01,51.19 275.68,50.51 276.13,50.51 277.05,49.6 277.05,46.17 278.08,45.13 278.66,45.13 279.24,44.55 JNGFF1.38 ; 146.17,90.27 146.57,90.68 151.37,90.68 154.3,93.61 154.52,93.61 154.63,93.5 154.63,93.23 154.74,93.12 154.96,93.12 155.07,93.23 155.07,93.5 155.19,93.61 155.41,93.61 155.52,93.5 155.52,93.23 155.63,93.12 155.86,93.12 155.97,93.23 155.97,93.5 156.08,93.61 156.3,93.61 156.41,93.5 156.41,93.23 156.53,93.12 156.75,93.12 156.86,93.23 156.86,93.5 156.97,93.61 157.2,93.61 157.31,93.5 157.31,93.23 157.42,93.12 157.64,93.12 157.76,93.23 157.76,93.5 157.87,93.61 158.62,93.61 159.15,93.08 161.21,93.08 161.7,93.58 v3(163.17,93.58) v2(164.58,93.58)
PCH_DPWROK: length 144.8
  TOP w0.112: v2(138.57,60.65) 138.64,60.65 138.9,60.39 138.9,57.53 138.97,57.47 138.97,56.94 RC215.1 139.8,56.1 CC266.1 140.49,56.04 RC220.1 ; v2(236.09,37.88) 236.09,38.24 236.28,38.43 236.28,40.74 RE536.2 237.75,42.21 238.5,42.21 239.16,41.55 v1(239.4,41.55) 239.66,41.81 UE7.1
  IN1 w0.119: v2(237.93,32.11) 235.51,32.11 235.13,32.49 234.08,32.49 233.52,32.49 233.07,32.94 231.07,32.94 230.66,32.94 230.09,32.94 229.09,33.94 219.08,33.94 217.78,32.65 205.35,32.65 205.12,32.42 204.84,32.42 204.52,32.1 202.56,32.1 199.58,35.07 199.58,35.51 198.78,36.31 196,39.09 195.39,39.09 189.54,44.95 188.76,44.95 187.59,46.12 156.01,46.12 148.78,53.35 146.66,53.35 145.66,54.35 142.39,54.35 140.03,56.71 140.03,57.57 139.34,58.26 139.34,59.11 138.57,59.88 v2(138.57,60.65)
  BOTTOM w0.076: UC1.BB20 134.58,65.95 134.58,65.16 135.17,64.57 135.17,64.05 136.09,63.14 136.09,61.38 136.96,60.51 138.29,60.51 138.43,60.65 v2(138.57,60.65)
  BOTTOM w0.112: v2(236.09,37.88) 236.3,37.67 236.3,36.35 237.62,35.03 237.62,32.42 v2(237.93,32.11)
PCH_DPWROK_EC: length 44.3
  TOP w0.102: RE34.1 239.3,37.92 239.83,37.38 240.73,37.38 242.47,39.12 242.47,44.14 v1(242.5,44.17) 242.81,44.48 243.35,44.48 v2(243.84,44.96)
  TOP w0.107: v2(266.02,42.79) UE1.F8
  IN2 w0.102: v2(243.84,44.96) 244.36,45.48 249.41,45.48 254.98,51.06 255.34,51.06 256.87,52.6 257.72,52.6 258.31,52 258.31,51.4 261.37,48.34 261.37,47.14 262.13,46.38 262.13,45.15 262.46,44.82 264.67,44.82 264.9,44.6 264.9,43.35 265.08,43.17 265.51,43.17 265.9,42.79 v2(266.02,42.79)
PCH_JTAG_TCK: length 58.3
  IN3 w0.076: v2(113.2,91.15) 112.77,91.59 112.77,94.67 112.31,95.12 112.31,96.08 112.22,96.17
  IN3 w0.135: 112.22,96.17 110.9,97.49 110.56,97.49 109.01,99.05 106.88,99.05 104.65,101.27 98.72,101.27 97.84,102.16 74.22,102.16 73.07,101.01 v2(73.07,100.82)
  BOTTOM w0.076: UC1.B56 113.61,87.97 113.87,88.24 113.87,89.73 113.23,90.37 113.23,91.12 v2(113.2,91.15) 112.72,91.63 112.72,92.11 113.09,92.48 113.09,92.69 113.93,93.53 RC86.1
  BOTTOM w0.102: v3(115.67,95.1) 115.2,94.63 115.2,93.94 114.8,93.53 RC86.1
  BOTTOM w0.112: v2(73.07,100.82) 72.61,101.28 JXDP1.55
PCH_JTAG_TDI: length 70.3
  TOP w0.112: RC229.2 63.38,104.67 64.14,105.43 v2(64.14,105.57)
  IN3 w0.076: v2(111.35,92.76) 111.35,93.77 110.75,94.38 110.75,95.64 110.22,96.16 110.07,96.16 110.06,96.17
  IN3 w0.135: v2(101.5,99.25) 101.53,99.22 102.71,99.22 104.19,97.73 106.42,97.73 106.91,97.24 108.99,97.24 110.06,96.17
  BOTTOM w0.076: CC304.1 RC81.1 111.84,93.24 v2(111.35,92.76) 112.28,91.83 112.28,91.61 112.56,91.32 112.56,88.96 112.69,88.84 112.69,88.48 112.65,88.38 112.65,88.19 112.69,88.1 112.69,87.85 112.55,87.37 112.55,87.26 112.47,86.99 UC1.D59
  BOTTOM w0.112: v2(101.5,99.25) 101.5,99.37 v1(101.15,99.72) 99.41,101.46 99.41,103.37 99.11,103.66 99.11,106.06 98.9,106.28 98.72,106.28 94.32,106.28 90.54,110.06 75.14,110.06 72.75,107.67 68.57,107.67 67.16,106.26 64.64,106.26 64.14,105.76 v2(64.14,105.57)
PCH_JTAG_TDO: length 71
  TOP w0.112: RC230.2 66.32,104.79 66.32,107.12 v2(65.99,107.45)
  BOTTOM w0.076: UC1.A56 113.61,89.76 112.73,90.64 112.73,91.39 112.55,91.56 112.55,92.18 112.93,92.55 112.93,92.76 113.58,93.41 113.58,95.38 113.29,95.68 RC82.1 CC303.1 114.31,95.98 114.63,96.3 114.63,97.38
  BOTTOM w0.112: 114.63,97.38 114.63,97.68 114.3,98.01 112.56,98.01 111.45,99.12 106.82,99.12 102.92,103.02 102.28,103.02 100.71,104.58 100.71,105.24 100.26,105.7 100.26,106.58 99.15,107.69 v3(98.68,107.69) 94.09,107.69 90.72,111.06 73.97,111.06 72.63,109.72 68.85,109.72 66.58,107.45 v2(65.99,107.45)
PCH_JTAG_TMS: length 95.8
  TOP w0.112: RC228.2 59.26,99.15 58.27,100.14 58.27,101.65 58.17,101.76 58.17,103.57 57.41,104.34 57.41,105.73 56.85,106.29 56.85,106.3 56.1,107.05 56.1,108.77 56.72,109.39 59.74,109.39 62.41,112.06 62.98,112.06 63.63,111.41 63.63,110.54 63.91,110.26 64.77,110.26 65.42,109.62 65.42,108.71 v2(64.22,107.52)
  IN3 w0.076: v2(111.91,92.74) 111.91,92.69 111.42,92.19 v2(111.39,92.19)
  BOTTOM w0.076: 111.92,97.5 111.92,97.2 112.37,96.75 RC130.1 112.37,96.18 113.41,95.14 113.41,93.48 112.67,92.74 v2(111.91,92.74) ; UC1.C59 112.44,87.62 112.52,87.88 112.52,88.05 112.46,88.24 112.46,88.39 112.52,88.51 112.52,88.77 112.4,88.89 112.4,91.23 111.43,92.19 v2(111.39,92.19)
  BOTTOM w0.112: v2(64.22,107.52) 64.22,107.17 64.7,106.7 66.99,106.7 69.02,108.73 71.94,108.73 74.06,110.85 90.63,110.85 94.28,107.19 v3(96.7,107.19) 99.34,107.19 100.05,106.49 100.05,105.61 100.5,105.15 100.5,104.5 102.19,102.8 102.83,102.8 106.73,98.9 111.37,98.9 111.92,98.35 111.92,97.5
PCH_PCIE_WAKE#: length 165.5
  TOP w0.112: UE1.L1 270.42,36.68 271.39,35.72 271.39,35.7 v2(271.4,35.69) ; RE274.2 172.2,49.22 RC67.1 171.26,48.93 169.98,48.93 169.48,49.44 v3(169.08,49.44) 166.65,49.44 v2(165.75,48.54)
  IN1 w0.119: v2(271.4,35.69) 271.09,35.69 270.6,35.21 270.6,35.02 270.35,34.77 268.96,34.77 267.55,36.17 262.34,36.17 261.98,35.82 261.19,35.82 260.83,36.17 259,36.17 258.19,35.36 257.18,35.36 256.5,34.67 253.6,34.67 253.26,34.33 251.29,34.33 251.09,34.54 249.71,34.54 248.64,33.47 241.37,33.47 240.88,32.98 240.26,32.98 239.11,34.13 236.4,34.13 235.57,34.96 231.06,34.96 231.04,34.97 231.02,34.97 230.02,35.97 229.05,35.97 218.27,35.97 218.2,35.9 217.28,34.98 214.75,34.98 205.97,34.98 203.9,37.05 202.88,37.05 201.61,38.31 199.61,38.31 196.83,41.1 196.41,41.1 196.41,41.09 196.22,41.09 190.37,46.95 189.59,46.95 188.42,48.12 166.17,48.12 v2(165.75,48.54) 156.42,48.54 149.92,55.04 149.92,55.43 148.53,56.83 145.55,56.83 145.29,56.57 145.29,56.25 144.89,55.86 143,55.86 141.57,57.3 141.57,58.16 140.84,58.88 140.84,60.07 140.41,60.5 v2(140.19,60.5)
  BOTTOM w0.076: UC1.BB15 136.89,65.9 136.89,64.7 140.03,61.55 140.03,60.66 v2(140.19,60.5)
PCH_PLTRST#: length 76.2
  TOP w0.112: v2(169.17,66.45) 169.66,66.94 v1(169.81,67.08) 170.4,67.67 170.4,70.87 171.09,71.57 171.09,79.01 169.92,80.18 169.92,80.86 169.22,81.55 169.22,87.67 168.77,88.12 168.77,89.57 168.42,89.93 168.42,91.32 v2(168.45,91.35)
  IN3 w0.076: v2(140.57,71.31) 141,70.88 141,69.13 141.08,69.05 142.76,69.05 143.36,69.65 143.36,70 143.49,70.12 144.15,70.12
  IN3 w0.135: 144.15,70.12 144.42,70.12 144.87,69.68 148.56,69.68 149.13,69.11 152.17,69.11 153.81,70.75 157.32,70.75 160.84,67.24 163.45,67.24 163.9,66.79 166.12,66.79 166.92,67.59 168.66,67.59 169.17,67.08 v2(169.17,66.45)
  BOTTOM w0.076: UC1.AN10 140.17,71.7 v2(140.57,71.31)
  BOTTOM w0.112: 174.55,93.74 174.68,93.87 UC7.1 ; 174.55,93.74 174.55,93.55 174.88,93.22 UC7.2 176.39,93.22 177.17,92.45 RC60.1 177.17,91 RC244.1 177.2,90.12 RC62.1 ; 174.55,93.74 174.42,93.87 174.15,93.87 173.26,92.99 170.54,92.99 169.01,91.47 168.56,91.47 v2(168.45,91.35)
PCH_PLTRST#_5105: length 12.3
  TOP w0.112: 269.62,36.79 269.62,36.77 271.22,35.17 v2(271.22,35.11) ; v3(276.61,32.93) 276.58,32.9 RE340.1 276.13,31.99 v2(275.95,32.17) 275.89,32.17 275.49,31.77 275.49,31.4 275.91,30.99 UE6.4
  IN1 w0.119: v2(275.95,32.17) 275.95,32.49 274.62,33.82 273.77,33.82 273.01,34.58 271.76,34.58 v2(271.22,35.11)
PCH_PLTRST#_AND: length 560.9
  TOP w0.102: UT1.L4 v2(27.96,82.91)
  TOP w0.112: v2(204.6,34.92) 205.16,34.92 207.05,33.03 216.88,33.03 217.2,33.34 230.51,33.34 232.99,30.86 234.8,30.86 236.02,29.64 240.26,29.64 240.73,29.17 240.73,25.95 241.92,24.76 241.92,22.95 242.56,22.31 243.21,22.31 243.99,21.54 255.72,21.54 v2(258.11,23.92) ; v2(170.54,92.33) 170.2,92 170.2,91.61 170.65,91.16 170.65,88.63 174.8,84.48 176.76,84.48 179.18,82.06 179.18,73 178.31,72.13 178.31,70.29 177.36,69.34 177.36,66.72 179.8,64.27 180.44,64.27 183.37,61.34 183.37,59.36 185.03,57.7 v1(185.03,55.97) 185.03,54.49 184.67,54.12 184.67,41.57 184.96,41.28 186.4,41.28 186.49,41.37 188.56,41.37 188.56,41.36 v2(188.57,41.36) ; UR1.1 295.3,53.35 295.15,53.5 v2(293.87,53.5) ; RZ114.1 CZ61.1 262.49,22.61 263.56,21.53 272.17,21.53 272.99,22.35 272.99,23.6 276.04,26.64 v2(276.04,26.83)
  IN1 w0.119: v2(281.12,60.19) 281.12,64.86 280.61,65.37 279.1,65.37 278.32,66.15 v2(278.32,67.21) ; JNGFF3.50 25.5,13 23.67,13 23.24,13.43 23.24,13.65 19.4,17.49 19.4,24.95 18.86,25.49 18.86,45.06 20.11,46.32 20.94,46.32 22.85,48.22 22.85,52.46 25.22,54.83 27.32,54.83 27.47,54.68 27.88,54.68 28.12,54.92 28.12,55.41 27.29,56.24 27.29,57.66 27.55,57.92 27.55,58.58 26.39,59.73 26.39,63.65 25.18,64.86 24.18,64.86 22.46,66.58 22.46,72.24 25.99,75.76 25.99,76.18 26.24,76.43 26.43,76.43 28.56,78.56 28.56,79.92 27.96,80.52 v2(27.96,82.91) 28.52,82.34 29.39,82.34 30.29,81.44 32.64,81.44 34.36,79.72 35.4,79.72 35.88,80.2 35.88,81.43 36.64,82.2 36.64,83.22 35.52,84.34 35.52,91.58 34.37,92.73 34.37,97.62 34.1,97.88 34.1,103.48 33.8,103.78 33.8,108.57 35.16,109.93 36.13,109.93 40.07,113.87 45.28,113.87 46.05,114.64 48.24,114.64 48.74,114.14 52.66,114.14 56.07,117.55 79.27,117.55 81.55,115.28 88.65,115.28 91.05,117.68 142.97,117.68 154.63,106.01 155.74,106.01 157.35,107.63 164.38,107.63 166.66,105.34 166.66,102.08 164.06,99.49 164.06,96.99 166.51,94.54 168.4,94.54 170.54,92.4 v2(170.54,92.33) ; v2(283.22,44.08) 283.48,44.08 283.71,43.85 289.1,43.85 290.8,45.55 290.8,47.84 291.22,48.26 291.22,49.26 292.86,50.9 292.86,52.44 293.87,53.45 v2(293.87,53.5)
  IN3 w0.135: v2(276.04,26.83) 276.28,27.08 277.26,27.08 279.88,29.7 280.01,29.7 281.85,31.54 282.53,31.54 283.09,32.09 283.09,33.14 282.22,34.01 282.22,35.18 282.68,35.64 282.68,38.8 282.94,39.07 282.94,43.8 v2(283.22,44.08)
  BOTTOM w0.112: v2(276.04,26.83) 276.04,26.72 272.07,22.76 266.27,22.76 265.98,22.48 259.12,22.48 258.73,22.86 258.47,22.86 258.11,23.22 v2(258.11,23.92) ; v2(204.6,34.92) 204.19,34.92 202.95,36.16 199.72,36.16 195,40.89 190.7,40.89 190.21,41.37 188.56,41.37 188.56,41.36 v2(188.57,41.36) ; RC325.1 172.88,92.13 UC7.4 172.11,92.57 RC65.1 171.13,92.42 171.03,92.32 170.54,92.32 170.54,92.33 v2(170.54,92.33) ; v2(281.12,60.19) 281.12,58.01 278.23,55.12 278.23,54.74 278.08,54.59 278.08,53.04 278.3,52.83 278.3,52.25 278.91,51.64 279.3,51.64 279.39,51.55 280.06,51.55 ; 280.06,51.55 280.01,51.5 280.01,48.22 280.18,48.05 JNGFF1.52 282.37,48.05 283.22,47.2 v2(283.22,44.08) ; 280.06,51.55 JNGFF1.66 ; JNGFF2.42 274.2,72.57 274.36,72.42 274.36,71.03 278.17,67.21 v2(278.32,67.21)
PCH_PLTRST#_EC: length 154
  TOP w0.112: v2(175.68,90.45) 175.68,90.13 176.17,89.64 177.49,89.64 178.31,88.83 179.51,88.83 186.1,82.24 186.1,76.85 188.1,74.85 188.1,69.49 190.59,67 190.85,67 195.55,62.29 195.55,55.98 205.22,46.31 205.22,44.07 207.73,41.56 207.73,37.12 209.07,35.78 215.74,35.78 216.05,36.1 228.57,36.1 229.8,37.33 v1(230.39,37.33) 230.6,37.33 v2(231.21,36.72) ; UE6.2 278.86,30.34 279.39,30.86 279.39,32.2 278.59,33 278.03,33 277.53,33.5 276.56,33.5 276.28,33.22 275.67,33.22 275.21,33.68 274.26,33.68 273.92,34.03 v2(273.92,34.32)
  IN1 w0.119: v2(273.92,34.32) 273.36,34.87 273.36,36.53 272.82,37.07 270.52,37.07 270.17,36.72 269.23,36.72 268.38,37.57 255.07,37.57 253.76,36.26 250.85,36.26 250.5,35.92 249.12,35.92 248.77,36.26 248.34,36.26 247.68,35.61 241.15,35.61 240.74,36.02 238.82,36.02 238.35,36.49 238.34,36.49 231.44,36.49 v2(231.21,36.72)
  BOTTOM w0.112: v2(231.21,36.72) 230.74,37.19 RE375.2 ; v2(175.68,90.45) 175.68,90.75 175.9,90.96 RC244.2
PCH_POPIRCOMP: length 16.5
  TOP w0.381: RC89.1 144.17,58.65 v3(144.17,59) 144.17,61.8 v2(144.18,61.8)
  IN1 w0.381: v2(136,68.77) 136,68.22 136.15,68.07 136.15,67.02 137.03,66.14 138.32,66.14 140.61,63.85 141.52,63.85 142.16,63.21 142.8,63.21 144.18,61.84 v2(144.18,61.8)
  BOTTOM w0.254: UC1.AU16 v2(136,68.77)
PCH_PWROK: length 179.2
  TOP w0.112: PR614.1 47.33,68.85 v2(46.48,68)
  BOTTOM w0.076: 138.24,55.78 139.02,55 139.02,54.97 ; 138.24,55.78 138.24,59 135.92,61.32 135.92,63.07 134.99,64 134.99,64.52 134.42,65.09 134.42,65.69 134.28,65.83 134.28,66.37 UC1.BA20 ; 138.24,55.78 119.93,55.78
  BOTTOM w0.112: v2(46.48,68) 46.79,67.69 46.79,63.81 48.46,62.14 v3(51.07,62.14) 53.42,62.14 54.09,61.47 55.56,61.47 55.78,61.25 55.78,59.92 56.3,59.4 63.06,59.4 63.5,58.96 63.5,58.2 65.92,55.78 119.93,55.78 ; RC411.1 192.8,62.19 192.8,60.18 189.71,57.08 187.43,57.08 183.09,52.74 181.79,52.74 179.18,50.13 149,50.13 147.4,51.73 142.27,51.73 139.02,54.97
PCH_RSMRST#: length 41.4
  TOP w0.112: RE364.2 279.48,34.22 279.23,33.96 v2(278.43,33.96) ; RE363.2 269.03,33.52 v2(269.51,33.04) 269.51,32.45 269.37,32.31 RE342.1
  IN3 w0.135: v2(278.43,33.96) 278.38,33.96 278.09,34.25 275.11,34.25 273.93,33.07 271.84,33.07 271.44,33.47 269.94,33.47 v2(269.51,33.04) 268.88,33.04 268.25,33.66 263.73,33.66 263.55,33.48 257.32,33.48 256.89,33.91 253.48,33.91 252.68,33.11 249.78,33.11 248.91,33.99 244.58,33.99 243.58,32.99 v2(243.54,32.99)
  BOTTOM w0.112: UZ6.1 243.58,32.95 v2(243.54,32.99)
PCH_RSMRST#_AND: length 317.2
  TOP w0.102: RC75.1 138.69,54.68 RC215.2 138.48,56.51 138.48,57.26 138.41,57.33 v3(138.41,57.68) 138.41,60.19 138.03,60.57 138.03,60.78 v2(138.63,61.38) ; v2(79.82,98.33) 79.82,99.22 80.96,100.36 80.96,102.27 83.63,104.93 86.81,104.93 88.27,106.39 89.27,106.39 90.19,107.32 95.32,107.32 96.29,108.29 98.36,108.29 99.61,109.53 99.61,113.13 101.09,114.61 104.52,114.61 105.41,115.5 133.6,115.5 135.75,113.35 155.57,113.35 159.78,109.14 160.67,109.14 162.68,107.12 162.68,106.49 163.11,106.07 164.1,106.07 164.2,106.16 166.69,106.16 166.9,105.95 168.69,105.95 169.57,105.07 169.57,102.34 170.73,101.18 173.53,101.18 175.73,98.97 175.73,94.78 176.34,94.17 176.34,93.12 178.99,90.47 180.19,90.47 188.94,81.72 188.94,76.34 189.68,75.6 190.38,75.6 190.72,75.25 v2(190.72,75.18) ; v2(241.7,32.92) 238.3,32.92 237.05,34.17 232.54,34.17 232.33,33.96 216.94,33.96 216.62,33.64 207.52,33.64 201.55,39.61 201.55,43.02 199.9,44.67 199.9,48.42 193.39,54.92 193.39,59.63 192.05,60.97 v2(191.69,60.97)
  BOTTOM w0.076: 140.71,56.82 140.71,57.55 139.12,59.14 139.12,60.84 138.63,61.33 v2(138.63,61.38) 138.52,61.28 138.46,61.28 138.04,60.86 137.08,60.86 136.47,61.47 136.47,63.23 135.7,63.99 135.7,65.64 135.51,65.83 135.51,66.09 135.56,66.21 135.56,66.35 135.5,66.58 135.5,66.7 135.57,66.91 135.67,67.02 135.77,67.13 UC1.AY17
  BOTTOM w0.102: UZ6.4 242.28,33.9 241.7,33.32 v2(241.7,32.92) ; v2(79.82,98.33) 79.82,99.35 79.24,99.93 RC124.1 ; 140.71,56.82 140.71,55.85 143.97,52.6 147.7,52.6 148.78,51.51 162.94,51.51 163.64,50.82 178.89,50.82 183.77,55.7 183.87,55.81 183.87,58.43 184.79,59.34 190.07,59.34 v2(191.69,60.97) 191.68,60.98 191.68,62.08 190.65,63.11 190.65,66.72 191.3,67.36 191.3,68.12 190.35,69.07 190.35,74.3 190.72,74.68 v2(190.72,75.18)
PCH_RSMRST#_GPIO204: length 4
  TOP w0.107: UE1.H2 268.05,37.59 268.5,37.14 268.5,36.33 269.55,35.27 269.55,34.83 269.3,34.58 RE363.1
PCH_RTCRST#: length 342.9
  TOP w0.112: v2(136.87,71.98) 136.43,71.53 136.43,67.93 139.41,64.94 139.41,64.03 v1(140.2,63.25) 141.36,62.09 141.36,59.82 141.82,59.36 RC57.1 141.85,59.15 CC25.1 142.88,62.94 142.8,63.02 142.8,63.33 143.63,64.16 143.71,64.16 143.79,64.25 144.44,64.25 145.14,63.54 146.84,63.54 147.99,62.4 147.99,59.5 150.4,57.09 154.84,57.09 156.34,55.58 156.34,53.63 157.53,52.44 159.26,52.44 160.07,53.25 v2(160.07,53.69) ; v2(254.87,39.24) 254.97,39.35 254.97,40.36 RE94.2
  IN1 w0.119: v2(160.07,53.69) 160.43,53.33 160.43,52.29 162.09,50.63 163.62,50.63 164.03,51.04 171.74,51.04 172.13,50.65 180,50.65 181.08,49.57 188.01,49.57 189.02,49.57 189.54,49.06 190.31,49.06 196.83,42.55 197.43,42.55 199.63,40.35 200.21,39.76 202.22,39.76 203.48,38.5 204.5,38.5 206.57,36.43 215.35,36.43 216.68,36.43 217.67,37.42 229.65,37.42 229.65,37.42 230.47,37.42 230.47,37.42 230.67,37.42 230.98,37.11 231.53,37.11 231.65,36.99 238.35,36.99 238.37,36.99 238.56,36.99 239.03,36.52 241.13,36.52 241.41,36.24 247.6,36.24 248.25,36.89 249.21,36.89 249.56,36.54 250.24,36.54 250.59,36.89 253.5,36.89 254.87,38.26 v2(254.87,39.24) 255.31,39.68 256.09,39.68 256.09,39.68 257.2,39.68 258.21,40.69 259.7,40.69 260.47,41.46 260.47,43.78 261.04,44.35 262.21,44.35 262.58,43.99 266.19,43.99 266.43,44.23 266.43,45.38 266.64,45.59 270.37,45.59 271.09,46.31 271.97,46.31 272.48,46.81 274.64,46.81 275.35,47.51 284.74,47.51 284.97,47.28 287.31,47.28 287.46,47.42 287.47,47.42 287.87,47.82 287.87,51.87 293.06,57.07 293.06,57.66 295.82,60.42 295.82,62.72 293.72,64.82 289.59,64.82 289.44,64.97 287.8,64.97 287.61,65.16 287.3,65.16 285.22,67.24 282.36,67.24 280.09,69.51 280.09,73.7 281.72,75.33 281.72,76.96 281.27,77.41 281.27,87.93 281.1,88.1 281.1,90.8 282.93,92.63 282.93,99.95 285.97,103 314,103 314.42,102.57 v2(314.42,102.3)
  IN3 w0.135: v2(169.12,73.21) 170.26,73.21 173.92,69.55 173.92,68.27 178.04,64.15 v2(178.04,63.34)
  BOTTOM w0.076: v2(136.87,71.98) 136.91,71.94 UC1.AM16
  BOTTOM w0.112: v2(169.12,73.21) 168.79,72.88 166.34,72.88 CMOS1.1 ; JAPS1.9 316.35,102.44 315.98,102.08 314.65,102.08 v2(314.42,102.3) ; v2(160.07,53.69) 160.27,53.89 160.27,54.82 161.17,55.72 164.69,55.72 165.07,56.1 165.07,56.22 165.3,56.45 165.42,56.45 168.34,59.37 178,59.37 178.87,60.24 178.87,62.52 v2(178.04,63.34)
PCH_RTCX1: length 24.2
  TOP w0.112: YC2.1 153.06,74.84 RC54.2 152.05,73.83 CC23.1 152.05,73 151.68,72.63 151.36,72.63 v2(150.81,72.09)
  IN1 w0.076: v2(136,71.94) 135.64,72.3 135.64,72.74 135.83,72.93 136.76,72.93 136.76,72.94 137.97,72.94 137.99,72.92 138.11,72.92 138.21,72.82 138.21,72.56 138.51,72.26 139.29,72.26 139.33,72.3 140.5,72.3 141.07,72.88 142.73,72.88 145.23,70.38 145.5,70.38
  IN1 w0.119: v2(150.81,72.09) 150.81,71.78 150.18,71.15 149.32,71.15 148.55,70.38 145.5,70.38
  BOTTOM w0.076: UC1.AM18 v2(136,71.94)
PCH_RTCX2: length 20.8
  TOP w0.112: RC54.1 151.23,73.93 151.23,73.46 RC296.1 151.06,73.21 150.17,72.32 v2(150.17,72.1)
  IN1 w0.076: v2(135.08,71.94) 135.47,72.34 135.47,72.81 135.76,73.1 136.69,73.1 136.69,73.1 138.04,73.1 138.05,73.09 138.18,73.09 138.38,72.89 138.38,72.75 138.38,72.62 138.57,72.43 139.22,72.43 139.26,72.47 140.43,72.47 141,73.04 142.8,73.04 144.5,71.34 148.92,71.34 149.35,71.77 149.84,71.77 149.91,71.84
  IN1 w0.119: 149.91,71.84 v2(150.17,72.1)
  BOTTOM w0.076: UC1.AM20 v2(135.08,71.94)
PCH_RTCX2_R: length 2.7
  TOP w0.112: YC2.2 150.56,74.23 CC26.1 150.61,73.87 150.37,73.63 150.37,73.51 RC296.2
PCH_SMB_ALERT#: length 6.1
  TOP w0.102: v2(139.87,80.18) 140.29,79.76 v3(143.8,79.76) 144.6,78.96 RC23.1
  BOTTOM w0.076: UC1.R10 140.18,80.49 v2(139.87,80.18)
PCH_SPI_CLK: length 52.7
  TOP w0.112: v2(175.39,75.38) v3(174.62,75.38) 173.38,74.14 173.38,71.16 172.73,70.51 172.73,66.97 172.42,66.66 172.42,64.36 170.89,62.83 164.27,62.83 163.39,63.71 162.93,63.71 159.6,67.04 159.45,67.76 159.19,68.39 159.19,69.13 157.67,70.64 153.48,70.64 152.07,69.23 149.34,69.23 149.16,69.41 147.57,69.41 146.98,68.82 v2(146.96,68.82)
  BOTTOM w0.076: v2(146.96,68.82) 146.63,69.15 146.12,69.15 145.74,68.76 145.27,68.76 145.01,68.5 UC1.AV2
  BOTTOM w0.112: JSPI1.13 v2(175.39,75.38) 175.4,75.37 175.4,73.77 175.26,73.63 175.26,72.12 175.01,71.86 RC35.1
PCH_SPI_CLK_0_R: length 13
  BOTTOM w0.112: RPC1.6 177.54,85.43 177.25,85.73 177.25,86.97 RC29.1 177.55,87.2 177.97,87.62 177.97,88.55 v2(177.76,88.77) 177.7,88.83 177.7,91.87 177.82,92 178.28,92 178.4,91.89 178.4,89.25 178.51,89.13 179.72,89.13 UC5.6
PCH_SPI_CLK_1_R: length 46.6
  IN1 w0.119: v2(176.58,80.21) 172.94,80.21 172.4,80.75 170.36,80.75 169.74,80.12 167.62,80.12 166.3,81.45 164.67,81.45 164.53,81.31 164.53,79.89 166.25,78.17 166.25,77.66 165.36,76.77 165.36,75.85 164.85,75.34 163.92,75.34 163.66,75.08 163.41,75.08 163.4,75.07 162.39,75.07 161.61,75.85 161.61,76.74 161.02,77.33 v2(160.66,77.33)
  BOTTOM w0.112: v1(158.6,78.3) 158.21,77.9 RC28.1 158.72,77.33 v2(160.66,77.33) ; v2(176.58,80.21) 176.58,80.38 177.97,81.77 178.41,81.77 RC408.2 179.28,82.26 180.02,81.52 181.74,81.52 182.09,81.88 183.33,81.88 183.44,81.99 183.44,82.38 183.55,82.49 183.77,82.49 183.88,82.38 183.88,81.99 184,81.88 184.21,81.88 184.33,82 184.33,82.96 184.22,83.07 183.22,83.07 183.11,82.96 183.11,82.66 183,82.55 182.77,82.55 182.66,82.66 182.66,82.96 182.55,83.07 182.39,83.07 181.62,82.3 UC6.6
PCH_SPI_CLK_2_R: length 3
  BOTTOM w0.102: 173.98,86.14 RZ63.2
  BOTTOM w0.112: UZ12.19 173.34,85.05 173.98,85.69 RZ60.2 173.98,86.14
PCH_SPI_CLK_R1: length 21
  TOP w0.112: v2(176.34,78.15) 176.34,78.14 v3(175.68,77.47)
  IN3 w0.135: v2(176.34,78.15) 176.34,79.88 176.18,80.04 v2(176.18,80.68)
  BOTTOM w0.112: v2(176.18,80.68) 177.77,82.26 RC408.1 177.99,82.45 177.68,82.77 176.98,82.77 176.64,83.1 176.64,83.79 177.08,84.23 177.08,85.2 176.85,85.43 RPC1.3 175.22,85.43 RZ60.1 ; v2(176.34,78.15) 175.89,77.7 JSPI1.14 175.89,73.56 175.79,73.46 175.79,71.95 175.66,71.81 175.66,70.72 175.3,70.36 RC35.2
PCH_SPI_CS#0: length 53.5
  TOP w0.112: v2(174.51,74.56) 174.5,74.56 174.5,74.45 v3(173.87,73.83) 173.87,70.95 173.23,70.31 173.23,66.76 172.91,66.45 172.91,64.16 171.09,62.34 164.07,62.34 163.19,63.22 162.7,63.22 161.29,64.63 160.08,64.63 157.65,62.19 154.62,62.19 152.91,63.32 152.09,64.14 151.74,64.14 149.79,66.09 v2(149.79,67.4)
  BOTTOM w0.076: UC1.AU3 144.42,69.19 144.68,69.46 145,69.46 145.17,69.52 145.46,69.67 145.78,69.99 147.57,69.99 148.01,69.55 148.58,69.55 149.5,68.64 149.5,67.78
  BOTTOM w0.112: 174.5,74.56 174.5,74.71 174.58,74.78 174.58,76.47 174.39,76.65 JSPI1.11 ; 174.5,74.56 174.5,72.47 173.92,71.88 RC36.1 ; 174.5,74.56 v2(174.51,74.56) ; 149.5,67.78 149.5,67.69 v2(149.79,67.4)
PCH_SPI_CS#0_R1: length 45.7
  BOTTOM w0.112: JSPI1.12 174.89,73.96 174.77,73.83 174.77,72.4 174.52,72.14 174.52,70.85 174.25,70.58 174.12,70.58 RC36.2 174.45,69.84 176.4,69.84 176.63,69.61 179.41,69.61 180.56,70.76 180.56,72.18 179.92,72.82 179.92,77.02 183.35,80.44 188.91,80.44 189.9,81.44 190.17,81.44 191.16,82.43 v3(191.16,86.68) 191.16,91.18 190.39,91.95 RC37.1
PCH_SPI_CS#0_R2: length 2.4
  BOTTOM w0.112: v2(189.97,91.24) 189.48,91.24 RC37.2 189.22,90.98 UC5.1
PCH_SPI_CS#1: length 56
  TOP w0.112: v2(149.23,67.4) 149.23,66.31 151.64,63.9 151.97,63.9 152.69,63.18 154.56,61.94 157.73,61.94 160.18,64.39 161.19,64.39 162.6,62.98 163.09,62.98 163.97,62.1 171.19,62.1 173.32,64.22 v3(173.32,65.44) 173.32,65.97 173.48,66.13 173.48,70.22 174.12,70.86 174.12,72.36 176.16,74.4 177.29,74.4 v2(177.71,74.82)
  BOTTOM w0.076: UC1.AU2 145.01,69.19 145.16,69.34 145.55,69.53 145.85,69.83 147.5,69.83 147.94,69.39 148.51,69.39 149.32,68.59 149.32,67.59 149.23,67.51
  BOTTOM w0.112: 149.23,67.51 v2(149.23,67.4) ; RC32.2 178.05,72.16 178.05,74.08 177.71,74.42 v2(177.71,74.82) 178.39,75.5 JSPI1.19
PCH_SPI_CS#1_R1: length 22.6
  BOTTOM w0.112: RC32.1 178.89,72.23 JSPI1.20 v3(180.25,78.59) 180.26,78.6 180.26,79.89 180.4,80.03 182.26,80.03 183.15,80.92 185.06,80.92 185.29,81.15 185.29,83.64 187.37,85.72 RC42.1
PCH_SPI_CS#1_R2: length 1.6
  BOTTOM w0.112: RC42.2 189.26,84.84 UC6.1
PCH_SPI_CS#2: length 61.2
  TOP w0.112: v2(148.21,68.86) 148.3,68.77 148.96,68.77 149.14,68.59 149.14,68.02 148.76,67.64 148.76,66.44 151.54,63.66 151.87,63.66 152.54,62.99 154.49,61.7 157.83,61.7 160.28,64.15 161.09,64.15 162.5,62.74 162.99,62.74 163.87,61.86 171.29,61.86 173.56,64.12 173.56,64.74 173.98,65.17 173.98,69.59 174.5,70.11 174.5,72.04 v3(174.77,72.31) 175.77,73.31 176.28,73.31 176.28,73.3 v2(176.27,73.3)
  IN1 w0.119: v2(175.64,84.87) 176.72,84.87 177.93,83.66 177.93,77.78 176.72,76.57 176.72,73.75 v2(176.27,73.3)
  BOTTOM w0.076: v2(148.21,68.86) 147.55,69.53 145.85,69.53 UC1.AU1
  BOTTOM w0.112: RZ61.1 v2(175.64,84.87)
PCH_SPI_CS#2_R: length 14.6
  TOP w0.112: v2(173.33,84.36) 173.41,84.36 v3(173.72,84.67)
  IN1 w0.119: v2(162.68,84.55) 163.07,84.16 163.42,84.16 163.9,83.68 171.63,83.68 172.32,84.36 v2(173.33,84.36)
  BOTTOM w0.112: UZ12.20 172.79,84.55 172.97,84.36 v2(173.33,84.36) 173.48,84.36 RZ61.2 ; RZ113.1 162.77,84.64 v2(162.68,84.55)
PCH_SPI_D0: length 60.1
  TOP w0.112: v2(177.39,73.72) 177.32,73.66 177.2,73.66 174.82,71.27 v3(174.82,66.63) 174.82,65.32 174.03,64.54 174.03,63.93 171.49,61.38 163.67,61.38 162.79,62.26 162.3,62.26 160.91,63.66 160.47,63.66 158.03,61.22 154.35,61.22 152.23,62.62 151.67,63.18 151.34,63.18 147.91,66.62 v2(146.43,66.62)
  BOTTOM w0.076: 147.08,66.05 146.51,66.62 v2(146.43,66.62) 145.79,66.62 145.63,66.78 145.3,66.78 145.18,66.9 145.18,67.39 144.91,67.65 144.06,67.65 143.89,67.82 UC1.AV3
  BOTTOM w0.102: 147.08,66.05 147.56,65.56 148.61,65.56
  BOTTOM w0.112: RC33.1 177.49,71.57 177.49,73.62 v2(177.39,73.72) 177.06,74.05 177.06,75.6 177.54,76.07 177.54,76.6 177.39,76.74 JSPI1.17 ; RC10.2 149.7,64.12 149.7,64.71 148.85,65.56 148.61,65.56
PCH_SPI_D0_0_R: length 14.4
  BOTTOM w0.112: RPC1.7 178.13,84.94 178.38,85.18 178.38,86.22 178.51,86.35 v2(178.78,86.35) 179.43,86.35 180.18,85.6 184.18,85.6 184.38,85.8 184.38,86.1 184.14,86.34 180.29,86.34 179.73,86.9 179.73,87.05 179.84,87.17 UC5.5
PCH_SPI_D0_1_R: length 12.8
  BOTTOM w0.112: RC409.2 178.69,81.28 178.18,81.28 178.03,81.13 178.03,80.97 178.38,80.61 178.38,80.46 178.23,80.31 178.07,80.31 177.72,80.66 177.56,80.66 177.29,80.39 177.29,80.23 177.44,80.08 177.44,79.92 177.26,79.74 177.1,79.74 176.97,79.87 176.81,79.87 176.58,79.65 176.58,79.49 176.93,79.15 177.7,79.15 177.81,79.26 v3(177.81,79.48) 177.81,79.79 177.92,79.9 178.14,79.9 178.26,79.79 178.26,79.26 178.37,79.15 179.37,79.15 179.55,79.32 179.55,79.56 179.25,79.86 179.25,80.04 179.37,80.15 179.52,80.15 179.63,80.26 179.63,80.48 179.52,80.6 179.37,80.6 179.25,80.71 179.25,80.92 179.37,81.03 UC6.5
PCH_SPI_D0_2_R: length 1.8
  BOTTOM w0.112: RZ59.2 172.85,83.98 172.78,84.05 UZ12.21
PCH_SPI_D0_R1: length 20.5
  TOP w0.112: v2(175.71,81.83) 177.91,79.63 v2(178.64,79.63) 178.72,79.55 v1(178.72,78.52) 178.72,77.12 v2(177.92,76.32)
  BOTTOM w0.112: v2(175.71,81.83) 175.71,83.16 RZ59.1 175.4,84.48 175.88,84.48 176.33,84.94 RPC1.2 ; JSPI1.18 177.89,76.35 v2(177.92,76.32) 177.92,76.12 177.31,75.5 177.31,74.47 177.79,73.99 177.79,70.63 177.52,70.36 RC33.2 ; v2(178.64,79.63) 178.82,79.8 RC409.1
PCH_SPI_D1: length 50.6
  TOP w0.112: v2(174.65,64.29) 175.48,65.12 175.48,71.27 176.44,72.23 v2(176.82,72.23)
  BOTTOM w0.076: 148.61,66.5 147.43,66.5 146.9,67.02 146.89,67.02 145.7,68.21 144.51,68.21 UC1.AW3
  BOTTOM w0.112: JSPI1.15 176.39,76.4 176.55,76.25 176.55,73.59 176.82,73.33 v2(176.82,72.23) 176.82,72.07 176.27,71.52 RC34.1 ; 148.61,66.5 151.02,66.5 151.13,66.39 151.13,65.7 151.56,65.27 151.56,64.69 153.78,62.47 157.25,62.47 157.65,62.88 160.89,62.88 161.29,63.27 166.87,63.27 167.97,64.37 168.98,64.37 169.68,65.07 174.13,65.07 v1(174.34,64.87) 174.65,64.55 v2(174.65,64.29)
PCH_SPI_D1_0_R: length 15.4
  BOTTOM w0.112: RPC1.8 178.51,84.44 178.62,84.55 178.62,85.72 178.77,85.87 179.48,85.87 179.99,85.37 184.28,85.37 184.62,85.7 184.62,89.43 184.89,89.71 v2(186.25,89.71) UC5.2
PCH_SPI_D1_1_R: length 13.4
  BOTTOM w0.112: RC410.2 182.16,79.6 183.25,80.68 185.16,80.68 185.53,81.05 185.53,81.43 185.64,81.54 186.48,81.54 186.59,81.66 186.59,81.88 186.48,81.99 185.64,81.99 185.53,82.1 185.53,82.33 185.64,82.44 186.48,82.44 186.59,82.55 186.59,82.77 186.48,82.89 185.64,82.89 185.53,83 185.53,83.54 186.12,84.13 186.39,84.13 186.95,83.57 UC6.2
PCH_SPI_D1_2_R: length 2
  BOTTOM w0.112: RZ58.2 173.36,81.82 172.63,82.55 UZ12.24
PCH_SPI_D1_R1: length 36.2
  IN3 w0.135: v2(177.12,76.41) 174.98,76.41 174.85,76.55 174.85,81.05 174.98,81.19 v2(175.71,81.19)
  BOTTOM w0.112: RC410.1 180.72,78.16 179.2,76.64 179.2,72.68 180.32,71.56 180.32,70.86 179.31,69.85 176.77,69.85 RC34.2 176.43,70.52 176.6,70.52 176.75,70.67 176.75,71.59 177.2,72.03 177.2,73.34 176.82,73.72 176.82,76.12 v2(177.12,76.41) 177.1,76.41 176.89,76.62 JSPI1.16 ; RPC1.1 176.28,84.44 176.15,84.31 176.15,81.44 175.9,81.19 v2(175.71,81.19) 175.4,81.19 RZ58.1 174.77,80.94 v3(174.63,80.8)
PCH_SPI_D2: length 58.4
  TOP w0.112: v2(173.74,76.17) 173.9,76 174.08,76 174.25,76.17 176.15,76.17 176.88,75.43 177.97,75.43 178.33,75.08 178.33,74.55 178,74.22 178,73.31 177.88,73.19 177.26,72.56 177.26,70.99 175.72,69.45 175.72,64.77 175,64.05 v2(175,63.85)
  BOTTOM w0.076: 146.83,66.85 145.64,68.04 144.99,68.04 UC1.AW2
  BOTTOM w0.102: 146.83,66.85 147.87,65.8 148.61,65.8
  BOTTOM w0.112: JSPI1.9 173.39,76.81 173.74,76.47 v2(173.74,76.17) 172.9,75.33 RC38.1 ; 148.61,65.8 149.36,65.8 149.99,65.17 RC11.2 153.58,62 157.45,62 157.85,62.4 161.09,62.4 161.49,62.8 167.07,62.8 168.17,63.9 169.18,63.9 169.6,64.32 170.05,64.32 170.16,64.2 170.46,64.2 170.97,64.71 v1(171.85,64.71) 173.58,64.71 174.44,63.85 v2(175,63.85)
PCH_SPI_D2_0_R: length 13.6
  BOTTOM w0.112: UC5.3 186.21,88.44 186.1,88.55 186.1,89.12 186.21,89.23 188.39,89.23 188.68,89.52 188.68,90.54 188.77,90.63 189.14,90.63 189.25,90.52 189.25,89.63 189.36,89.52 189.82,89.52 189.97,89.68 189.97,90.76 190.09,90.87 190.45,90.87 190.56,90.76 v3(190.56,89.59) 190.56,88.97 190.45,88.86 189.36,88.86 189.24,88.75 RC39.2
PCH_SPI_D2_1_R: length 13
  BOTTOM w0.112: UC6.3 188.66,82.3 188.77,82.41 188.77,83.21 188.88,83.32 189.54,83.32 189.66,83.43 v1(189.66,83.56) 189.66,83.66 189.54,83.77 188.88,83.77 188.77,83.88 188.77,84.28 188.88,84.39 189.68,84.39 189.79,84.5 189.79,86.3 189.9,86.41 190.33,86.41 190.45,86.3 190.45,82.91 190.26,82.73 189.69,82.73 RC43.2
PCH_SPI_D2_R1: length 41.7
  BOTTOM w0.112: RC43.1 190.68,82.81 190.68,87.9 RC39.1 189.62,87.88 v3(189.62,87.52) 189.62,87.43 188.65,86.45 187.76,86.45 185.05,83.74 185.05,81.27 184.94,81.16 183.05,81.16 182.16,80.27 180.3,80.27 180.02,79.99 180.02,78.79 179.9,78.68 176.17,78.68 175.96,78.46 ; 175.96,78.46 175.96,79.45 175.31,80.1 174.07,80.1 RC30.1 ; 175.96,78.46 175.44,77.95 174.02,77.95 173.89,77.82 JSPI1.10 173.89,76.65 174.2,76.35 174.2,74.85 173.94,74.59 173.94,72.56 173.45,72.07 173.45,70.67 173.18,70.4 RC38.2
PCH_SPI_D3: length 55.8
  TOP w0.112: v2(148.75,68.35) 148.48,68.08 148.48,67.92 148.52,67.88 148.52,66.34 151.42,63.45 151.46,63.42 151.77,63.42 152.39,62.8 154.42,61.46 157.93,61.46 160.38,63.91 160.99,63.91 162.4,62.5 162.89,62.5 163.77,61.62 171.39,61.62 173.8,64.03 173.8,64.64 174.33,65.18 v3(174.33,68.67) 174.33,69.31 v2(174.43,69.4)
  BOTTOM w0.076: v2(148.75,68.35) 148.15,68.35 147.16,69.34 146.08,69.34 145.67,68.93 143.83,68.93 UC1.AU4
  BOTTOM w0.112: v2(174.43,69.4) 173.85,68.82 171.73,68.82 171.33,69.23 171.33,70.96 171.66,71.29 RC40.1 171.83,76.02 172.39,76.59 JSPI1.7
PCH_SPI_D3_0_R: length 15.3
  BOTTOM w0.112: v3(178.73,89.71) UC5.7 184.1,89.71 184.21,89.59 184.21,88.06 184.1,87.94 179.72,87.94 179.5,88.16 178.8,88.16 178.59,87.95 178.59,87.15 177.74,86.3 RPC1.5
PCH_SPI_D3_1_R: length 13.2
  BOTTOM w0.112: RC407.2 179.33,82.79 181.42,82.79 182.19,83.57 183.16,83.57 183.67,84.08 183.67,84.72 183.51,84.88 183.34,84.88 183.23,84.77 183.23,84.26 183.12,84.14 182.9,84.14 182.78,84.26 182.78,84.77 182.67,84.88 182.45,84.88 182.33,84.77 182.33,84.26 182.22,84.14 182.01,84.14 181.89,84.26 181.89,84.77 181.77,84.88 181.55,84.88 181.44,84.77 181.44,83.71 181.3,83.57 UC6.7
PCH_SPI_D3_R1: length 36.1
  TOP w0.112: v2(171.78,69.39) 171.78,69.78 172.01,70.01 172.01,70.87 172.66,71.52 172.66,82.65 173.38,83.36 v3(174.69,83.36) v2(177.17,83.36)
  IN1 w0.119: v2(177.17,83.36) 176.17,84.36 175.6,84.36 175.14,84.82 175.14,86.12 v2(175.56,86.55)
  BOTTOM w0.112: v2(175.56,86.55) 176.17,85.93 RPC1.4 ; v2(177.17,83.36) 177.19,83.34 RC407.1 ; RC316.1 RC31.1 172.89,78.04 JSPI1.8 172.89,76.44 172.33,75.87 172.33,70.63 172.07,70.38 RC40.2 171.83,69.44 v2(171.78,69.39)
PCH_SPI_DO2_XDP: length 168.2
  TOP w0.112: v2(170.33,64.62) 169.77,65.18 169.77,66.12 171.05,67.4 171.05,70.6 171.75,71.3 171.75,79.28 170.57,80.46 170.57,81.13 170.24,81.46 170.24,90.99 169.79,91.44 169.79,98.21 168.72,99.27 167.89,99.27 167.54,98.92 159.5,98.92 157.63,100.78 157.63,101.14 157.63,105.03 155.51,107.15 141.32,107.15 v1(141.05,107.42) 140.42,108.05 135.52,108.05 134.92,107.45 127.89,107.45 v2(127.27,108.07)
  IN2 w0.124: v2(127.27,108.07) 126.74,108.6 121.95,108.6 119.71,106.37 105.21,106.37 104.99,106.58 101.03,106.58 100.91,106.71 93.26,106.71 92.43,107.54 77.37,107.54 74.84,105 72.31,105 71.43,105.88 v2(71.1,105.88)
  BOTTOM w0.112: JXDP1.60 71.11,105.87 v2(71.1,105.88) ; RC11.1 151.32,65.17 151.32,64.59 153.68,62.24 157.35,62.24 157.75,62.64 160.99,62.64 161.39,63.04 166.97,63.04 168.07,64.13 169.08,64.13 169.57,64.62 v2(170.33,64.62)
PCH_SPI_DO_XDP: length 176.7
  TOP w0.112: v2(86.36,92.87) 88.33,94.84 89.66,94.84 89.79,94.96 89.79,98.68 93.57,102.46 97.21,102.46 98.48,103.73 100.81,103.73 101.36,104.28 105.43,104.28 107.49,106.33 v1(109.48,106.33) 111.57,106.33 112.02,106.77 115.97,106.77 116.73,106.02 116.73,105.66 117.01,105.39 117.34,105.39 119.88,107.92 126.29,107.92 127.25,106.96 135.09,106.96 135.55,107.42 138.42,107.42 138.93,106.91 155.41,106.91 157.39,104.93 157.39,101.24 157.39,101.24 157.39,100.68 159.4,98.68 167.64,98.68 167.99,99.03 168.62,99.03 169.55,98.11 169.55,90.24 169.31,90.01 169.31,88.17 170,87.48 170,81.36 170.33,81.03 170.33,80.36 171.51,79.18 171.51,71.4 170.81,70.7 170.81,67.5 169.54,66.22 169.54,64.82 170.39,63.97 v2(170.39,63.79)
  IN2 w0.124: v2(73.23,95.76) 73.23,95.62 74.4,94.45 75.82,94.45 76.4,93.87 78.81,93.87 79.19,93.49 85.74,93.49 v2(86.36,92.87)
  BOTTOM w0.112: v2(73.23,95.76) 73.23,96.92 RC133.1 72.39,98.14 RC128.1 ; v2(170.39,63.79) 170.13,63.52 169.21,63.52 169.08,63.66 168.27,63.66 167.17,62.56 161.59,62.56 161.19,62.16 157.95,62.16 157.55,61.76 153.49,61.76 150.92,64.32 RC10.1
PCI_CLK_LPC1: length 12.5
  TOP w0.112: RC22.1 149.35,61.91 v1(147.81,63.45) 147.02,64.24 145.41,64.24 144.78,64.86 143.53,64.86 v2(143.45,64.78)
  BOTTOM w0.076: UC1.AY9 140.87,67.03 140.87,66.87 140.88,66.85 140.88,65.93 141.64,65.18 141.64,65.18 142.19,64.63 143.32,64.63 143.45,64.76 v2(143.45,64.78)
