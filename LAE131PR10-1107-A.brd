# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_C_DTX_N1: length 3.9
  TOP w0.104: UR1.8 295.4,50.55 295.31,50.63 295.13,50.63 295.08,50.58 294.44,50.58 294.44,50.59 294.09,50.59 v4(293.46,51.22) 293.07,51.61 292.82,51.61 CR14.2
PCIE_PRX_C_DTX_N5: length 4.6
  TOP w0.076: 26.11,92.55 26.27,92.4 26.27,91.87 26.4,91.74 26.4,91.31 UT1.F22
  TOP w0.104: 26.11,92.55 25.88,92.79 25.88,94.62 25.7,94.79 25.7,95.02 CT130.1
PCIE_PRX_C_DTX_N6: length 4.6
  TOP w0.076: 27.67,93.1 27.67,93.09 27.66,93.1 27.66,93.09 27.66,92.9 28.11,92.44 28.11,91.86 28.24,91.74 28.24,91.31 UT1.K22
  TOP w0.104: CT128.1 27.67,95.02 27.67,93.1
PCIE_PRX_C_DTX_N7: length 3.7
  TOP w0.076: 29.75,93.1 29.75,93.09 29.77,93.07 29.77,91.89 29.61,91.74 29.61,91.74 29.61,91.32 29.71,91.22 29.71,91.22 UT1.P22
  TOP w0.104: 29.75,93.1 29.75,94.32 CT9.1
PCIE_PRX_C_DTX_N8: length 2.7
  TOP w0.076: UT1.V22 31.91,91.3 31.91,92.18 32.29,92.55 32.29,92.76 32.3,92.78
  TOP w0.104: CT7.1 32.3,93.24 32.3,92.78
PCIE_PRX_C_DTX_N9: length 2.3
  TOP w0.104: CL2.2 270.59,96.23 270.92,96.23 271.22,95.93 271.57,95.93 271.68,95.82 UL1.39
PCIE_PRX_C_DTX_P1: length 3.9
  TOP w0.104: UR1.7 295.38,50.95 295.29,50.86 295.08,50.86 295,50.79 v4(294.68,50.79) 294.18,50.79 293.78,51.19 293.78,51.19 293.44,51.53 293.44,51.53 293.16,51.81 292.93,51.81 CR13.2
PCIE_PRX_C_DTX_P5: length 4.5
  TOP w0.076: UT1.F23 26.17,91.43 26.12,91.38 26.03,91.38 25.94,91.46 25.94,91.72 26.09,91.87 26.09,92.28 26.04,92.33 26.02,92.33 25.98,92.38 25.96,92.38 25.95,92.39
  TOP w0.104: 25.95,92.39 25.68,92.66 25.68,94.53 25.5,94.71 25.5,95.02 CT129.1
PCIE_PRX_C_DTX_P6: length 4.5
  TOP w0.076: UT1.K23 28.01,91.43 27.96,91.38 27.87,91.38 27.78,91.46 27.78,91.72 27.94,91.88 27.94,92.37 27.48,92.83 27.48,93.07 27.47,93.09 27.47,93.1
  TOP w0.104: 27.47,93.1 27.46,93.11 27.46,95.03 CT127.1
PCIE_PRX_C_DTX_P7: length 3.7
  TOP w0.076: UT1.P23 29.85,91.39 29.92,91.33 30.04,91.33 30.1,91.38 30.1,91.72 29.94,91.87 29.94,93.07 29.95,93.09 29.95,93.1
  TOP w0.104: CT8.1 29.95,94.32 29.95,93.1
PCIE_PRX_C_DTX_P8: length 2.6
  TOP w0.076: UT1.V23 31.69,91.47 31.65,91.43 31.54,91.43 31.46,91.51 31.46,91.82 31.74,92.1 31.74,92.25 32.11,92.62 32.11,92.77 32.1,92.78
  TOP w0.104: 32.1,92.78 32.1,93.24 CT6.1
PCIE_PRX_C_DTX_P9: length 2.4
  TOP w0.104: UL1.38 271.65,96.22 271.56,96.13 271.31,96.13 271,96.43 270.69,96.43 CL1.2
PCIE_PRX_DTX_N1: length 214.3
  TOP w0.104: CR14.1 291.21,51.71 290.59,51.71 v2(290.45,51.57)
  IN3 w0.076: 138.51,85.85 138.48,85.82 138.48,84.78 138.24,84.55 138.1,84.55 v2(137.82,84.27)
  IN3 w0.135: v2(290.45,51.57) 290.28,51.74 287.86,51.74 287.33,51.22 287.09,51.22 286.68,50.81 284.49,50.81 283.48,51.83 281.8,51.83 281.67,51.69 281.67,46.09 281.1,45.51 281.1,33.46 279.63,31.99 279.63,31.58 278.97,30.92 278.39,30.92 277.13,29.66 275.91,29.66 275.81,29.56 267.73,29.56 266.84,30.45 265.29,30.45 264.98,30.15 264.08,30.15 263.78,30.45 260.92,30.45 259.53,29.05 258.84,29.05 258.18,28.39 258.17,28.39 257.78,28 253.71,28 253.43,27.72 249.22,27.72 248.83,28.11 248.83,28.65 247.4,30.08 245.47,30.08 245.11,29.72 242.25,29.72 240.71,31.26 238.76,31.26 238.48,31.54 238.48,32.15 235.86,34.77 232.2,34.77 231.98,34.55 206.76,34.55 206.56,34.55 201.2,39.92 201.05,39.92 193.84,47.13 193.84,47.34 188.86,52.32 188.86,53.57 183.38,59.05 183.38,60.45 181.97,61.87 181.97,63.17 177.92,67.23 177.92,67.34 177.92,67.44 177.92,69.01 174.32,72.6 173.62,72.6 171.91,74.31 171.91,74.32 171.58,74.65 171.58,77.35 172.29,78.06 172.29,80.52 170.45,82.37 170.45,84.03 169.48,84.99 168.01,84.99 167.14,85.86 161.47,85.86 160.66,85.05 153.45,85.05 151.94,86.56 149.14,86.56 148.93,86.35 142.58,86.35 142.05,85.82 140.75,85.82 140.07,86.5 139.16,86.5 138.51,85.85
  BOTTOM w0.076: UC1.H13 138.28,84 v2(137.82,84.27)
PCIE_PRX_DTX_N3: length 231.9
  IN3 w0.076: v2(136,84.19) 135.86,84.19 135.49,84.56 135.49,84.9 135.49,84.9 135.49,86.69 135.46,86.72 135.46,86.79
  IN3 w0.135: v2(291.79,58.69) 290.78,58.69 289.77,59.71 287.95,59.71 286.82,60.83 273.65,60.83 272.46,59.64 270.37,59.64 268.9,58.17 263.54,58.17 262.84,57.47 262.84,56.26 260.95,54.37 260,54.37 259.45,53.82 257.92,53.82 255.99,51.89 254.26,51.89 244.8,42.43 243.39,42.43 241.48,40.53 239.92,40.53 239.33,41.11 229.42,41.11 228.93,40.62 221.43,40.62 220.41,41.63 210.97,41.63 210.89,41.55 207.61,41.55 205.72,43.44 204.65,43.44 198.49,49.6 198.49,50.87 190.85,58.51 190.61,58.51 188.02,61.1 188.02,62.5 186.34,64.17 186.34,64.98 182.7,68.62 182.7,69.46 183.03,69.78 183.03,70.83 182.32,71.53 182.32,72.97 181.83,73.46 181.83,84.47 178.85,87.45 176.62,87.45 172.83,91.24 172.83,92.02 170.79,94.06 167.08,94.06 165.44,95.7 161.86,95.7 161.61,95.95 152.59,95.95 152.41,95.77 151.92,95.77 151.14,94.99 151.14,94.45 150.43,93.73 149.78,93.73 149.37,93.32 146.44,93.32 144.78,94.99 142.81,94.99 142.16,95.63 138.41,95.63 136.57,93.79 136.57,88.04 135.62,87.09 135.62,86.95 135.46,86.79
  BOTTOM w0.076: UC1.H16 136.26,83.94 v2(136,84.19)
  BOTTOM w0.104: v2(291.79,58.69) 291.56,58.46 291.24,58.46 291,58.22 291,56.59 292.17,55.42 292.17,52.05 292.89,51.32 292.89,49.77 292.23,49.11 292.23,46.62 291.41,45.8 JNGFF1.43
PCIE_PRX_DTX_N4: length 217.7
  IN3 w0.135: v2(136.91,84.97) 136.91,85.04 136.5,85.45 136.5,85.88 136.6,85.99 136.6,86.93 137.18,87.5 137.18,87.95 137.25,88.02 137.25,92.87 139.3,94.93 141.9,94.93 142.75,94.08 142.75,93.45 143.64,92.55 147.91,92.55 148.23,92.23 149.95,92.23 152.99,95.27 161.2,95.27 161.6,94.88 164.39,94.88 166.29,92.98 170.91,92.98 172.15,91.74 172.15,90.96 181.08,82.03 181.08,77.86 180.55,77.32 180.55,71.58 181.99,70.14 181.99,68.35 185.64,64.69 185.64,63.5 187.25,61.89 187.25,60.9 190.32,57.83 190.57,57.83 197.79,50.6 197.79,49.33 204.71,42.41 205.67,42.41 206.35,41.73 206.35,41.24 206.83,40.76 211.43,40.76 212.76,39.43 228.72,39.43 229.72,40.43 238.74,40.43 239.56,39.6 242.94,39.6 243.3,39.97 243.3,41.37 243.67,41.74 245.07,41.74 252.95,49.62 253.75,49.62 255.1,50.97 257.13,50.97 258.65,52.49 259.13,52.49 260.32,53.68 261.24,53.68 265.05,57.49 269.69,57.49 270.27,58.07 271.89,58.07 272.48,58.66 273.8,58.66 274.09,58.94 274.97,58.94 275.11,58.81 275.62,58.81 276.6,59.79 286.85,59.79 288.88,57.76 289.08,57.76 v2(289.24,57.92)
  BOTTOM w0.076: v2(136.91,84.97) 137.29,84.59 UC1.G15
  BOTTOM w0.104: JNGFF1.67 289.29,51.8 289.43,51.67 289.55,51.67 289.68,51.79 289.68,55.16 288.48,56.36 288.48,57.37 288.78,57.67 288.99,57.67 v2(289.24,57.92)
PCIE_PRX_DTX_N5: length 141.2
  TOP w0.104: v2(26.29,96.24) 26.29,96.24 26.29,96.51 26.18,96.61 25.94,96.61 25.69,96.36 25.69,95.92 25.82,95.79 CT130.2
  IN1 w0.119: v2(136.02,85.46) 136.44,85.88 136.49,85.88 136.73,86.12 136.73,89.33 137.23,89.83 137.23,95.66 135.35,97.53 135.35,100.07 129.05,106.37 124.54,106.37 124.36,106.19 123.7,106.19 123.3,106.6 122.04,106.6 121.56,107.07 97.8,107.07 96.72,105.99 93.04,105.99 91.67,107.35 67.17,107.35 66.72,106.9 63.53,106.9 62.48,107.95 57.71,107.95 57.21,107.45 50.68,107.45 50.25,107.88 43.66,107.88 43.17,107.39 42.99,107.39 42.8,107.58 42.69,107.58 v2(42.41,107.86)
  IN3 w0.135: v2(42.41,107.86) 41.93,107.86 41.51,108.28 39.6,108.28 39.27,107.95 35.3,107.95 32.24,104.88 31.63,104.88 29.41,102.66 29.41,100.2 27.17,97.96 26.68,97.96 26.68,97.96 26.23,97.96 26.03,97.96 25.55,97.47 25.55,96.65 25.84,96.36 26.16,96.36 v2(26.29,96.24)
  BOTTOM w0.076: UC1.F16 136.23,85.46 v2(136.02,85.46)
PCIE_PRX_DTX_N6: length 131.8
  TOP w0.104: CT128.2 27.81,95.79 27.61,95.98 27.61,96.04 27.48,96.17 27.48,96.35 27.59,96.46 28.54,96.46 29.28,97.2 30.97,97.2 31.03,97.15 32.29,97.15 32.43,97 32.43,96.94 32.39,96.89 32.39,96.64 32.29,96.54 32.14,96.54 v2(32.12,96.56)
  IN1 w0.119: v2(40.48,102.37) 40.99,102.37 41.9,101.45 43.21,101.45 44.12,102.37 45,102.37 47.2,104.56 50.29,104.56 50.57,104.84 53.77,104.84 54.31,104.31 57.89,104.31 58.13,104.07 62.44,104.07 63.01,103.51 91.67,103.51 91.92,103.26 97.75,103.26 98.47,103.99 100.07,103.99 100.33,103.73 106.12,103.73 106.32,103.93 121.07,103.93 122.91,102.09 128.44,102.09 129.95,100.58 129.95,97.98 133.4,94.53 133.4,90.14 134.8,88.74 135.04,88.74 135.95,87.83 135.95,86.77 135.67,86.49 135.67,85.7 135.6,85.64 135.6,85.5 135.6,85.5 135.6,85.32 v2(135.13,84.85)
  IN3 w0.135: v2(32.12,96.56) 32.12,97.28 33.36,98.52 33.36,99.68 36.05,102.37 v2(40.48,102.37)
  BOTTOM w0.076: v2(135.13,84.85) 135.41,84.85 135.54,84.73 UC1.G18
PCIE_PRX_DTX_N7: length 124.7
  TOP w0.104: CT9.2 29.78,95.31 29.78,95.49 v2(29.61,95.66)
  IN1 w0.119: v2(134.25,85.58) 134.46,85.74 134.48,85.9 134.48,85.91 134.43,85.97 134.43,86.07 134.43,86.07 134.43,87.35 133.42,88.36 132.62,88.36 132.13,88.84 132.13,90.99 129.58,93.55 129.58,93.89 126.78,96.7 124.54,96.7 123.17,98.06 123.17,98.95 119.69,102.43 107.1,102.43 106.89,102.22 99.83,102.22 99.33,101.72 91.27,101.72 90.99,101.99 62.39,101.99 61.83,102.55 61.4,102.55 60.84,101.98 60.65,101.98 59.78,101.98 59.58,102.19 52.85,102.19 51.99,103.05 48.08,103.05 45.09,100.05 44.54,100.05 43.97,99.49 41.99,99.49 41.62,99.12 40.66,99.12 v2(40.54,98.99)
  IN3 w0.135: v2(40.54,98.99) 40.5,99.03 39.97,99.03 39.32,99.68 35.67,99.68 34.99,99 34.99,98.22 35.22,97.99 35.22,96.04 33.27,94.09 30.85,94.09 29.74,95.19 29.74,95.53 v2(29.61,95.66)
  BOTTOM w0.076: UC1.F20 134.62,85.25 134.29,85.58 v2(134.25,85.58)
PCIE_PRX_DTX_N8: length 130.8
  TOP w0.104: CT7.2 32.41,94.01 32.29,94.14 32.29,94.48 31.75,95.01 31.75,95.49 31.89,95.63 32.08,95.63 32.23,95.48 v2(32.23,95.31)
  IN1 w0.119: v2(40.75,97.62) 40.9,97.77 41.45,97.77 42.16,98.48 44.87,98.48 48.79,102.4 51.67,102.4 52.91,101.16 62.71,101.16 62.86,101.3 63.85,101.3 64.49,100.66 68.42,100.66 69.09,101.33 90.74,101.33 91.07,101 102.96,101 103.47,101.5 107.08,101.5 107.34,101.77 112.69,101.77 112.69,101.77 113.02,101.77 113.02,101.77 113.28,101.77 113.28,101.77 113.6,101.77 113.6,101.77 113.92,101.77 113.92,101.77 114.25,101.77 114.25,101.77 114.49,101.77 114.49,101.77 114.82,101.77 114.82,101.77 115.42,101.77 115.42,101.77 115.75,101.77 115.75,101.77 116.01,101.77 116.01,101.77 116.33,101.77 116.33,101.77 116.67,101.77 116.67,101.77 116.99,101.77 116.99,101.77 117.25,101.77 117.25,101.77 117.57,101.77 117.58,101.77 118.01,101.77 118.01,101.77 118.34,101.77 118.34,101.77 118.56,101.77 124.3,96.02 126.47,96.02 128.5,93.99 128.5,89.71 131.63,86.58 132.42,86.58 132.69,86.32 132.69,85.5 132.93,85.26 132.98,85.26 v2(133.26,84.98)
  IN3 w0.135: v2(32.23,95.31) 32.06,95.48 31.73,95.48 31.36,95.85 31.36,97.5 32.66,98.79 32.66,99.95 35.76,103.06 40.89,103.06 41.57,102.38 41.57,98.17 41.19,97.79 40.92,97.79 v2(40.75,97.62)
  BOTTOM w0.076: v2(133.26,84.98) 133.29,85 133.43,85 133.71,84.72 UC1.G21
PCIE_PRX_DTX_N9: length 229.9
  TOP w0.104: CL2.1 268.86,95.94 268.73,96.07 268.73,96.49 268.59,96.63 268.21,96.63 265.88,94.3 265.88,65.15 265.54,64.82 265.54,64.78 265.14,64.37 265.1,64.37 264.79,64.06 264.79,60.65 266.36,59.08 267.79,59.08 v2(268.17,59.46)
  IN3 w0.135: v2(268.17,59.46) 267.83,59.12 263.47,59.12 262.02,57.66 262.02,56.46 261.08,55.52 259.63,55.52 258.62,54.5 257.29,54.5 255.36,52.57 253.98,52.57 244.62,43.22 243.19,43.22 241.76,41.79 228.39,41.79 228.15,41.55 221.63,41.55 220.2,42.97 207.47,42.97 191.25,59.19 190.89,59.19 189.12,60.96 189.12,62.6 187.03,64.69 187.03,65.29 185.17,67.15 185.17,67.79 184.05,68.91 184.05,70.37 183.71,70.71 183.71,71.12 183.08,71.75 183.08,84.35 175.65,91.78 174.22,91.78 170.69,95.31 167.74,95.31 166.66,96.39 162.39,96.39 162.1,96.68 152.34,96.68 152.15,96.49 151.62,96.49 151.06,95.93 150.58,95.93 150.06,96.45 145.67,96.45 145.02,95.8 142.96,95.8 141.91,96.84 140.54,96.84 140.01,96.31 138.1,96.31 135.88,94.1 135.88,88.65 134.02,86.78 133.03,86.78 132.67,86.41 132.67,86.22 132.59,86.14 132.3,86.14 v2(132.29,86.15)
  BOTTOM w0.102: UC1.E22 132.55,85.89 v2(132.29,86.15)
PCIE_PRX_DTX_N11: length 186.8
  IN1 w0.119: v2(128.72,85.63) 128.72,86.39 128.31,86.81 128.31,87.19 127.1,88.4 127.1,94.45 126.19,95.37 124.05,95.37 119.01,100.41 107.19,100.41 106.75,100.86 103.73,100.86 103.22,100.34 89.52,100.34 89.35,100.17 69.22,100.17 69.06,100.01 54.63,100.01 53.48,98.86 53.48,97.56 49.63,93.72 48.6,93.72 47.17,92.3 47.17,87.96 46.87,87.65 46.87,84.73 47.13,84.47 47.13,82.22 46.64,81.73 46.64,80.41 45.92,79.7 45.92,76.08 47.21,74.8 47.21,66.9 47.93,66.19 47.93,55.55 48.14,55.34 48.14,49.07 44.69,45.63 44.69,43.18 40.82,39.31 40.82,28.39 41.15,28.06 41.15,24.66 38.08,21.59 31.21,21.59 31.08,21.46 31.08,21.18 v2(31.3,20.96)
  BOTTOM w0.076: UC1.E28 128.83,86.19 128.72,86.19 128.59,86.07 128.59,85.76 v2(128.72,85.63)
  BOTTOM w0.104: JNGFF3.29 31.35,17.32 31.2,17.47 31.2,19.61 31.06,19.75 31.06,20.72 v2(31.3,20.96)
PCIE_PRX_DTX_N12: length 186.9
  IN1 w0.119: v2(27.4,19.9) 27.4,20.56 27.66,20.82 28.51,20.82 28.83,20.51 37.6,20.51 41.65,24.55 41.65,28.18 41.24,28.59 41.24,39.13 45.11,43.01 45.11,45.45 48.58,48.92 48.58,56.25 48.92,56.59 48.92,56.97 48.36,57.52 48.36,66.89 47.63,67.62 47.63,75.91 46.35,77.19 46.35,79.52 47.06,80.24 47.06,81.55 47.56,82.05 47.56,82.19 47.56,82.2 47.56,85.53 47.84,85.81 47.84,92.13 48.82,93.11 49.64,93.11 53.98,97.45 53.98,98.32 55.22,99.57 69.43,99.57 69.59,99.73 89.59,99.73 89.78,99.92 101.88,99.92 102.07,99.72 104.9,99.72 105.15,99.97 118.84,99.97 123.9,94.91 124.33,94.91 126.29,92.95 126.29,86.91 127.08,86.13 v2(127.79,86.13)
  BOTTOM w0.076: v2(127.79,86.13) 127.99,86.13 UC1.E30
  BOTTOM w0.104: JNGFF3.43 27.85,17.32 27.98,17.46 27.98,18.87 27.55,19.3 27.55,19.74 v2(27.4,19.9)
PCIE_PRX_DTX_P1: length 214.3
  TOP w0.104: v2(290.45,52.16) 290.7,51.91 291.35,51.91 CR13.1
  IN3 w0.076: 138.34,86.02 138.33,86.01 138.33,85.97 138.29,85.94 138.29,85.76 138.29,84.86 138.17,84.73 138.04,84.73 v2(137.82,84.95)
  IN3 w0.135: v2(290.45,52.16) 290.28,51.99 287.76,51.99 287.23,51.46 286.99,51.46 286.58,51.05 284.59,51.05 283.58,52.07 281.7,52.07 281.43,51.79 281.43,46.19 280.86,45.61 280.86,33.56 279.39,32.09 279.39,31.68 278.87,31.16 278.29,31.16 277.03,29.9 275.81,29.9 275.71,29.8 267.83,29.8 266.94,30.69 265.19,30.69 264.88,30.39 264.18,30.39 263.88,30.69 260.82,30.69 259.43,29.29 258.74,29.29 258.08,28.63 258.07,28.63 257.68,28.24 253.61,28.24 253.33,27.96 249.32,27.96 249.07,28.21 249.07,28.75 247.5,30.32 245.37,30.32 245.01,29.96 242.35,29.96 240.81,31.5 240.61,31.5 238.86,31.5 238.72,31.64 238.72,32.25 235.96,35.01 232.1,35.01 231.88,34.79 206.86,34.79 206.67,34.79 206.66,34.79 201.3,40.16 201.15,40.16 194.08,47.23 194.08,47.44 189.11,52.42 189.11,53.67 183.63,59.15 183.63,60.55 182.22,61.97 182.22,63.27 178.16,67.33 178.16,67.34 178.16,69.11 174.42,72.84 173.72,72.84 172.15,74.41 172.15,74.42 171.82,74.75 171.82,77.25 172.54,77.96 172.54,80.62 170.69,82.47 170.69,84.13 169.58,85.24 168.11,85.24 167.24,86.11 161.37,86.11 160.56,85.29 153.55,85.29 152.04,86.8 149.04,86.8 148.83,86.59 142.48,86.59 141.95,86.06 140.85,86.06 140.17,86.74 139.06,86.74 138.34,86.02
  BOTTOM w0.076: v2(137.82,84.95) UC1.G13
PCIE_PRX_DTX_P3: length 231.9
  IN3 w0.076: 135.7,86.69 135.67,86.66 135.67,84.98 135.67,84.97 135.67,84.64 135.76,84.55 135.95,84.55 136.1,84.7 136.1,84.88 v2(136.08,84.9)
  IN3 w0.135: 135.7,86.69 135.86,86.85 135.86,86.99 136.81,87.94 136.81,93.69 138.51,95.39 142.06,95.39 142.71,94.74 144.68,94.74 146.34,93.08 149.47,93.08 149.88,93.49 150.53,93.49 151.39,94.35 151.39,94.89 152.02,95.53 152.51,95.53 152.69,95.71 161.51,95.71 161.76,95.46 165.34,95.46 166.98,93.82 170.69,93.82 172.59,91.92 172.59,91.14 176.52,87.21 178.75,87.21 181.59,84.37 181.59,73.36 182.08,72.87 182.08,71.43 182.79,70.73 182.79,69.88 182.46,69.56 182.46,68.52 186.1,64.88 186.1,64.07 187.78,62.4 187.78,61 190.51,58.27 190.75,58.27 198.25,50.77 198.25,49.5 204.55,43.2 205.62,43.2 207.51,41.31 210.99,41.31 211.07,41.39 220.31,41.39 221.33,40.37 229.03,40.37 229.52,40.87 239.23,40.87 239.82,40.29 241.58,40.29 243.49,42.19 244.9,42.19 254.36,51.65 256.09,51.65 258.02,53.58 259.55,53.58 260.1,54.13 261.05,54.13 263.08,56.16 263.08,57.37 263.64,57.93 269,57.93 270.47,59.4 272.56,59.4 273.75,60.59 286.72,60.59 287.84,59.47 289.67,59.47 290.68,58.45 291.44,58.45 v2(291.79,58.11)
  BOTTOM w0.076: UC1.G16 136.42,84.56 136.21,84.56 136.08,84.69 v2(136.08,84.9)
  BOTTOM w0.104: JNGFF1.41 289.42,45.3 289.72,45.6 291.49,45.6 292.43,46.54 292.43,49.03 293.09,49.69 293.09,51.41 292.37,52.13 292.37,55.51 291.2,56.68 291.2,58.13 291.33,58.26 291.63,58.26 v2(291.79,58.11)
PCIE_PRX_DTX_P4: length 217.6
  IN3 w0.135: v2(289.23,57.33) 289.23,57.4 289.1,57.52 288.78,57.52 286.75,59.55 276.7,59.55 275.72,58.57 275.01,58.57 274.87,58.7 274.19,58.7 273.9,58.41 272.58,58.41 271.99,57.83 270.37,57.83 269.79,57.24 265.15,57.24 261.34,53.44 260.42,53.44 259.23,52.25 258.75,52.25 257.23,50.73 255.2,50.73 253.85,49.38 253.05,49.38 245.17,41.5 243.77,41.5 243.54,41.27 243.54,39.87 243.04,39.36 239.46,39.36 238.64,40.19 229.82,40.19 228.82,39.19 212.66,39.19 211.33,40.52 206.73,40.52 206.11,41.14 206.11,41.63 205.57,42.17 204.61,42.17 197.55,49.23 197.55,50.5 190.47,57.59 190.22,57.59 187.01,60.8 187.01,61.79 185.4,63.4 185.4,64.59 181.75,68.25 181.75,70.04 180.31,71.48 180.31,77.42 180.84,77.96 180.84,81.93 171.91,90.86 171.91,91.64 170.81,92.74 166.19,92.74 164.29,94.63 161.5,94.63 161.1,95.03 153.09,95.03 150.05,91.99 148.13,91.99 147.81,92.31 143.54,92.31 142.51,93.35 142.51,93.98 141.8,94.68 139.4,94.68 137.49,92.77 137.49,87.92 137.42,87.85 137.42,87.4 136.85,86.83 136.85,86.45 137.42,85.88 137.42,85.5 137.29,85.38 137.04,85.38 136.91,85.51 v2(136.91,85.67)
  BOTTOM w0.076: UC1.F15 136.94,85.67 v2(136.91,85.67)
  BOTTOM w0.104: JNGFF1.65 289.27,51.3 289.43,51.47 289.64,51.47 289.88,51.71 289.88,55.24 288.68,56.44 288.68,57.28 288.87,57.47 289.07,57.47 289.09,57.49 289.23,57.34 v2(289.23,57.33)
PCIE_PRX_DTX_P5: length 141.3
  TOP w0.104: v2(26.29,97.05) 26.09,96.85 25.9,96.85 25.49,96.44 25.49,95.97 CT129.2
  IN1 w0.119: v2(136.1,86.22) 136.22,86.09 136.39,86.09 136.51,86.21 136.51,89.42 137.01,89.92 137.01,95.57 135.13,97.44 135.13,99.98 128.96,106.15 124.63,106.15 124.45,105.97 123.61,105.97 123.2,106.38 121.95,106.38 121.47,106.86 97.89,106.86 96.81,105.77 92.95,105.77 91.58,107.13 67.26,107.13 66.81,106.68 63.44,106.68 62.39,107.73 57.8,107.73 57.3,107.23 50.59,107.23 50.16,107.66 43.75,107.66 43.26,107.17 42.9,107.17 42.71,107.36 42.54,107.36 42.41,107.24 v2(42.41,107.12)
  IN3 w0.135: v2(26.29,97.05) 26.34,96.99 26.34,96.75 26.23,96.63 26.12,96.63 26.1,96.62 25.92,96.62 25.79,96.75 25.79,97.37 26.13,97.72 26.32,97.72 26.45,97.59 26.66,97.59 26.79,97.72 27.27,97.72 29.65,100.1 29.65,102.56 31.73,104.64 32.34,104.64 35.4,107.71 39.37,107.71 39.7,108.04 41.41,108.04 41.55,107.9 41.55,107.25 41.67,107.12 41.85,107.12 41.97,107.24 41.97,107.37 42.08,107.49 42.26,107.49 42.43,107.32 42.43,107.13 v2(42.41,107.12)
  BOTTOM w0.076: v2(136.1,86.22) 136.08,86.2 136.08,86.04 136.22,85.89 UC1.E16
PCIE_PRX_DTX_P6: length 131.8
  TOP w0.104: CT127.2 27.28,96.44 27.5,96.66 28.45,96.66 29.2,97.4 31.06,97.4 31.11,97.35 32.37,97.35 32.64,97.08 32.64,96.89 v2(32.8,96.72)
  IN1 w0.119: v2(40.48,101.76) 40.48,101.86 40.6,101.98 40.64,101.98 40.77,102.11 40.94,102.11 41.81,101.24 43.3,101.24 44.21,102.15 45.1,102.15 47.29,104.34 50.38,104.34 50.66,104.63 53.68,104.63 54.22,104.09 57.8,104.09 58.03,103.86 62.35,103.86 62.92,103.29 91.58,103.29 91.83,103.04 97.84,103.04 98.56,103.77 99.98,103.77 100.24,103.51 106.21,103.51 106.41,103.71 120.98,103.71 122.82,101.87 128.35,101.87 129.73,100.48 129.73,97.89 133.18,94.44 133.18,90.05 134.71,88.52 134.95,88.52 135.73,87.74 135.73,86.86 135.45,86.58 135.45,86.4 135.45,85.79 135.38,85.73 135.38,85.59 135.26,85.47 135.09,85.47 v2(135.07,85.5)
  IN3 w0.135: v2(32.8,96.72) 32.75,96.68 32.56,96.68 32.36,96.88 32.36,97.18 33.6,98.42 33.6,99.58 36.15,102.13 39.37,102.13 39.51,101.99 39.51,101.79 39.63,101.67 39.82,101.67 39.92,101.77 39.92,101.97 40.06,102.1 40.18,102.1 40.31,101.97 40.4,101.97 40.48,101.89 v2(40.48,101.76)
  BOTTOM w0.076: UC1.F18 135.51,85.24 135.25,85.5 v2(135.07,85.5)
PCIE_PRX_DTX_P7: length 124.6
  TOP w0.104: CT8.2 29.99,95.24 29.99,95.49 v2(30.16,95.66)
  IN1 w0.119: v2(40.52,99.55) 40.74,99.33 41.53,99.33 41.9,99.7 43.88,99.7 44.45,100.27 45,100.27 47.99,103.27 52.08,103.27 52.94,102.4 59.67,102.4 59.87,102.2 60.74,102.2 61.31,102.77 61.92,102.77 62.48,102.21 91.09,102.21 91.36,101.94 99.24,101.94 99.74,102.44 106.8,102.44 107.01,102.64 119.78,102.64 123.39,99.04 123.39,98.16 124.63,96.91 126.87,96.91 129.8,93.98 129.8,93.64 132.35,91.09 132.35,88.93 132.71,88.58 133.51,88.58 134.64,87.44 134.64,86.15 134.76,86.02 134.83,86.01 v2(135.03,86.17)
  IN3 w0.135: v2(40.52,99.55) 40.24,99.27 40.07,99.27 39.42,99.92 35.57,99.92 34.75,99.1 34.75,98.12 34.98,97.89 34.98,96.14 33.17,94.33 30.95,94.33 29.98,95.29 29.98,95.48 v2(30.16,95.66)
  BOTTOM w0.076: UC1.E20 134.76,85.89 v2(135.03,86.17)
PCIE_PRX_DTX_P8: length 130.9
  TOP w0.104: CT6.2 32.08,94.18 32.08,94.4 31.55,94.93 31.55,95.58 31.8,95.83 32.07,95.83 v2(32.22,95.98)
  IN1 w0.119: v2(133.28,85.56) 133.19,85.47 133.02,85.47 132.9,85.59 132.9,86.41 132.51,86.8 131.72,86.8 131.54,86.98 131.54,87.3 131.42,87.42 131.11,87.42 128.72,89.8 128.72,94.08 126.56,96.24 124.39,96.24 118.65,101.98 118.43,101.98 118.43,101.99 117.92,101.99 117.92,101.98 117.67,101.98 117.66,101.99 117.16,101.99 117.16,101.98 117.08,101.98 117.08,101.99 116.58,101.99 116.57,101.98 116.42,101.98 116.42,101.99 115.92,101.99 115.92,101.98 115.84,101.98 115.84,101.99 115.33,101.99 115.33,101.98 114.91,101.98 114.91,101.99 114.4,101.99 114.4,101.98 114.34,101.98 114.34,101.99 113.83,101.99 113.83,101.98 113.69,101.98 113.69,101.99 113.19,101.99 113.19,101.98 113.11,101.98 113.11,101.99 112.6,101.99 112.6,101.98 107.25,101.98 106.99,101.72 103.38,101.72 102.87,101.21 91.16,101.21 90.83,101.55 90.65,101.55 69,101.55 68.33,100.88 64.58,100.88 63.94,101.52 62.77,101.52 62.62,101.38 53,101.38 51.76,102.62 48.7,102.62 44.78,98.7 42.07,98.7 41.36,97.99 40.96,97.99 40.73,98.22 v2(40.73,98.23)
  IN3 w0.135: v2(32.22,95.98) 32.22,95.85 32.1,95.73 31.83,95.73 31.6,95.95 31.6,97.4 32.9,98.69 32.9,99.85 35.86,102.82 40.79,102.82 41.33,102.28 41.33,101.54 41.19,101.41 41.09,101.41 40.96,101.27 40.96,101 41.09,100.87 41.19,100.87 41.33,100.73 41.33,100.5 41.2,100.37 40.86,100.37 40.72,100.23 40.72,99.96 40.86,99.83 41.2,99.83 41.33,99.7 41.33,98.27 41.09,98.03 40.86,98.03 40.73,98.16 v2(40.73,98.23)
  BOTTOM w0.076: v2(133.28,85.56) 133.31,85.59 133.49,85.59 133.71,85.37 UC1.F21
PCIE_PRX_DTX_P9: length 229.8
  TOP w0.104: CL1.1 268.12,96.83 265.68,94.38 265.68,65.24 v4(265.18,64.74) 264.59,64.15 264.59,60.57 266.27,58.88 v2(268.17,58.88)
  IN3 w0.135: v2(268.17,58.88) 263.57,58.88 262.26,57.56 262.26,56.36 261.18,55.28 259.73,55.28 258.72,54.26 257.39,54.26 255.46,52.33 254.08,52.33 244.72,42.98 243.29,42.98 241.86,41.55 228.49,41.55 228.25,41.31 221.53,41.31 220.1,42.73 207.37,42.73 191.15,58.95 190.79,58.95 188.88,60.86 188.88,62.5 186.79,64.59 186.79,65.19 184.93,67.05 184.93,67.69 183.81,68.81 183.81,70.27 183.47,70.61 183.47,71.02 182.84,71.65 182.84,84.25 175.55,91.53 174.12,91.53 170.59,95.07 167.64,95.07 166.56,96.15 162.29,96.15 162,96.44 152.44,96.44 152.25,96.25 151.72,96.25 151.16,95.69 150.48,95.69 149.96,96.21 145.77,96.21 145.12,95.56 142.86,95.56 141.81,96.6 140.64,96.6 140.11,96.07 138.2,96.07 136.13,94 136.13,88.55 134.12,86.54 133.13,86.54 132.91,86.31 132.91,86.12 132.69,85.9 132.65,85.9 132.29,85.54 v2(132.29,85.51)
  BOTTOM w0.102: UC1.E23 131.91,85.89 v2(132.29,85.51)
PCIE_PRX_DTX_P11: length 186.7
  IN1 w0.119: v2(129.11,86.51) 128.92,86.51 128.53,86.9 128.53,87.28 127.32,88.49 127.32,94.54 126.28,95.58 124.14,95.58 119.1,100.62 107.29,100.62 106.84,101.07 103.64,101.07 103.13,100.56 89.43,100.56 89.26,100.39 69.13,100.39 68.97,100.23 54.54,100.23 53.26,98.95 53.26,97.65 49.54,93.94 48.51,93.94 46.96,92.39 46.96,88.05 46.65,87.74 46.65,84.64 46.91,84.38 46.91,82.31 46.42,81.82 46.42,80.51 45.71,79.79 45.71,75.99 46.99,74.71 46.99,66.81 47.71,66.1 47.71,55.46 47.92,55.25 47.92,49.16 44.47,45.72 44.47,43.27 40.6,39.4 40.6,28.3 40.93,27.96 40.93,24.75 37.99,21.8 31.12,21.8 30.86,21.55 30.86,21.11 v2(30.72,20.96)
  BOTTOM w0.076: v2(129.11,86.51) 129.31,86.51 129.93,85.89 UC1.E27
  BOTTOM w0.104: JNGFF3.31 30.85,17.32 31,17.47 31,19.53 30.86,19.66 30.86,20.81 v2(30.72,20.96)
PCIE_PRX_DTX_P12: length 187
  IN1 w0.119: v2(27.98,19.9) 27.61,20.26 27.61,20.47 27.75,20.61 28.42,20.61 28.74,20.29 37.69,20.29 41.87,24.46 41.87,28.27 41.46,28.68 41.46,39.04 45.33,42.92 45.33,45.36 48.8,48.83 48.8,56.16 49.14,56.5 49.14,57.06 48.58,57.61 48.58,66.98 47.85,67.71 47.85,76 46.57,77.28 46.57,79.43 47.28,80.15 47.28,81.46 47.78,81.96 47.78,82.1 47.78,82.11 47.78,85.44 48.06,85.72 48.06,92.04 48.91,92.89 49.73,92.89 54.19,97.36 54.19,98.23 55.31,99.35 69.52,99.35 69.68,99.51 89.68,99.51 89.87,99.7 101.79,99.7 101.98,99.51 104.99,99.51 105.24,99.75 118.75,99.75 123.81,94.69 124.24,94.69 126.07,92.86 126.07,86.82 126.98,85.91 127.46,85.91 127.81,85.56 v2(127.84,85.56)
  BOTTOM w0.076: UC1.F30 128.22,85.36 128.03,85.56 v2(127.84,85.56)
  BOTTOM w0.104: JNGFF3.41 28.35,17.32 28.19,17.49 28.19,18.95 27.75,19.39 27.75,19.67 v2(27.98,19.9)
PCIE_PTX_C_DRX_N1: length 4.2
  TOP w0.104: UR1.4 295.37,52.15 295.29,52.23 295.06,52.23 294.96,52.33 v4(294.69,52.33) 294.69,52.33 294.52,52.33 294.52,52.33 293.67,52.33 293.29,52.7 293.29,53.24 293.17,53.36 292.87,53.36 CR12.2
PCIE_PTX_C_DRX_N3: length 2.9
  BOTTOM w0.104: CZ13.2 290.85,44.17 290.34,44.15 289.57,44.15 289.42,44.3 JNGFF1.37
PCIE_PTX_C_DRX_N4: length 2
  BOTTOM w0.104: CZ15.2 289.8,50.15 289.57,50.15 289.42,50.3 JNGFF1.61
PCIE_PTX_C_DRX_N5: length 2.8
  TOP w0.076: 27.08,92.53 27.17,92.43 27.17,91.88 27.32,91.74 27.32,91.31 UT1.H22
  TOP w0.104: 27.08,92.53 26.65,92.96 26.65,93.24 CT126.2
PCIE_PTX_C_DRX_N6: length 2.7
  TOP w0.076: 28.75,92.78 28.75,92.61 29.03,92.33 29.03,91.87 29.16,91.74 29.16,91.31 UT1.M22
  TOP w0.104: 28.75,92.78 28.75,93.24 CT124.2
PCIE_PTX_C_DRX_N7: length 2.6
  TOP w0.076: UT1.T22 31,91.31 31,92.38 31.03,92.41
  TOP w0.104: 31.03,92.41 31.16,92.54 31.16,93.24 CT5.2
PCIE_PTX_C_DRX_N8: length 2.8
  TOP w0.076: UT1.Y22 32.61,91.14 32.84,91.37 32.84,91.72 33.44,92.31 33.44,92.77 33.45,92.78
  TOP w0.104: 33.45,92.78 33.45,93.24 CT3.2
PCIE_PTX_C_DRX_N9: length 2.3
  TOP w0.104: CL6.2 270.64,94.44 270.86,94.44 271.13,94.72 271.62,94.72 271.72,94.62 UL1.42
PCIE_PTX_C_DRX_N11: length 3
  BOTTOM w0.104: JNGFF3.35 29.85,17.32 29.64,17.53 29.64,18.95 CN69.1
PCIE_PTX_C_DRX_N12: length 3.3
  BOTTOM w0.104: CN71.1 26.04,18.95 26.04,18.37 26.69,17.71 26.69,17.4 26.85,17.24 JNGFF3.47
PCIE_PTX_C_DRX_P1: length 4.2
  TOP w0.102: 295.15,52.46 295.1,52.52
  TOP w0.104: 295.1,52.52 295.08,52.53 294.44,52.53 294.44,52.53 293.75,52.53 293.5,52.78 v4(293.5,53) 293.5,53.32 293.26,53.56 292.94,53.56 CR11.2 ; 295.15,52.46 295.27,52.46 295.35,52.55 UR1.3
PCIE_PTX_C_DRX_P3: length 2.9
  BOTTOM w0.104: CZ12.2 290.86,43.96 290.86,43.96 290.35,43.95 289.57,43.95 289.42,43.8 JNGFF1.35
PCIE_PTX_C_DRX_P4: length 1.9
  BOTTOM w0.104: CZ14.2 290,49.95 289.57,49.95 289.42,49.8 JNGFF1.59
PCIE_PTX_C_DRX_P5: length 2.8
  TOP w0.076: UT1.H23 27.09,91.38 27.04,91.33 26.95,91.33 26.86,91.42 26.86,91.72 27,91.86 27,92.27 26.91,92.37
  TOP w0.104: 26.91,92.37 26.45,92.83 26.45,93.25 CT125.2
PCIE_PTX_C_DRX_P6: length 2.6
  TOP w0.076: UT1.M23 28.93,91.43 28.88,91.38 28.79,91.38 28.7,91.46 28.7,91.72 28.86,91.87 28.86,92.26 28.55,92.57 28.55,92.78
  TOP w0.104: CT123.2 28.55,93.24 28.55,92.78
PCIE_PTX_C_DRX_P7: length 2.6
  TOP w0.076: UT1.T23 30.77,91.43 30.72,91.38 30.63,91.38 30.54,91.46 30.54,91.72 30.81,91.98 30.82,92 30.82,92.49 30.89,92.55
  TOP w0.104: 30.89,92.55 30.96,92.62 30.96,93.24 CT4.2
PCIE_PTX_C_DRX_P8: length 2.8
  TOP w0.076: 33.25,92.78 33.26,92.76 33.26,92.39 32.74,91.86 32.51,91.86 32.38,91.73 32.38,91.52 32.46,91.44 32.56,91.44 32.61,91.5 UT1.Y23
  TOP w0.104: 33.25,92.78 33.25,93.24 CT2.2
PCIE_PTX_C_DRX_P9: length 2.3
  TOP w0.104: UL1.41 271.68,95.02 271.58,94.92 271.05,94.92 270.77,94.65 270.64,94.65 CL5.2
PCIE_PTX_C_DRX_P11: length 3
  BOTTOM w0.104: JNGFF3.37 29.35,17.32 29.44,17.41 29.44,18.83 CN70.1
PCIE_PTX_C_DRX_P12: length 3.3
  BOTTOM w0.104: JNGFF3.49 26.35,17.25 26.49,17.39 26.49,17.63 25.84,18.29 25.84,18.88 CN72.1
PCIE_PTX_DRX_N1: length 224.5
  TOP w0.104: CR12.1 291.26,53.43 290.61,53.43 289.78,52.61 286.83,52.61 v2(286.55,52.33)
  IN3 w0.135: v2(138.97,92.73) 139.17,92.93 139.36,92.93 139.66,92.62 139.66,90.96 140.76,89.86 140.95,89.86 142.6,88.21 148.08,88.21 148.62,87.67 149.95,87.67 154.57,92.29 156.9,92.29 161.2,88 166.03,88 166.84,87.19 168.81,87.19 171.66,84.34 171.66,82.19 173.04,80.8 173.04,77.84 172.26,77.06 172.26,74.93 173.88,73.31 174.58,73.31 178.6,69.29 178.6,67.5 182.65,63.45 182.65,62.15 184.18,60.62 184.18,59.74 188.01,55.91 188.01,55.49 194.52,48.98 194.52,47.41 201.25,40.68 201.4,40.68 206.83,35.25 231.67,35.25 231.95,35.53 236.93,35.53 238.16,34.3 238.16,33.87 239.71,32.33 240.82,32.33 242.49,30.66 244.58,30.66 246.44,32.52 247.56,32.52 248.58,31.51 250,31.51 250.1,31.51 251.91,29.69 252.79,29.69 253.22,29.26 253.85,29.26 254.04,29.07 257.9,29.07 258.8,29.98 258.8,30.52 258.94,30.66 259.81,30.66 260.37,31.23 263.85,31.23 264.05,31.43 264.95,31.43 264.95,31.43 265.05,31.43 265.23,31.25 267.64,31.25 268.16,30.73 271.28,30.73 271.77,30.24 275.12,30.24 277.05,32.17 278.81,32.17 280.42,33.78 280.42,45.98 280.99,46.56 280.99,52.17 281.32,52.51 284.52,52.51 284.81,52.21 285.8,52.21 286.08,52.5 286.39,52.5 v2(286.55,52.33)
  BOTTOM w0.076: UC1.B17 135.93,87.96 136.17,88.21 136.18,88.21 136.41,88.44 136.41,89 136.69,89.27 136.69,90.25 137.48,91.04 137.48,91.34 138.13,91.99 138.13,92.73 138.38,92.98 138.8,92.98 138.97,92.8 v2(138.97,92.73)
PCIE_PTX_DRX_N3: length 225
  IN3 w0.135: v2(291.67,57.01) 291.72,57.01 291.88,57.17 291.88,57.33 291.78,57.44 290.71,57.44 289.9,56.63 288.65,56.63 286.41,58.87 277.15,58.87 276.02,57.73 275.37,57.73 274.14,56.51 265.38,56.51 259.58,50.7 258.16,50.7 257.5,50.04 255.69,50.04 254.34,48.7 253.33,48.7 243.23,38.59 239.2,38.59 238.29,39.51 230.29,39.51 229.3,38.51 212.37,38.51 211.26,39.63 206.66,39.63 205.55,40.73 204.35,40.73 203.94,41.14 203.94,41.86 196.85,48.95 196.85,50.24 191.29,55.8 190.59,55.8 190.05,56.33 190.05,56.79 186.26,60.58 186.26,61.44 184.72,62.98 184.72,64.3 181.07,67.95 181.07,69.74 179.62,71.19 179.62,78.34 180.09,78.81 180.09,81.12 169.15,92.06 164.49,92.06 163.03,93.52 158.96,93.52 158.14,94.33 153.36,94.33 150.33,91.31 147.82,91.31 147.5,91.63 143.16,91.63 141.82,92.98 141.82,93.7 141.52,94 141.29,94 v2(140.93,93.65)
  BOTTOM w0.076: v2(140.93,93.65) 140.7,93.88 138.57,93.88 137.61,92.92 137.61,92.15 137.09,91.63 137.09,91.18 136.34,90.43 136.34,89.46 135.64,88.77 135.64,88.51 135.68,88.44 135.68,88.16 135.64,88.05 135.64,87.88 135.66,87.82 135.69,87.71 135.77,87.64 136,87.64 136.2,87.43 136.2,87.14 135.91,86.85 UC1.D17
  BOTTOM w0.104: CZ13.1 292.11,44.39 292.67,43.84 292.96,43.84 293.23,44.11 293.23,46.59 293.5,46.86 293.5,51.6 292.89,52.22 292.89,55.57 291.98,56.48 291.98,56.81 291.78,57.01 v2(291.67,57.01)
PCIE_PTX_DRX_N4: length 221.6
  IN3 w0.135: v2(288.37,61.32) 288.37,61.13 288.49,61 288.67,61 288.8,61.13 288.8,61.96 288.56,62.2 287.68,62.2 287.16,61.67 273.19,61.67 272.05,60.54 268.72,60.54 268.1,59.92 267.66,59.92 267.3,59.56 262.29,59.56 259.76,57.03 259.76,56.57 258.55,55.35 256.99,55.35 256.12,54.48 255.26,54.48 244.58,43.8 243.04,43.8 241.48,42.23 227.95,42.23 227.74,42.02 221.83,42.02 220.26,43.59 207.61,43.59 189.58,61.62 189.58,63.02 187.48,65.12 187.48,65.46 186.3,66.65 186.3,67.3 184.54,69.06 184.54,70.59 184.19,70.94 184.19,71.27 183.53,71.93 183.53,84.53 175.55,92.5 175.47,92.5 172.94,95.04 171.95,95.04 170.9,96.09 170.25,96.09 169.36,96.98 167.07,96.98 166.92,96.83 163.76,96.83 163.13,97.46 162.14,97.46 161.85,97.18 154.6,97.18 154.05,97.73 150.84,97.73 150.02,96.91 148.74,96.91 147.46,98.2 145.78,98.2 144.89,97.31 143.14,97.31 142.74,97.7 140.66,97.7 139.7,96.75 137.71,96.75 134.15,93.19 134.15,90.85 134.36,90.64 134.57,90.64 134.79,90.85 v2(134.79,91.06)
  BOTTOM w0.076: v2(134.79,91.06) 134.56,90.83 134.43,90.83 134.19,90.59 134.19,88.53 134.56,88.17 UC1.B19
  BOTTOM w0.104: v2(288.37,61.32) 288.58,61.32 288.83,61.07 288.83,60.08 289.75,59.15 289.75,55.99 290.95,54.8 290.95,51.54 291.67,50.82 291.67,50.39 291.55,50.26 291.48,50.26 CZ15.1
PCIE_PTX_DRX_N5: length 137.6
  TOP w0.104: CT126.1 26.65,94.2 26.65,94.55 26.82,94.72 v2(26.94,94.72)
  IN1 w0.119: v2(135.4,90.46) 135.4,90.37 135.53,90.24 135.58,90.24 135.73,90.09 136.18,90.09 136.27,90.09 136.36,90.18 136.36,90.54 136.1,90.8 136.1,91.07 136.36,91.33 136.36,95.3 134.49,97.18 134.49,99.71 128.71,105.48 124.9,105.48 124.51,105.08 122.34,105.08 121.21,106.21 98.16,106.21 97.06,105.11 92.65,105.11 91.35,106.41 67.65,106.41 67.27,106.02 62.99,106.02 62.03,106.98 58.09,106.98 57.7,106.58 50.28,106.58 49.95,106.91 44.13,106.91 43.81,106.59 v2(43.81,106.58)
  IN3 w0.135: v2(26.94,94.72) 26.81,94.72 26.68,94.86 26.68,94.89 26.52,95.04 26.52,95.33 28.89,97.7 28.89,98.37 30.35,99.82 30.35,102.29 31.88,103.82 32.55,103.82 35.28,106.54 36.92,106.54 37.15,106.77 41.01,106.77 41.39,106.39 42.72,106.39 43.22,106.9 43.49,106.9 43.64,106.74 43.65,106.74 v2(43.81,106.58)
  BOTTOM w0.076: UC1.C19 134.42,87.31 134.33,87.4 134.33,87.51 134.43,87.61 134.62,87.61 134.77,87.71 134.82,87.88 134.82,88.05 134.77,88.24 134.77,88.39 134.83,88.52 134.83,88.86 134.67,89.03 134.67,89.71 135.4,90.44 v2(135.4,90.46)
PCIE_PTX_DRX_N6: length 135.3
  TOP w0.104: v2(28.92,94.64) 28.88,94.64 28.69,94.45 28.69,94.27 28.69,94.27 28.69,94.21 28.89,94.01 CT124.1
  IN1 w0.119: v2(41.11,105.48) 41.11,105.55 41.43,105.87 41.71,105.87 42.21,105.38 44.07,105.38 44.37,105.68 48.34,105.68 48.9,106.24 49.7,106.24 50.02,105.92 54.27,105.92 54.81,105.38 57.56,105.38 58.48,106.3 61.73,106.3 63.42,104.61 69.5,104.61 70.08,105.19 91.6,105.19 92.33,104.46 97.31,104.46 98.41,105.55 105.99,105.55 106.54,105 121.51,105 122.09,104.42 124.76,104.42 125.13,104.79 128.43,104.79 131.99,101.23 131.99,98.96 133.84,97.11 133.84,96.5 135.72,94.62 135.72,93.2 135.6,93.09 135.39,93.09 135.27,92.97 135.27,92.73 135.39,92.61 135.6,92.61 135.72,92.49 135.72,91.71 135.56,91.55 135.44,91.55 135.31,91.68 v2(135.31,91.76)
  IN3 w0.135: v2(41.11,105.48) 41.09,105.48 40.82,105.75 40.25,105.75 39.97,106.03 38.09,106.03 37.62,105.56 35.41,105.56 31.08,101.23 31.08,98.93 28.59,96.44 28.59,94.97 v2(28.92,94.64)
  BOTTOM w0.076: v2(135.31,91.76) 135.17,91.61 135.13,91.58 135.02,91.58 135.01,91.59 134.57,91.59 134.56,91.58 134.42,91.58 133.86,91.02 133.86,90.74 133.85,90.73 133.85,88.39 133.86,88.39 133.86,88.16 133.82,88.12 133.82,87.9 133.72,87.8 133.7,87.69 133.73,87.55 134.01,87.03 UC1.D20
PCIE_PTX_DRX_N7: length 131.1
  TOP w0.104: CT5.1 31.17,94.19 31.17,94.58 31.07,94.68 31.07,95.62 30.24,96.45 30.24,96.6 v2(30.41,96.78)
  IN1 w0.119: v2(134.6,91.96) 134.55,92.01 134.07,92.01 133.82,92.26 133.82,95.56 133.18,96.21 133.18,96.86 131.32,98.71 131.32,100.98 128.17,104.14 125.44,104.14 125.07,103.76 121.84,103.76 121.25,104.35 106.14,104.35 105.93,104.15 100.7,104.15 100.41,104.44 98.26,104.44 97.62,103.8 92.07,103.8 91.35,104.52 70.38,104.52 69.81,103.95 63.17,103.95 62.59,104.53 58.41,104.53 58.2,104.74 54.49,104.74 53.95,105.28 50.15,105.28 49.88,105.01 46.04,105.01 43.14,102.11 41.85,102.11 40.34,103.62 40.34,103.91 v2(40.18,104.07)
  IN3 w0.135: v2(40.18,104.07) 40.28,104.17 40.28,104.17 40.29,104.19 40.29,104.46 40.1,104.66 39.78,104.66 39.65,104.52 39.65,104.22 39.51,104.09 39.24,104.09 39.11,104.22 39.11,104.52 38.97,104.66 36.68,104.66 32.13,100.1 32.13,99.01 30.26,97.14 30.26,96.93 v2(30.41,96.78)
  BOTTOM w0.076: UC1.B21 133.43,88.19 133.61,88.37 133.61,88.39 133.68,88.46 133.68,88.62 133.69,88.63 133.69,91.78 133.87,91.96 v2(134.6,91.96)
PCIE_PTX_DRX_N8: length 122.9
  TOP w0.104: CT3.1 33.43,94.21 33.43,94.91 33.23,95.12 33.23,95.45 v2(33.42,95.64)
  IN1 w0.119: v2(132.57,91.6) 132.57,91.61 132.17,92 132.11,92 131.87,92.24 131.87,94.5 128.98,97.39 128.98,100.19 127.98,101.19 122.59,101.19 120.71,103.07 106.71,103.07 106.51,102.87 99.55,102.87 99.06,102.38 91.55,102.38 91.29,102.64 62.66,102.64 62.1,103.2 59.58,103.2 59.21,102.83 53.81,102.83 52.66,103.98 51.11,103.98 50.83,103.7 47.58,103.7 45.38,101.5 44.49,101.5 43.13,100.13 41.72,100.13 41.11,100.75 40.67,100.75 v2(40.54,100.61)
  IN3 w0.135: v2(33.42,95.64) 33.37,95.64 33.22,95.8 33.22,95.95 33.52,96.25 34.01,96.25 34.54,96.78 34.54,97.71 34.3,97.95 34.3,99.29 35.81,100.8 39.39,100.8 39.69,100.5 39.87,100.5 40.16,100.8 40.34,100.8 v2(40.54,100.61)
  BOTTOM w0.076: UC1.D21 133.16,87.17 133.14,87.26 133.06,87.65 133,87.85 133,88.1 133.03,88.19 133.03,88.38 133,88.48 133,88.89 133.19,89.08 133.19,91.8 133.01,91.98 132.83,91.98 132.57,91.72 v2(132.57,91.6)
PCIE_PTX_DRX_N9: length 222.3
  TOP w0.104: CL6.1 268.69,94.79 267.86,94.79 266.65,93.58 266.65,64.46 265.53,63.35 265.53,62.64 v2(265.78,62.39)
  IN3 w0.135: v2(131.73,90.77) 131.34,90.38 131.19,90.38 131.06,90.51 131.06,92.99 137.35,99.29 139.35,99.29 140.51,100.44 144.58,100.44 145.08,100.94 148.04,100.94 148.38,100.61 157.85,100.61 158.63,99.83 167.66,99.83 170.5,97 172.23,97 174.59,94.64 174.59,94.35 175.77,93.17 175.86,93.17 185.6,83.43 185.6,73.34 186.84,72.11 186.84,71.68 186.67,71.52 186.67,69.82 188.39,68.11 188.39,67.47 189.55,66.31 189.55,64.07 192.72,60.9 192.72,59.5 207.15,45.02 221.5,45.02 222.55,43.97 225.88,43.97 226.96,45.05 229.76,45.05 230.54,44.27 241.37,44.27 242.79,45.69 243.58,45.69 256.27,58.38 257.23,58.38 260.46,61.6 264.99,61.6 v2(265.78,62.39)
  BOTTOM w0.076: v2(131.73,90.77) 131.57,90.62 131.36,90.62 131.13,90.39 131.13,89.76 131.59,89.3 131.59,88.35 131.85,88.08 131.96,88.08 UC1.B23
PCIE_PTX_DRX_N11: length 206.6
  IN1 w0.119: v2(45.13,90.76) 45.21,90.68 45.87,90.68 46.51,90.04 46.51,88.28 46.2,87.97 46.2,85.77 46,85.56 46,80.68 45.28,79.97 45.28,78.26 45.11,78.09 45.11,75.67 44.4,74.95 44.4,70.65 44.98,70.06 44.98,69.83 45.4,69.42 45.4,67.6 47.21,65.79 47.21,65.61 47.21,55.12 47.37,54.96 47.37,49.22 44.05,45.89 44.05,43.45 40.17,39.58 40.17,28.02 40.48,27.71 40.48,24.89 37.82,22.23 30.16,22.23 29.73,21.8 v2(29.73,21.02)
  IN3 w0.135: v2(45.13,90.76) 45.94,90.76 46.37,91.19 46.94,91.77 46.94,92.69 48.11,93.86 48.11,102.93 51.05,105.86 52.74,105.86 55.63,108.74 60.97,108.74 61.9,109.67 68.54,109.67 69.47,108.74 91.69,108.74 93.9,110.95 100.54,110.95 102.27,109.22 109.6,109.22 109.87,109.5 121.27,109.5 121.34,109.57 122.9,109.57 128.37,104.1 v2(128.37,103.36)
  BOTTOM w0.076: 129.45,98.51 129.45,98.49 129.44,98.47 129.44,96.05 128.89,95.5 128.89,92.66 130.6,90.95 130.6,89.84 131.41,89.03 131.41,88.25 131.81,87.85 131.81,87.52 131.76,87.47 131.76,87.24 UC1.D24
  BOTTOM w0.104: v2(29.73,21.02) 29.57,20.86 29.57,20.51 CN69.2 ; v2(128.37,103.36) 128.21,103.2 128.21,102.77 128.49,102.49 128.53,102.49 128.94,102.08 128.94,102.04 129.45,101.53 129.45,98.51
PCIE_PTX_DRX_N12: length 202.7
  IN1 w0.119: v2(45.11,89.54) 45.17,89.49 45.61,89.49 45.87,89.23 45.87,88.57 45.48,88.18 45.16,88.18 44.83,87.85 44.83,87.33 45.35,86.82 45.35,80.94 44.64,80.23 44.64,78.52 43.75,77.64 43.75,70.38 44.34,69.8 44.34,69.57 44.76,69.15 44.76,66.98 46.47,65.26 46.47,58.24 45.76,57.53 45.76,54.54 46.47,53.84 46.47,49.23 43.4,46.16 43.4,46.05 38.58,41.23 36.43,41.23 35.38,40.18 33.79,40.18 31.79,38.18 30.85,38.18 28.16,35.5 28.16,32.81 26.07,30.72 26.07,22.35 26.21,22.2 v2(26.21,21.1)
  IN3 w0.135: v2(45.11,89.54) 45.68,89.54 47.05,90.91 47.69,91.55 47.69,92.34 49.05,93.69 49.05,102.74 51.48,105.17 53.14,105.17 54.95,106.97 56.43,106.97 57.42,107.97 61.3,107.97 61.67,108.35 68.55,108.35 68.93,107.97 91.88,107.97 93.97,110.06 100.41,110.06 101.93,108.54 106.2,108.54 106.59,108.15 109.59,108.15 110.25,108.82 121.07,108.82 123.8,106.09 125.03,106.09 126.87,104.24 v2(126.87,103.37)
  BOTTOM w0.076: 128.78,98.51 128.78,98.49 128.77,98.47 128.77,96.05 128.38,95.66 128.38,92.56 129.25,91.7 129.25,89.84 129.36,89.72 129.47,89.72 129.56,89.63 129.56,89.52 129.64,89.43 129.77,89.43 129.85,89.35 129.85,89.23 129.94,89.14 130.08,89.14 130.18,89.04 130.18,88.9 130.31,88.77 130.46,88.77 130.8,88.43 130.89,88.43 130.95,88.49 UC1.A25
  BOTTOM w0.104: v2(26.21,21.1) 25.99,20.87 25.99,20.53 CN71.2 ; v2(126.87,103.37) 126.87,102.45 127.12,102.2 127.8,102.2 128.78,101.22 128.78,98.51
PCIE_PTX_DRX_P1: length 224.5
  TOP w0.104: CR11.1 291.34,53.64 290.52,53.64 289.7,52.81 286.66,52.81 v2(286.55,52.91)
  IN3 w0.135: v2(138.97,93.42) 139.18,93.21 139.41,93.21 139.91,92.72 139.91,91.06 140.86,90.1 141.05,90.1 142.7,88.45 148.18,88.45 148.72,87.91 149.85,87.91 154.47,92.53 157.01,92.53 161.3,88.24 166.13,88.24 166.94,87.43 168.91,87.43 171.9,84.44 171.9,82.29 173.28,80.9 173.28,77.74 172.5,76.96 172.5,75.03 173.98,73.55 174.68,73.55 178.84,69.39 178.84,67.6 182.9,63.55 182.9,62.25 184.43,60.72 184.43,59.84 188.25,56.01 188.25,55.59 194.76,49.08 194.76,47.51 201.35,40.93 201.5,40.93 206.93,35.49 231.57,35.49 231.85,35.78 237.03,35.78 238.4,34.4 238.4,33.97 239.81,32.57 240.92,32.57 242.59,30.9 244.48,30.9 246.34,32.76 247.66,32.76 248.68,31.75 249.9,31.75 250.2,31.75 252.01,29.94 252.89,29.94 253.32,29.5 253.95,29.5 254.14,29.31 257.8,29.31 258.56,30.08 258.56,30.62 258.84,30.91 259.71,30.91 260.27,31.47 263.75,31.47 263.95,31.67 264.15,31.67 265.15,31.67 265.33,31.49 267.74,31.49 268.26,30.97 271.38,30.97 271.87,30.49 275.02,30.49 276.95,32.41 278.71,32.41 280.18,33.88 280.18,46.08 280.75,46.66 280.75,52.27 281.22,52.75 284.62,52.75 284.91,52.46 285.7,52.46 285.98,52.74 286.38,52.74 v2(286.55,52.91)
  BOTTOM w0.076: v2(138.97,93.42) 138.97,93.37 138.75,93.15 138.31,93.15 137.96,92.8 137.96,92.09 v4(137.63,91.77) 137.31,91.45 137.31,91.11 136.51,90.31 136.51,89.35 136.25,89.09 136.25,88.51 136.11,88.37 136.02,88.37 135.91,88.49 UC1.A17
PCIE_PTX_DRX_P3: length 225
  IN3 w0.135: v2(292.3,57.01) 292.13,57.19 292.13,57.43 291.88,57.68 290.61,57.68 289.8,56.87 288.75,56.87 286.51,59.11 277.05,59.11 275.92,57.98 275.27,57.98 274.04,56.75 265.28,56.75 259.48,50.95 258.06,50.95 257.4,50.28 255.59,50.28 254.24,48.94 253.23,48.94 243.13,38.83 239.3,38.83 238.39,39.75 230.19,39.75 229.2,38.75 212.47,38.75 211.36,39.87 206.76,39.87 205.65,40.98 204.45,40.98 204.19,41.24 204.19,41.96 197.09,49.05 197.09,50.34 191.39,56.04 190.69,56.04 190.3,56.43 190.3,56.89 186.5,60.68 186.5,61.54 184.96,63.08 184.96,64.4 181.31,68.05 181.31,69.84 179.86,71.29 179.86,78.24 180.33,78.71 180.33,81.22 169.25,92.3 164.59,92.3 163.13,93.76 159.06,93.76 158.24,94.58 153.26,94.58 150.23,91.55 147.92,91.55 147.6,91.87 143.26,91.87 142.06,93.08 142.06,93.8 141.62,94.24 140.96,94.24 v2(140.92,94.28)
  BOTTOM w0.076: v2(140.92,94.28) 140.78,94.14 140.77,94.14 140.69,94.06 138.5,94.06 137.43,92.99 137.43,92.23 136.92,91.71 136.92,91.25 136.17,90.5 136.17,89.53 135.48,88.84 135.48,88.48 135.51,88.38 135.51,88.19 135.48,88.1 135.48,87.85 135.55,87.6 135.55,87.3 135.59,87.25 135.59,87.18 135.74,87.03 135.86,87.03 135.91,87.09 UC1.C17
  BOTTOM w0.104: v2(292.3,57.01) 292.18,56.88 292.18,56.56 293.09,55.65 293.09,52.3 293.7,51.69 293.7,46.78 293.43,46.5 293.43,44.03 293.02,43.62 CZ12.1
PCIE_PTX_DRX_P4: length 221.7
  IN3 w0.135: v2(289.2,61.26) 289.04,61.41 289.04,62.06 288.66,62.44 287.58,62.44 287.06,61.92 273.09,61.92 271.95,60.78 268.62,60.78 268,60.16 267.56,60.16 267.2,59.8 262.19,59.8 259.52,57.13 259.52,56.67 258.45,55.59 256.89,55.59 256.02,54.72 255.16,54.72 244.48,44.04 242.94,44.04 241.38,42.47 227.85,42.47 227.64,42.26 221.93,42.26 220.36,43.83 207.71,43.83 189.83,61.72 189.83,63.12 187.72,65.22 187.72,65.56 186.54,66.75 186.54,67.4 184.78,69.16 184.78,70.69 184.43,71.04 184.43,71.37 183.77,72.03 183.77,84.63 175.65,92.75 175.57,92.75 173.04,95.28 172.05,95.28 171,96.33 170.35,96.33 169.46,97.22 166.97,97.22 166.82,97.07 163.86,97.07 163.23,97.7 162.04,97.7 161.75,97.42 154.7,97.42 154.15,97.97 150.74,97.97 149.92,97.15 148.84,97.15 147.56,98.44 145.68,98.44 144.79,97.55 143.24,97.55 142.84,97.95 140.56,97.95 139.6,96.99 137.61,96.99 133.9,93.29 133.9,90.75 134.26,90.4 134.59,90.4 v2(134.72,90.27)
  BOTTOM w0.076: UC1.A19 134.52,88.58 134.42,88.58 134.37,88.63 134.37,90.52 134.5,90.65 134.63,90.65 134.68,90.7 134.99,90.7 135.04,90.65 135.04,90.43 134.88,90.27 v2(134.72,90.27)
  BOTTOM w0.104: v2(289.2,61.26) 289.03,61.09 289.03,60.16 289.95,59.23 289.95,56.08 291.15,54.88 291.15,51.62 291.87,50.9 291.87,50.3 291.63,50.06 291.47,50.06 291.19,49.78 CZ14.1
PCIE_PTX_DRX_P5: length 137.6
  TOP w0.104: CT125.1 26.45,94.19 26.45,94.56 v2(26.28,94.72)
  IN1 w0.119: v2(135.4,89.87) 136.09,89.87 136.36,89.87 136.58,90.09 136.58,90.27 136.58,95.39 134.71,97.27 134.71,99.8 128.8,105.7 124.81,105.7 124.42,105.3 122.43,105.3 121.3,106.43 98.07,106.43 96.96,105.33 92.74,105.33 91.44,106.62 67.56,106.62 67.18,106.24 63.08,106.24 62.12,107.2 58,107.2 57.6,106.8 50.37,106.8 50.04,107.13 43.82,107.13 v2(43.81,107.14)
  IN3 w0.135: v2(43.81,107.14) 43.12,107.14 42.62,106.63 41.49,106.63 41.11,107.01 37.05,107.01 36.82,106.78 35.18,106.78 32.45,104.06 31.78,104.06 30.11,102.39 30.11,99.92 28.65,98.47 28.65,97.8 26.28,95.43 v2(26.28,94.72)
  BOTTOM w0.076: v2(135.4,89.87) 135.4,89.93 135.32,90.01 135.21,90.01 134.84,89.64 134.84,89.13 135,88.97 135,88.51 134.95,88.38 134.95,88.19 134.99,88.1 134.99,87.85 134.93,87.65 134.93,87.54 134.77,86.99 UC1.D19
PCIE_PTX_DRX_P6: length 135.3
  TOP w0.104: CT123.1 28.49,94.14 28.49,94.49 v2(28.35,94.63)
  IN1 w0.119: v2(41.1,106.09) 41.81,106.09 42.3,105.6 43.98,105.6 44.28,105.9 48.25,105.9 48.81,106.46 49.79,106.46 50.11,106.14 54.36,106.14 54.9,105.6 57.47,105.6 58.39,106.51 61.82,106.51 63.51,104.83 69.41,104.83 69.99,105.41 91.69,105.41 92.42,104.68 97.22,104.68 98.32,105.77 106.08,105.77 106.63,105.22 121.6,105.22 122.18,104.64 124.66,104.64 125.04,105.01 128.52,105.01 132.21,101.32 132.21,99.05 134.06,97.2 134.06,96.59 135.94,94.72 135.94,91.62 135.35,91.03 v2(135.35,91.02)
  IN3 w0.135: v2(28.35,94.63) 28.35,96.54 30.84,99.03 30.84,101.33 35.31,105.8 37.52,105.8 37.99,106.27 40.07,106.27 40.35,105.99 41,105.99 v2(41.1,106.09)
  BOTTOM w0.076: v2(135.35,91.02) 135.55,91.02 135.63,91.09 135.63,91.28 135.5,91.4 134.94,91.4 134.94,91.41 134.64,91.41 134.63,91.41 134.49,91.41 134.03,90.95 134.03,90.66 134.03,90.66 134.03,88.46 134.03,88.46 134.03,88.11 134.13,88.01 134.21,88.01 134.27,87.95 134.27,87.77 134.15,87.64 UC1.C20
PCIE_PTX_DRX_P7: length 131
  TOP w0.104: v2(29.81,96.76) 30.04,96.53 30.04,96.37 30.87,95.54 30.87,94.6 30.97,94.5 30.97,94.2 CT4.1
  IN1 w0.119: v2(134.59,92.65) 134.59,92.51 134.31,92.23 134.16,92.23 134.04,92.35 134.04,95.65 133.39,96.3 133.39,96.95 131.54,98.8 131.54,101.07 128.26,104.36 125.35,104.36 124.98,103.98 121.93,103.98 121.34,104.57 106.05,104.57 105.84,104.37 100.79,104.37 100.5,104.65 98.17,104.65 97.53,104.02 92.16,104.02 91.44,104.74 70.29,104.74 69.72,104.17 63.26,104.17 62.68,104.74 58.5,104.74 58.29,104.96 54.58,104.96 54.04,105.49 50.06,105.49 49.79,105.23 45.95,105.23 43.05,102.33 41.94,102.33 40.56,103.7 40.56,103.88 v2(40.74,104.07)
  IN3 w0.135: v2(29.81,96.76) 30.02,96.97 30.02,97.24 31.88,99.11 31.88,100.2 36.58,104.9 40.2,104.9 40.53,104.56 40.53,104.27 v2(40.74,104.07)
  BOTTOM w0.076: v2(134.59,92.65) 134.65,92.59 134.65,92.41 134.55,92.32 134.45,92.32 134.27,92.14 133.8,92.14 133.52,91.85 133.52,88.7 UC1.A21
PCIE_PTX_DRX_P8: length 123
  TOP w0.104: v2(32.85,95.66) 33.02,95.48 33.02,95.03 33.23,94.83 33.23,94.18 CT2.1
  IN1 w0.119: v2(40.5,101.16) 40.7,100.96 41.2,100.96 41.81,100.35 43.04,100.35 44.4,101.72 45.29,101.72 47.49,103.91 50.73,103.91 51.02,104.2 52.75,104.2 53.9,103.05 59.12,103.05 59.49,103.42 62.19,103.42 62.75,102.86 91.38,102.86 91.64,102.6 98.97,102.6 99.46,103.08 106.42,103.08 106.62,103.29 120.8,103.29 122.68,101.41 128.07,101.41 129.2,100.28 129.2,97.48 132.09,94.59 132.09,92.34 132.22,92.21 132.45,92.21 132.57,92.33 v2(132.57,92.44)
  IN3 w0.135: v2(40.5,101.16) 40.37,101.04 35.71,101.04 34.06,99.39 34.06,97.85 34.3,97.61 34.3,96.88 33.91,96.49 33.42,96.49 32.98,96.05 32.98,95.78 v2(32.85,95.66)
  BOTTOM w0.076: v2(132.57,92.44) 132.48,92.44 132.4,92.36 132.4,92.18 132.5,92.08 132.7,92.08 132.78,92.15 133.07,92.15 133.35,91.87 133.35,89.01 133.16,88.83 133.16,88.51 133.2,88.44 133.2,88.16 133.16,88.05 133.16,87.88 133.25,87.62 133.36,87.51 133.36,87.38 UC1.C21
PCIE_PTX_DRX_P9: length 222.4
  TOP w0.104: CL5.1 267.78,94.99 266.45,93.66 266.45,64.55 265.33,63.43 265.33,62.52 v2(265.2,62.39)
  IN3 w0.135: v2(131.73,90.14) 131.09,90.14 130.82,90.41 130.82,93.09 137.25,99.53 139.25,99.53 140.41,100.69 144.48,100.69 144.98,101.19 148.14,101.19 148.48,100.85 157.95,100.85 158.73,100.08 167.76,100.08 170.6,97.24 172.33,97.24 174.83,94.74 174.83,94.45 175.87,93.41 175.96,93.41 185.84,83.53 185.84,73.44 187.08,72.21 187.08,71.58 186.91,71.42 186.91,69.92 188.63,68.21 188.63,67.57 189.79,66.41 189.79,64.17 192.96,61 192.96,59.6 207.25,45.26 221.6,45.26 222.65,44.21 225.78,44.21 226.86,45.29 229.86,45.29 230.64,44.52 241.27,44.52 242.69,45.93 243.48,45.93 256.17,58.62 257.13,58.62 260.36,61.84 264.89,61.84 265.2,62.15 v2(265.2,62.39)
  BOTTOM w0.076: v2(131.73,90.14) 131.73,90.31 131.6,90.44 131.43,90.44 131.3,90.32 131.3,89.83 131.76,89.37 131.76,88.42 131.92,88.26 132.03,88.26 132.14,88.37 132.14,88.55 UC1.A23
PCIE_PTX_DRX_P11: length 206.5
  IN1 w0.119: v2(45.13,90.18) 45.41,90.46 45.78,90.46 46.29,89.95 46.29,88.37 45.99,88.06 45.99,85.86 45.78,85.65 45.78,80.77 45.06,80.06 45.06,78.35 44.9,78.18 44.9,75.76 44.18,75.04 44.18,70.56 44.76,69.97 44.76,69.74 45.18,69.32 45.18,67.51 46.99,65.7 46.99,55.03 47.15,54.87 47.15,49.31 43.83,45.99 43.83,43.54 39.95,39.67 39.95,27.93 40.26,27.62 40.26,24.98 37.73,22.45 30.07,22.45 29.51,21.89 29.51,21.39 v2(29.15,21.02)
  IN3 w0.135: v2(127.7,103.35) 127.77,103.35 128.13,103.7 128.13,104 122.8,109.33 121.44,109.33 121.37,109.26 109.97,109.26 109.7,108.98 102.17,108.98 100.44,110.71 94,110.71 91.79,108.5 69.37,108.5 68.44,109.43 62,109.43 61.07,108.5 55.73,108.5 52.84,105.62 51.15,105.62 48.35,102.83 48.35,93.76 47.18,92.59 47.18,91.67 46.61,91.09 46.04,90.52 45.47,90.52 v2(45.13,90.18)
  BOTTOM w0.076: UC1.C24 131.52,87.35 131.44,87.27 131.32,87.27 131.23,87.37 131.23,87.56 131.22,87.57 131.22,87.83 131.24,87.84 131.24,88.96 130.43,89.77 130.43,90.88 128.72,92.59 128.72,95.57 129.26,96.12 129.26,98.49 129.26,98.5 129.25,98.49 129.25,98.51
  BOTTOM w0.104: 129.25,98.51 129.25,101.44 v4(128.57,102.12) 128.01,102.69 128.01,103.14 127.8,103.35 v2(127.7,103.35) ; v2(29.15,21.02) 29.36,20.81 29.36,20.48 CN70.2
