# Allegro board LAE131PR10-1107-A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V_ALW on IN1 (solid shape): 174.57,116.33 174.57,115.71 169.83,110.97 169.83,110.49 168.04,108.7 153.32,108.7 153.3,108.73 153.01,108.91 152.71,108.73 152.7,108.7 152.46,108.7 151.34,109.82 151.34,110.23 151.53,110.41 167.16,110.41 167.17,110.4 167.95,110.4 168.2,110.66 168.48,110.94 168.48,112.08 169.64,113.23 169.67,113.23 169.95,113.32 170.05,113.61 170.04,113.63 173.03,116.62 174.28,116.62
+5V_ALW on IN1 (solid shape): outline of 579 points within 282.77,65.91 296.27,82.52
+5V_ALW on IN2 (solid shape): outline of 2555 points within 12.55,32.61 40.8,67.34
+5V_ALW on IN3 (solid shape): outline of 189 points within 131.63,104.86 152.75,111.25
+5V_ALW on IN3 (solid shape): outline of 540 points within 282.89,72.1 292.04,82.96
+5V_ALW on VCC: 38.33,45.43 36.58,47.19 36.58,61.97 43.53,68.92 46.84,68.92 48.77,70.86 48.77,77.82 70.89,77.82 71.12,77.59 71.12,76.15 70.89,75.91 66.19,75.91 65.53,75.26 65.53,68.91 64.79,68.17 57.94,68.17 57.53,67.76 57.53,65.48 57.17,65.12 51.08,65.12 49.53,63.57 49.53,53.33 52.47,50.39 164.45,50.39 168.79,54.73 168.79,63.74 169.27,64.23 171.09,64.23 178.59,56.74 183.62,56.74 184.28,57.39 184.28,107.77 182.99,109.06 169.67,109.06 169.67,117.88 176.03,117.88 176.03,117.2 176.67,115.67 178.2,115.03 184.2,115.03 185.73,115.67 186.37,117.2 186.37,117.88 190.43,117.88 190.43,117.5 190.88,116.18 192.03,115.41 192.03,109.05 192.67,107.52 194.2,106.88 194.73,106.88 194.73,81.05 198.16,67.25 207.66,56.66 213.99,53.62 220.94,52.58 227.46,52.58 234.41,53.62 240.74,56.66 250.24,67.25 253.67,81.05 253.67,91.41 263.02,91.41 263.02,66.75 251.36,55.09 249.58,55.09 239.93,45.43
+5V_ALW2 on BOTTOM (solid shape): 32.84,48.32 34.11,47.05 34.11,46.84 34.03,46.76 33.28,46.76 32.75,47.29 32.58,47.29 32.39,47.1 32.39,46.63 32.25,46.48 32.03,46.48 31.86,46.66 31.86,47.22 31.79,47.29 31.79,48.25 31.85,48.32 32.58,48.32
+5V_ALW_PDA on TOP (solid shape): outline of 88 points within 29.15,55.67 31.63,58.93
+5V_ALW_PDA on BOTTOM (solid shape): outline of 373 points within 18.54,53.3 32.13,59.98
+5V_ALWP on TOP (solid shape): 39.52,58.43 39.52,53.09 39.21,52.77 38.06,52.77 37.85,52.99 37.85,58.45 38.04,58.64 39.31,58.64
+5V_ALWP on BOTTOM (solid shape): 38.42,59.53 39.25,59.53 39.25,60.04 39.56,60.04 39.56,59.59 39.63,59.53 40.39,59.53 40.52,59.4 40.52,59.02 40.45,58.96 40.45,58.31 40.39,58.25 39.87,58.25 39.55,57.93 39.55,52.97 39.45,52.86 33.39,52.86 32.91,53.35 32.91,57.59 34.6,59.28 35.88,59.28 36.13,59.53 37.98,59.53 37.98,60.1 38.42,60.1
+5V_PD_VDD on TOP (solid shape): 18.61,96.23 18.61,95.6 18.86,95.34 19.05,95.34 19.18,95.22 19.18,94.93 19.19,94.91 19.19,94.66 19.12,94.59 18.93,94.59 18.86,94.6 18.78,94.58 18.44,94.58 18.44,94.75 17.88,94.75 17.88,94.16 18.13,94.16 18.16,94.13 18.16,93.95 18.54,93.57 18.8,93.57 18.93,93.44 18.93,92.55 18.92,92.31 18.72,92.1 17.72,92.1 17.42,92.4 17.45,92.43 17.49,92.55 17.49,92.68 17.49,93.2 17.13,93.56 17.13,93.71 16.9,93.93 16.88,93.93 16.72,94.08 16.72,95.55 16.76,95.59 17.16,95.59 18.06,96.49 18.35,96.49
+5V_RUN on TOP (solid shape): 158.18,115.6 158.18,113.7 158.05,113.57 157.36,113.57 157.16,113.76 157.16,115.66 157.29,115.79 157.99,115.79
+5V_RUN on TOP (solid shape): 191.45,77.06 191.45,76.17 191.07,75.79 189.8,75.79 189.55,76.04 189.55,77.06 189.74,77.25 191.26,77.25
+5V_RUN on TOP (solid shape): 290.02,85.36 290.02,84.42 289.92,84.32 288.31,84.32 288.17,84.18 288.17,84.02 287.96,83.81 287.84,83.81 287.66,83.63 286.66,83.63 286.33,83.96 286.33,85.62 286.65,85.93 289.45,85.93
+5V_RUN on TOP (solid shape): 264.64,26.44 264.64,25.43 264.5,25.28 263.84,25.28 263.75,25.19 263.27,25.19 263.16,25.3 263.16,25.76 263.31,25.91 263.73,25.91 263.8,25.98 263.8,26.47 263.88,26.55 264.53,26.55
+5V_RUN on TOP (solid shape): 297.44,23.36 297.66,23.28 297.88,23.36 299.63,23.36 299.72,23.27 299.72,22.15 300.3,22.15 300.31,22.14 300.31,21.88 299.79,21.88 299.78,21.87 299.78,21.37 300.31,21.37 300.31,21.11 300.29,21.1 299.72,21.1 299.72,20.69 299.6,20.56 298.55,20.56 298.54,20.57 297.46,20.57 297.06,20.97 297.06,22.15 296.76,22.45 296.22,22.45 296.12,22.54 296.12,23.23 296.25,23.36 296.64,23.36
+5V_RUN on BOTTOM (solid shape): 20.45,75.66 20.45,75.53 20.32,75.41 19.81,75.41 19.71,75.3 19.6,75.3 19.6,75.19 19.56,75.15 19.56,74.39 19.31,74.14 17.66,74.14 17.4,74.39 17.4,75.53 17.66,75.79 20.32,75.79
+5V_RUN on BOTTOM (solid shape): 186.15,77.09 186.15,77.01 186.22,77.01 186.31,76.93 189.99,76.93 190.24,76.68 190.24,74.64 189.99,74.39 186.18,74.39 185.55,75.02 183.13,75.02 182.62,75.53 182.62,78.2 182.75,78.33 184.91,78.33
+5V_RUN on BOTTOM (solid shape): 265.82,27.51 265.82,25.98 265.57,25.73 264.17,25.73 264.1,25.79 264.1,26.29 264.16,26.35 264.58,26.35 264.62,26.31 264.62,26.14 264.65,26.11 265.26,26.11 265.45,26.3 265.45,27.53 265.53,27.6 265.73,27.6
+5V_RUN on VCC: outline of 136 points within 18.42,16.73 300.61,117.88 ; 1 cut-out
+5V_RUN_AUDIO on TOP (solid shape): 297.12,41.12 297.12,39.48 296.29,38.65 296.29,38.32 296.17,38.19 295.15,38.19 294.9,38.45 294.9,40.23 294.77,40.35 294.39,40.35 294.26,40.48 294.26,40.73 294.39,40.86 294.84,40.86 295.2,41.22 297.02,41.22
+5V_RUN_AUDIO on TOP (solid shape): 301.82,22.95 301.82,18.83 301.64,18.65 301.64,18.64 301.25,18.25 299.72,18.25 299.44,17.97 298.03,17.97 297.93,18.07 297.93,18.36 298.47,18.36 298.47,18.79 297.93,18.79 297.93,20.05 298.22,20.33 299.7,20.33 299.91,20.54 299.91,20.92 300.48,20.92 300.48,21.49 299.91,21.49 299.91,21.75 300.48,21.75 300.48,22.32 299.91,22.32 299.91,23.08 300.11,23.28 301.5,23.28
+5V_RUN_AUDIO on IN2 (solid shape): outline of 313 points within 293.25,17.37 300.11,41.03
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): 296.79,21.17 296.79,20.59 297.79,19.59 297.79,18.08 297.75,18.04 297.04,18.04 296.97,18.12 296.97,18.92 296.9,18.99 296.48,18.99 296.4,19.07 296.4,19.75 296.12,20.02 296.12,21.18 296.18,21.24 296.72,21.24
+5V_RUN_PVDD_L on TOP (solid shape): 300.87,39.85 301.63,39.85 301.75,39.72 301.75,38.96 301.68,38.89 300.55,38.89 299.64,39.8 299.03,39.8 298.33,39.1 298.33,38.83 297.97,38.47 297.97,37.93 297.82,37.78 296.96,37.78 296.8,37.94 296.8,38.96 297.26,39.42 297.26,40.93 297.31,40.99 299.72,40.99
+5V_RUN_UZ4 on TOP (solid shape): 290.04,83.43 290.04,81.37 290.05,81.37 290.05,79.79 289.84,79.59 289.43,79.59 289.04,79.19 288.22,79.19 288.17,79.24 288.17,79.71 288.12,79.76 288.12,79.86 288.03,79.86 287.78,80.1 287.78,81.38 287.91,81.51 287.91,83.58 287.96,83.64 289.84,83.64
+5V_TBT_VBUS on BOTTOM (solid shape): 36.32,22.07 36.32,20.67 35.82,20.16 33.66,20.16 33.02,20.8 32.13,20.8 32.01,20.92 32.01,22.19 32.26,22.45 35.94,22.45
+5V_TBTA_VBUS_D on BOTTOM (solid shape): 36.32,19.52 36.32,19.05 36.48,18.89 36.71,18.89 36.71,18.77 37.07,18.41 37.42,18.77 37.42,18.89 37.61,18.89 37.61,18.84 37.83,18.52 38.22,18.59 38.52,18.89 39.75,18.89 39.9,19.04 41.25,19.04 41.4,18.89 41.4,17.87 41.02,17.49 40.67,17.49 40.58,17.54 40.57,17.63 40.26,18.08 39.95,17.63 39.94,17.54 39.86,17.49 36.79,17.49 36.71,17.53 36.69,17.62 36.37,18.02 36.05,17.62 36.03,17.53 35.95,17.49 35.18,17.49 34.9,17.78 34.9,19.61 35.05,19.76 36.08,19.76
+5V_TSP on TOP (solid shape): 99.2,117.58 99.2,115.19 98.54,114.53 98.11,114.53 97.7,114.12 97.01,114.12 96.56,114.57 96.56,115.37 95.62,116.31 94.66,116.31 94.64,116.33 97.94,116.33 97.94,116.27 97.95,116.22 97.97,116.17 97.99,116.13 98.02,116.08 98.06,116.05 98.1,116.02 98.15,115.99 98.2,115.98 98.25,115.97 98.3,115.97 98.35,115.98 98.4,115.99 98.45,116.02 98.49,116.05 98.53,116.08 98.56,116.13 98.58,116.17 98.6,116.22 98.6,116.27 98.6,116.33 98.6,116.38 98.58,116.43 98.56,116.47 98.53,116.52 98.49,116.55 98.45,116.58 98.4,116.61 98.35,116.62 98.3,116.63 98.25,116.63 98.2,116.62 98.15,116.61 98.1,116.58 98.06,116.55 98.02,116.52 97.99,116.47 97.97,116.43 97.95,116.38 97.94,116.33 94.64,116.33 94.48,116.48 94.48,117.67 94.59,117.78 99,117.78
+5V_TSP on BOTTOM (solid shape): 97.92,117.4 97.92,116.15 97.73,115.96 95.82,115.96 95.57,116.2 95.34,116.2 95.12,116.29 94.9,116.2 94.75,116.2 94.64,116.3 94.51,116.34 94.47,116.35 94.47,117.67 94.58,117.78 97.54,117.78
+5V_USB_CHG_PWR on TOP (solid shape): 305.64,60.83 305.67,60.8 305.67,60.04 305.69,60.01 305.69,58.62 305.6,58.53 304.56,58.53 304.51,58.58 304.51,58.78 304.5,58.79 304.5,58.87 304.49,58.87 304.49,59.22 304.49,59.22 304.49,59.61 304.02,60.08 304.02,60.54 304.1,60.66 304.14,60.8 304.14,60.84 305.64,60.84
+5V_USB_CHG_PWR on TOP (solid shape): 299.09,71.34 299.09,69.37 299,69.29 298.93,69.25 298.77,69.25 298.29,69.25 298.13,69.25 298.11,69.26 298.07,69.28 298.03,69.3 297.98,69.32 297.93,69.32 297.91,69.32 297.62,69.32 297.54,69.25 297.52,69.25 295.85,69.25 295.79,69.31 295.79,70.92 297.04,70.92 297.04,70.87 297.05,70.82 297.07,70.77 297.09,70.72 297.12,70.68 297.16,70.65 297.2,70.62 297.25,70.59 297.3,70.58 297.35,70.57 297.4,70.57 297.45,70.58 297.5,70.59 297.55,70.62 297.59,70.65 297.62,70.68 297.65,70.72 297.68,70.77 297.69,70.82 297.7,70.87 297.7,70.92 297.69,70.97 297.68,71.02 297.65,71.07 297.62,71.11 297.59,71.15 297.55,71.18 297.5,71.2 297.45,71.22 297.4,71.23 297.35,71.23 297.3,71.22 297.25,71.2 297.2,71.18 297.16,71.15 297.12,71.11 297.09,71.07 297.07,71.02 297.05,70.97 297.04,70.92 295.79,70.92 295.79,71.21 296.17,71.6 298.83,71.6
+5V_USB_CHG_PWR on BOTTOM (solid shape): outline of 101 points within 300.36,54.96 305.68,60.17
+5V_USB_CHG_PWR on IN1 (solid shape): 311.13,58.45 311.13,57.38 310.78,57.04 306.44,57.04 304.57,58.91 304.57,60.11 304.75,60.28 309.3,60.28
+5V_USB_CHG_PWR on IN3 (solid shape): outline of 327 points within 297.06,56.61 311.09,70.61
+DV33_18 on TOP (solid shape): 301.01,50.66 301.01,50.15 301.17,50 301.67,50 301.74,49.92 301.74,49.32 301.67,49.25 301.39,49.25 301.37,49.26 301.31,49.26 300.55,50.02 300.55,50.58 300.29,50.84 299.51,50.84 299.45,50.9 299.45,50.99 299.51,51.06 300.62,51.06
+VBUS_DC_SS on TOP (solid shape): 52.51,102.51 53.73,102.51 54.61,101.63 54.61,99.28 54.48,99.15 51.95,99.15 51.94,99.16 51.86,99.16 51.72,99.31 46.99,99.31 46.64,99.66 46.64,103 47.75,104.11 50.92,104.11
+VCC_CORE on TOP (solid shape): outline of 4565 points within 80.63,73.37 129.6,100.91
+VCC_CORE on BOTTOM (solid shape): outline of 227 points within 79.83,79.51 95.61,89.69
+VCC_CORE on BOTTOM (solid shape): outline of 451 points within 122.37,71.69 127.45,74.53
+VCC_CORE on BOTTOM (solid shape): outline of 575 points within 120.74,82.21 128.38,85.11
+VCC_CORE on IN1 (solid shape): outline of 352 points within 82.04,79.51 95.04,89.52
+VCC_CORE on IN1 (solid shape): outline of 743 points within 120.11,75.66 127.13,83.47
+VCC_CORE on IN2 (solid shape): outline of 4301 points within 82.05,71.69 127.46,90.62
+VCC_CORE on IN3 (solid shape): outline of 1346 points within 120.07,72.93 128.15,85.12
+VCC_CORE on VCC: 122.43,71.6 122.43,73.87 120.09,76.21 120.09,83.82 119.74,84.17 100.35,84.17 98.7,82.52 95.78,82.52 94,80.74 91.72,80.74 90.51,79.53 82.3,79.53 82.3,84.44 82.72,84.87 89.13,84.87 89.79,85.52 89.79,89.4 90.91,90.52 127.34,90.52 128.21,89.65 128.21,74.39 127.91,74.39 126.11,72.59 126.11,71.7 126.01,71.6
+VCC_EDRAM on TOP (solid shape): 60.86,62.38 60.86,61.71 60.86,61.7 60.83,61.56 60.86,61.41 60.86,61.4 60.86,61.31 60.49,60.94 59.14,60.94 58.87,61.2 58.34,61.2 58.34,61.73 58.34,61.74 56.88,61.74 56.88,61.19 56.88,61.19 56.6,61.19 56.55,61.24 56.55,61.8 56.54,61.8 56.54,62.41 56.83,62.71 60.54,62.71
+VCC_EDRAM on TOP (solid shape): 111.25,80.94 111.25,80.1 111.38,79.98 111.88,79.98 111.95,79.91 111.95,79.15 112.11,78.98 112.19,78.98 112.27,78.9 112.27,78.26 112.06,78.05 112.06,76.59 111.96,76.49 111.51,76.49 111.4,76.59 111.08,76.86 110.75,76.59 110.62,76.46 110.19,76.46 110.05,76.6 110.05,77.44 110.37,77.76 110.37,78.71 110.15,78.93 110.15,79.85 110.21,79.91 110.66,79.91 110.83,80.09 110.83,80.99 110.91,81.07 111.13,81.07
+VCC_EDRAM on IN3 (solid shape): outline of 2708 points within 58.36,60.55 111.76,80.49
+VCC_EDRAM_P on TOP (solid shape): 56.44,61.35 56.44,61.13 56.49,61.07 56.5,61.07 56.56,61.01 58.75,61.01 59.58,60.18 59.58,58.98 59.39,58.79 55.95,58.79 55.01,59.72 53.05,59.72 52.86,59.91 52.86,60.93 53.01,61.08 54.79,61.08 54.92,61.22 54.92,61.9 55.03,62.01 55.78,62.01
+VCC_EOPIO on TOP (solid shape): 57.75,54.31 57.75,53 57.52,52.77 55.04,52.77 54.98,52.84 54.98,54.12 55.25,54.39 57.67,54.39
+VCC_EOPIO on TOP (solid shape): 112.03,76.19 112.03,74.3 111.75,74.02 110.95,74.02 110.71,74.26 110.71,75.84 110.95,76.08 111.26,76.08 111.42,76.25 111.98,76.25
+VCC_EOPIO on BOTTOM (solid shape): 111.49,76.1 111.49,74.74 112.02,74.74 112.02,74.1 111.83,73.92 111.13,73.92 110.84,74.21 110.6,74.21 110.4,74.41 110.4,75.91 110.67,76.18 111.41,76.18
+VCC_EOPIO on VCC: 55.48,53.56 55.37,53.67 55.37,58.41 56.37,59.4 69.58,59.4 79.48,69.31 99.04,69.31 99.55,69.82 101.71,69.82 108.57,76.68 111.28,76.68 111.76,76.19 111.76,73.23 111.51,72.97 111.51,71.55 111.72,71.34 93.94,53.56
+VCC_EOPIO_P on TOP (solid shape): 50.93,46.72 50.93,45.38 50.81,45.26 50.5,45.26 49.9,45.86 49.9,46.63 49.82,46.71 49.82,46.87 49.89,46.94 50.71,46.94
+VCC_EOPIO_P on TOP (solid shape): 54.74,52.08 57.78,52.08 57.99,51.87 57.99,50.1 57.79,49.9 54.29,49.9 54.14,49.76 54.14,49.01 53.94,48.8 51.55,48.8 51.4,48.95 51.4,49.97 51.5,50.07 51.5,51.7 51.66,51.85 51.96,51.85 52.31,52.2 54.61,52.2
+VCC_GT on TOP (solid shape): outline of 4888 points within 79.4,64.86 121.64,90.1
+VCC_GT on BOTTOM (solid shape): outline of 793 points within 111.69,71.73 122.05,74.17
+VCC_GT on BOTTOM (solid shape): outline of 2186 points within 69.74,63.47 120.62,84.26
+VCC_GT on IN1 (solid shape): outline of 1500 points within 106.05,64.23 117.34,72.68
+VCC_GT on IN1 (solid shape): outline of 3664 points within 79.5,70.3 121.4,83.65
+VCC_GT on IN2 (solid shape): outline of 3180 points within 79.49,70.24 121.92,83.66
+VCC_GT on IN3 (solid shape): outline of 2846 points within 79.82,70.52 121.73,83.66
+VCC_GT on VCC: 79.63,69.82 79.63,74.92 81.28,76.57 81.28,78.22 82.09,79.03 90.72,79.03 91.93,80.23 94.21,80.23 95.99,82.01 98.91,82.01 100.56,83.66 119.53,83.66 119.58,83.61 119.58,75.99 121.92,73.64 121.92,71.64 121.88,71.6 112.18,71.6 112.02,71.76 112.02,72.76 112.27,73.01 112.27,76.4 111.49,77.18 108.35,77.18 101.5,70.33 99.34,70.33 98.83,69.82
+VCC_SA on TOP (solid shape): 132.51,75.54 132.51,74.38 132.09,73.97 130.83,73.97 130.65,74.15 130.65,75.4 130.84,75.59 132.45,75.59
+VCC_SA on TOP (solid shape): 86.87,89.43 89.38,89.43 89.47,89.34 89.47,86.75 89.23,86.52 87.34,86.52 86.32,85.5 84.6,85.5 84.08,86.02 84.08,86.18 83.81,86.45 83.81,89.77 83.92,89.88 85.03,89.88 85.08,89.93 86.36,89.93
+VCC_SA on TOP (solid shape): outline of 116 points within 128.86,78.22 132.45,85.49
+VCC_SA on BOTTOM (solid shape): 131.91,74.42 131.91,73.59 132,73.5 132,73.15 131.94,73.09 130.68,73.09 130.47,73.3 130.47,74.48 130.56,74.57 131.75,74.57
+VCC_SA on BOTTOM (solid shape): 86.83,89.41 89.07,89.41 89.38,89.1 89.38,86.79 89.11,86.51 86.9,86.51 86.69,86.3 86.69,85.72 86.39,85.41 84.2,85.41 83.72,85.9 83.72,87.41 83.76,87.45 83.77,87.45 83.79,87.48 85.11,87.48 85.11,88.3 83.84,88.3 83.72,88.42 83.72,89.81 83.9,89.99 86.26,89.99
+VCC_SA on BOTTOM (solid shape): outline of 149 points within 128.15,82.22 132.51,85.18
+VCC_SA on IN3 (solid shape): outline of 162 points within 129.23,73.95 131.88,83.36
+VCC_SA on VCC: 90.7,91.03 89.28,89.61 89.28,85.73 88.92,85.38 83.7,85.38 83.7,98.27 131.96,98.27 131.96,84.91 131.95,84.91 131.95,73.37 131.17,73.37 130.15,74.39 128.73,74.39 128.72,74.4 128.72,89.86 127.55,91.03 ; 1 cut-out
+VSS_PLL on TOP (solid shape): 267.4,36.86 267.4,35.89 267.18,35.68 267.18,34.73 267.51,34.4 267.51,33.27 267.48,33.23 266.67,33.23 266.56,33.34 266.56,34.95 266.79,35.17 266.79,35.84 267.04,36.1 267.04,36.86 267.15,36.96 267.3,36.96
GND on TOP (solid shape): 34.71,18.39 34.71,17.67 34.53,17.49 33.44,17.49 33.19,17.74 33.19,18.49 33.35,18.65 34.46,18.65
GND on TOP (solid shape): 45.52,62.4 45.52,60.45 45.45,60.37 43.95,60.37 43.69,60.63 43.69,61.94 44.26,62.52 45.41,62.52
GND on TOP (solid shape): 57.89,49.53 57.89,48.52 57.79,48.42 54.48,48.42 54.33,48.56 54.33,49.54 54.56,49.77 57.65,49.77
GND on TOP (solid shape): 59.47,58.42 59.47,57.41 59.37,57.31 56.05,57.31 55.91,57.45 55.91,58.43 56.14,58.66 59.22,58.66
GND on TOP (solid shape): 89.36,90.85 89.36,89.72 89.23,89.59 87.05,89.59 86.96,89.68 86.96,90.76 87.24,91.04 89.17,91.04
GND on TOP (solid shape): 124.08,103.29 124.08,101.37 123.73,101.02 119.01,101.02 118.8,101.24 118.8,103.22 119.2,103.62 123.74,103.62
GND on TOP (solid shape): 144.77,101.63 144.77,100.78 144.67,100.67 142.35,100.67 142.11,100.91 142.11,101.51 142.34,101.74 144.66,101.74
GND on TOP (solid shape): 272.93,86.33 272.93,84.8 272.8,84.68 271.4,84.68 271.27,84.8 271.27,86.33 271.4,86.45 272.8,86.45
GND on TOP (solid shape): 280.94,78.1 280.94,77.52 280.65,77.22 277.47,77.22 277.32,77.38 277.32,78.22 277.47,78.37 280.67,78.37
GND on TOP (solid shape): 310.75,33.04 310.75,31.92 310.67,31.84 309.96,31.84 308.82,32.99 308.82,33.83 308.99,34 309.78,34
GND on TOP (solid shape): 194.61,29.97 194.61,27.4 194.15,26.94 193.17,26.94 193.04,27.06 193.04,29.95 193.11,30.02 194.56,30.02
GND on TOP (solid shape): 23.24,46.89 23.24,45.88 22.99,45.62 20.96,45.62 20.83,45.75 20.83,46.77 20.89,46.83 21.72,46.83 21.97,47.08 23.05,47.08
GND on TOP (solid shape): 64.01,93.31 64.01,91.53 62.74,90.26 60.71,90.26 60.2,90.77 60.2,93.06 60.61,93.46 62.76,93.46 62.86,93.57 63.76,93.57
GND on TOP (solid shape): 70.27,92.29 70.27,91.83 70.46,91.64 70.46,87.52 69.92,86.98 68.84,86.98 68.55,87.27 68.55,92.32 68.66,92.43 70.13,92.43
GND on TOP (solid shape): 177.24,112.54 177.24,112.22 177.03,112.01 176.63,112.01 176.18,111.55 175.34,111.55 175.19,111.7 175.19,112.64 175.31,112.77 177.01,112.77
GND on TOP (solid shape): 264.15,77.22 264.15,76.47 264.06,76.37 260.78,76.37 260.73,76.32 259.12,76.32 259.02,76.41 259.02,77.44 259.25,77.66 263.72,77.66
GND on TOP (solid shape): 44.32,44 44.32,42.54 44.25,42.47 43.14,42.47 42.47,43.15 42.47,43.94 42.65,44.11 44.2,44.11
GND on TOP (solid shape): 23.05,43.72 23.94,43.72 24.01,43.78 24.26,43.78 24.39,43.66 24.39,43.27 24.2,43.08 20.7,43.08 20.51,43.27 20.51,43.97 20.58,44.04 22.74,44.04
GND on TOP (solid shape): 41.36,57.88 41.36,51.56 41.16,51.36 39,51.36 38.77,51.59 38.77,52.31 38.99,52.52 39.43,52.52 39.75,52.84 39.75,57.75 39.93,57.93 41.31,57.93
GND on TOP (solid shape): 89.49,86.33 89.49,85.76 88.84,85.11 87.2,85.11 87.16,85.15 87.16,85.97 87.61,86.42 89.02,86.42 89.18,86.42 89.41,86.42
GND on TOP (solid shape): 92.25,43 94.85,43 95.26,42.58 95.26,40.47 92.41,37.61 92.41,37.03 91.62,36.24 87.78,36.24 87.58,36.44 87.58,41.55 89.08,43.05 92.2,43.05
GND on TOP (solid shape): 119.05,32.07 121.74,32.07 121.95,31.87 121.95,31.41 121.96,31.4 121.96,30.8 121.74,30.58 115.85,30.58 115.66,30.77 115.66,32.56 115.85,32.74 118.38,32.74
GND on TOP (solid shape): 164.51,90.51 165.49,90.51 165.77,90.23 165.77,89.43 165.7,89.36 162.74,89.36 162.6,89.5 162.6,90.71 162.73,90.83 164.19,90.83
GND on TOP (solid shape): 197.79,36.58 197.79,36.12 197.54,35.88 197.54,34.2 197.86,33.89 197.86,33.5 197.74,33.38 196.7,33.38 196.24,33.84 196.24,36.55 196.37,36.67 197.69,36.67
GND on TOP (solid shape): 318.05,70.04 308.01,70.04 308.01,53.16 318.05,53.16 318.05,51.94 306.79,51.94 306.79,71.26 318.05,71.26
GND on TOP (solid shape): 18.75,47.4 17.53,47.4 17.53,54.79 7.04,54.79 7.04,56.01 18.75,56.01
GND on TOP (solid shape): 117.91,35.71 119.04,35.71 119.05,35.7 121.09,35.7 121.31,35.48 121.31,34.89 121.04,34.62 117.94,34.62 117.76,34.81 117.76,35.54 117.73,35.57 117.88,35.73
GND on TOP (solid shape): 301.63,41.24 301.63,40.23 300.74,40.23 299.53,41.43 296.17,41.43 296.16,41.43 295.11,41.43 294.67,40.99 294.26,40.99 294.01,41.24 294.01,42.26 294.64,42.89 299.98,42.89
GND on TOP (solid shape): 20.7,93.69 20.74,93.66 20.74,92.3 20.37,91.93 19.26,91.93 19.04,92.15 19.04,93.05 19.31,93.31 20.03,93.31 20.03,93.53 20.07,93.57 20.07,93.82 20.2,93.95 20.7,93.95
GND on TOP (solid shape): 23.18,57.31 23.18,56.63 23.28,56.52 24.4,56.52 24.48,56.44 24.48,55.02 24.17,54.7 21.93,54.7 21.66,54.98 21.66,56.66 22.43,57.43 23.05,57.43
GND on TOP (solid shape): 64.65,114.78 64.65,113.76 63.5,112.62 63.5,112.34 63.44,112.27 63.08,112.27 63.07,112.29 62.61,112.29 62.56,112.34 62.56,112.87 62.61,112.92 62.61,115.41 62.74,115.54 63.89,115.54
GND on TOP (solid shape): 89.36,80.03 89.36,79.32 88.8,78.76 85.17,78.76 83.75,77.34 79.77,77.34 79.49,77.62 79.49,78.64 80.3,79.46 84.08,79.46 84.72,80.1 89.28,80.1
GND on TOP (solid shape): 309.74,102.06 310.16,102.06 310.52,101.69 310.52,100.74 310.39,100.62 310.01,100.62 309.82,100.81 308.42,100.81 307.91,101.31 307.91,102.58 308.04,102.71 309.08,102.71
GND on TOP (solid shape): 311.03,15.97 311.03,14.83 313.22,12.64 316.2,12.64 316.8,12.03 316.8,10.45 316.55,10.19 314.71,10.19 313.63,11.27 313.18,11.27 310.33,14.13 310.33,15.84 310.52,16.03 310.96,16.03
GND on TOP (solid shape): 52.39,61.85 52.39,61.45 51.69,60.74 50.93,60.74 50.69,60.5 50.69,59.72 50.65,59.68 50.43,59.68 50.38,59.73 50.38,60.56 50.82,61 51.28,61 51.57,61.29 51.57,61.79 51.7,61.93 52.31,61.93
GND on TOP (solid shape): 69.84,75.53 69.84,73.37 69.61,73.15 68.77,73.15 68.52,72.89 68.52,70.9 68.76,70.66 68.76,70.28 68.46,69.98 66.27,69.98 66.14,70.11 66.14,75.28 66.78,75.91 69.46,75.91
GND on TOP (solid shape): 83.74,66.01 85.68,66.01 85.71,65.99 87.02,65.99 88.27,64.74 88.27,60.55 87.89,60.17 80.52,60.17 80.14,60.55 80.14,64.86 80.04,64.97 79.99,64.97 79.55,65.4 79.55,66 79.61,66.05 83.71,66.05
GND on TOP (solid shape): 275.32,54.09 275.32,53.91 275.76,53.47 275.76,53.23 276.08,52.91 276.08,52.68 275.97,52.57 274.28,52.57 274.27,52.58 274.27,53.36 274.04,53.59 273.76,53.59 273.76,54.13 273.78,54.15 275.27,54.15
GND on TOP (solid shape): 275.85,50.22 275.26,49.63 275.26,48.89 274.87,48.9 274.87,49.9 274.73,50.04 274.73,50.48 274.79,50.54 275.03,50.54 275.2,50.71 275.2,51.28 275.25,51.32 275.85,51.32
GND on TOP (solid shape): 20.51,85.5 20.51,83.22 20.46,83.17 19.66,83.17 19.42,83.42 19.42,83.65 19.43,83.65 19.43,83.98 19.21,84.2 18.74,84.2 18.66,84.28 18.66,84.73 18.68,84.75 19.68,84.75 19.92,84.99 19.92,85.47 19.98,85.54 20.47,85.54
GND on TOP (solid shape): 26.28,19.88 26.28,19.15 26.86,18.57 26.86,18.19 26.74,18.07 25.34,18.07 25.13,18.27 25.08,18.27 25.07,18.28 25.01,18.32 24.94,18.35 24.83,18.46 24.83,19.52 25.28,19.97 26.2,19.97
GND on TOP (solid shape): 180.72,100.56 182.12,100.56 182.63,100.05 182.63,98.77 182.88,98.52 182.88,98.27 182.56,97.95 181.22,97.95 180.95,98.22 180.95,98.86 180.77,99.04 177.51,99.04 177.31,99.24 177.31,100.42 177.43,100.55 177.43,100.56 177.8,100.93 180.35,100.93
GND on TOP (solid shape): 40.61,40.24 40.61,38.53 40.36,38.28 39.75,38.28 39.64,38.39 39.64,39.87 39.45,40.06 38.73,40.06 38.55,39.88 38.55,37.81 37.98,37.24 36.2,37.24 35.82,37.62 35.82,37.95 35.82,37.96 35.82,40.13 35.82,40.14 35.82,40.16 35.69,40.29 35.69,40.86 35.82,40.99 39.86,40.99
GND on TOP (solid shape): 188.15,112.36 188.15,110.39 186.04,108.29 186.04,107.71 186.29,107.47 187.06,107.47 187.52,107.02 187.52,105.31 186.88,104.68 185.6,104.68 185.53,104.74 185.53,105.5 184.96,106.06 184.96,111.08 186.5,112.62 187.9,112.62
GND on TOP (solid shape): 326.2,99.6 325.96,99.04 325.4,98.8 314.88,98.8 314.88,100.22 315.89,101.23 326.2,101.23
GND on TOP (solid shape): 198.64,26.73 198.64,25.19 198.47,25.02 198.46,25.02 197.88,24.43 197.88,21.8 197.52,21.45 195.24,21.45 194.96,21.73 194.96,22.28 195.21,22.52 195.26,22.52 195.75,22.52 195.78,22.52 195.82,22.53 196.07,22.53 196.18,22.64 196.18,26.91 196.63,27.36 198,27.36
GND on TOP (solid shape): 61.26,67.66 64.85,67.66 65.29,67.23 65.29,65.64 66.39,64.53 67.27,64.53 69.33,62.47 69.33,61.15 68.98,60.8 68.19,60.8 67.94,60.56 67.06,60.56 63.33,64.29 61.3,64.29 60.91,63.9 58.43,63.9 58.24,64.1 58.24,66.88 59.03,67.66 59.64,67.66 59.98,68.01 60.92,68.01
GND on TOP (solid shape): 124.04,74.93 124.04,74.17 124.56,73.64 124.56,73.44 124.59,73.41 124.56,73.35 123.91,73.35 123.58,73.02 123.58,72.69 123.07,72.69 123.07,73.28 123.34,73.28 123.54,73.48 123.54,74.16 123.54,74.22 123.54,74.52 123.48,74.58 123.48,74.92 123.51,74.95 124.02,74.95
GND on TOP (solid shape): 44.03,25.43 44.03,23.25 43.42,22.64 42.28,22.64 42,22.8 41.71,22.64 40.57,22.64 40.16,23.04 40.16,24.36 39.58,24.94 39.58,26.89 39.73,27.03 42.43,27.03
GND on TOP (solid shape): 72.46,83.09 72.46,82.11 72.6,81.97 76.59,81.97 76.71,81.85 76.71,79.84 76.6,79.73 72.84,79.73 72.71,79.61 72.71,78.83 72.58,78.71 69.28,78.71 68.63,79.36 68.63,80.74 69.09,81.2 69.09,82.93 69.15,82.99 70.61,82.99 71.11,83.49 71.21,83.53 71.3,83.6 71.95,83.6
GND on TOP (solid shape): 325.4,110.95 325.78,110.84 326.05,110.56 326.12,110.39 326.15,110.2 326.15,108.5 323.18,108.5 323.06,108.8 322.9,109.08 321.8,110.56 321.51,110.95
GND on TOP (solid shape): 49.6,48.39 49.6,47.47 49.6,47.47 49.6,46.43 49.75,46.28 49.75,45.56 50.12,45.19 50.28,45.19 50.44,45.03 50.44,43.09 49.07,41.72 48.26,41.72 48.17,41.82 48.17,44.76 48.84,45.43 48.84,46.33 48.52,46.65 47.95,46.65 47.88,46.72 47.88,48.37 47.92,48.42 48.64,48.42 49.57,48.42
GND on TOP (solid shape): 128.79,83.17 128.79,81.5 128.87,81.43 129.72,81.43 129.89,81.26 129.89,79.05 130.11,78.82 130.56,78.82 130.61,78.77 130.61,78.33 130.5,78.21 128.77,78.21 128.57,78.01 128.57,76.27 129.19,75.65 130.02,75.65 130.08,75.6 130.08,74.68 130.01,74.62 129.3,74.62 129.15,74.77 127.56,74.77 127.28,75.05 127.28,82.51 127.31,82.53 127.64,82.53 128.13,83.03 128.13,83.24 128.17,83.28 128.68,83.28
GND on TOP (solid shape): 228.04,31.29 228.04,30.23 227.98,30.2 227.74,30.04 227.72,29.76 227.71,29.66 227.63,29.62 222.75,29.62 222.6,29.77 222.6,31.06 222.94,31.39 227.94,31.39
GND on TOP (solid shape): 51.07,59.45 51.17,59.34 51.17,57.7 51.16,57.69 51.16,57.53 52.28,56.41 52.28,55.58 51.79,55.08 51.78,55.08 51.78,53.18 51.48,52.88 50.17,52.88 50,53.05 50,55.69 50.02,55.78 50,55.87 50,55.9 50.39,56.29 50.39,57.62 50.28,57.73 49.5,57.73 49.41,57.81 49.41,59.39 49.47,59.45 50.34,59.45 50.86,59.45
GND on TOP (solid shape): 126.04,73.9 126.63,73.31 127.04,73.31 127.2,73.47 127.2,73.74 127.21,73.78 127.25,73.79 127.36,73.82 127.45,73.88 127.49,73.91 127.59,73.81 128.01,73.81 128.08,73.73 128.08,72.57 127.98,72.47 126.61,72.47 126.45,72.62 126.45,73.21 126.3,73.36 125.74,73.36 125.45,73.66 125.45,73.85 124.78,74.51 124.78,74.93 124.79,74.94 126.04,74.94
GND on TOP (solid shape): 36.43,43.35 36.43,41.82 36.34,41.73 35,41.73 34.98,41.71 34.93,41.76 34.93,41.77 34.89,41.85 34.84,41.92 34.84,42.03 34.84,42.05 34.9,42.24 34.84,42.43 34.84,42.62 34.9,42.82 34.84,43.02 34.84,43.44 34.87,43.48 36.31,43.48
GND on TOP (solid shape): 149.99,74.39 149.99,74.05 149.65,73.71 149.65,73.67 149.48,73.5 149.48,72.61 147.96,71.09 147.32,71.09 147.2,71.21 147.2,71.85 147.45,72.1 148.21,72.1 148.34,72.23 148.35,72.24 148.46,72.31 148.54,72.43 148.54,72.44 148.59,72.48 148.59,72.61 148.54,72.66 148.54,72.67 148.46,72.78 148.35,72.85 148.34,72.87 148.34,73.25 148.44,73.35 148.87,73.35 148.87,73.4 149.1,73.63 149.1,74.14 149.48,74.52 149.86,74.52
GND on TOP (solid shape): 195.94,36.77 195.94,32.74 195.86,32.53 195.94,32.32 195.94,32.16 195.86,31.95 195.94,31.73 195.94,31.58 195.74,31.38 194.3,31.38 193.98,31.7 193.98,31.81 193.98,31.82 194,32 193.98,32.18 193.98,32.19 193.98,32.49 194.62,33.13 194.62,37.03 194.77,37.18 195.53,37.18
GND on TOP (solid shape): 10.72,80.47 10.72,77.45 11.44,76.73 12.23,76.73 12.98,75.98 12.98,74.69 12.64,74.35 10.2,74.35 10.2,74.83 10.24,74.84 10.69,75.62 10,76.2 1,76.2 0.44,76.44 0.2,77 0.2,78.43 7.28,78.43 9.61,80.76 10.43,80.76
GND on TOP (solid shape): 112.8,80.4 112.8,80.07 112.91,80.07 112.91,79.22 113.41,78.71 113.41,77.25 113.44,77.22 113.44,77.21 113.82,76.83 116.29,76.83 116.62,76.5 116.62,75.39 116.49,75.27 116.14,75.27 116.07,75.33 116.07,75.76 116.06,75.77 116.06,75.82 115.99,75.84 115.99,75.84 115.85,75.98 115.78,75.98 115.77,75.98 115.41,75.98 115.4,75.98 115.38,75.98 115.32,75.91 115.32,75.89 115.32,75.65 115.31,75.59 115.13,75.41 114.98,75.41 114.86,75.49 114.81,75.62 114.81,75.98 114.11,75.98 114.05,75.91 114.05,75.53 113.98,75.47 113.6,75.47 113.48,75.34 113.48,74.77 113.35,74.64 112.4,74.64 112.21,74.83 112.21,78.01 112.4,78.2 112.4,79.03 112.14,79.28 112.14,79.98 112.02,80.1 111.51,80.1 111.38,80.23 111.38,81.06 111.44,81.12 112.08,81.12
GND on TOP (solid shape): 61.22,87.98 61.22,85.31 59.69,83.79 59.69,83.03 60.07,82.64 60.07,82.52 59.82,82.26 59.82,80.36 59.06,79.6 59.06,78.71 59.69,78.07 59.69,77.18 59.57,77.06 57.66,77.06 57.53,77.18 57.53,81.37 58.04,81.88 58.04,84.8 58.93,85.69 58.93,86.84 59.59,86.84 59.59,86.78 59.61,86.73 59.63,86.68 59.65,86.64 59.68,86.59 59.72,86.56 59.77,86.53 59.82,86.5 59.87,86.49 59.92,86.48 59.97,86.48 60.03,86.49 60.08,86.5 60.12,86.53 60.17,86.56 60.21,86.59 60.24,86.64 60.27,86.68 60.29,86.73 60.3,86.78 60.3,86.84 60.3,86.89 60.29,86.94 60.27,86.99 60.24,87.04 60.21,87.08 60.17,87.11 60.12,87.14 60.08,87.17 60.03,87.18 59.97,87.19 59.92,87.19 59.87,87.18 59.82,87.17 59.77,87.14 59.72,87.11 59.68,87.08 59.65,87.04 59.63,86.99 59.61,86.94 59.59,86.89 59.59,86.84 58.93,86.84 58.93,87.34 59.82,88.23 60.96,88.23
GND on TOP (solid shape): 3.99,85.14 4.35,84.74 4.89,84.72 4.92,84.73 5.46,84.19 5.52,84.19 5.73,83.98 6.62,83.98 7,83.79 7.34,83.54 7.65,83.54 9.08,82.11 9.08,80.54 7.16,78.62 0.33,78.62 0.2,78.75 0.2,82.97 0.24,83.23 0.54,83.79 0.6,84.17 0.6,84.37 0.84,84.94 1.4,85.17 3.98,85.17
GND on TOP (solid shape): 55.95,116.75 55.95,116.7 51.64,112.45 47.45,116.82 47.45,118.79 55.95,118.79
GND on TOP (solid shape): 76.78,88.15 76.78,87.41 77.28,86.9 78.61,86.9 78.75,86.86 78.9,86.9 79.06,86.9 79.95,86.01 79.95,84.87 79.59,84.51 77.95,84.51 77.85,84.61 77.85,85.33 77.47,85.72 77.43,85.75 77.39,85.78 76.65,86.52 76.14,86.52 76.05,86.58 76.06,86.69 75.81,87.23 75.56,86.69 75.57,86.58 75.48,86.52 74.04,86.52 73.83,86.73 73.83,88.17 74.3,88.64 76.29,88.64
GND on TOP (solid shape): 47.03,17.13 47.11,17.04 47.2,16.95 47.76,16.38 47.94,16.12 48,15.82 48,8.7 47.76,8.14 47.2,7.9 40.75,7.9 40.19,8.14 39.95,8.7 39.95,12.6 39.86,12.95 39.6,13.21 39.55,13.28 39.58,13.37 40.31,14.1 40.32,14.1 40.68,14.32 40.9,14.68 40.9,14.69 43.34,17.13
GND on TOP (solid shape): 134.86,75.51 134.86,75.03 134.77,74.94 134.64,74.94 134.53,74.82 134.53,74.39 134.36,74.23 134.18,74.23 133.9,73.95 133.9,73.2 134.1,73 134.66,73 134.92,73.26 134.92,73.38 134.94,73.47 134.95,73.55 134.94,73.64 135.09,73.8 135.23,73.8 135.33,73.7 135.33,73.16 135.02,72.85 135,72.85 134.88,72.8 134.8,72.7 134.79,72.7 134.5,72.41 134.28,72.41 134.19,72.32 134.12,72.32 134.12,71.75 134.41,71.45 134.41,71.11 134.29,70.99 134.17,71.01 134.07,70.99 133.95,70.99 133.58,71.36 133.49,71.54 133.3,71.64 132.98,71.96 132.98,72.86 133.4,73.28 133.45,73.32 133.52,73.4 133.52,73.42 133.55,73.55 133.52,73.69 133.52,73.7 133.52,73.85 133.17,74.2 133.17,74.22 133.15,74.38 133.07,74.5 133.07,75.49 133.19,75.61 134.75,75.61
GND on TOP (solid shape): 121.16,81.25 121.16,80.99 121.36,80.79 121.8,80.79 121.93,80.92 121.93,81.26 122.03,81.36 122.29,81.36 122.38,81.27 122.38,81.06 122.52,80.92 122.69,80.92 122.92,80.81 123.16,80.91 123.18,80.92 123.28,80.92 123.55,80.79 123.82,80.92 123.94,80.92 124.17,80.82 124.41,80.92 124.56,80.92 124.81,80.81 125.06,80.92 125.24,80.92 125.43,80.85 125.63,80.91 125.64,80.92 125.67,80.92 125.8,81.05 125.8,81.31 125.86,81.37 126.24,81.37 126.3,81.31 126.3,80.53 126.28,80.52 126.14,80.39 126.09,80.21 126.06,80.14 125.99,80.1 120.21,80.1 120.21,80.74 120.65,80.74 120.72,80.8 120.72,81.25 120.84,81.37 121.03,81.37
GND on TOP (solid shape): 127.36,71.57 127.45,71.52 127.46,71.43 127.44,71.24 127.54,71.07 127.57,70.99 127.44,70.67 127.57,70.36 127.54,70.28 127.45,70.13 127.45,69.95 127.43,69.86 127.35,69.82 127.19,69.82 127.14,69.87 127.15,69.9 127.12,70.23 126.81,70.37 126.78,70.38 126.76,70.41 126.74,70.46 126.7,70.5 126.62,70.67 126.7,70.85 126.76,70.99 126.7,71.14 126.65,71.2 126.63,71.27 126.62,71.31 126.63,71.35 126.63,71.4 126.57,71.46 126.57,71.57
GND on TOP (solid shape): 251.14,71.59 254.67,72.24 256.65,69.25 253.46,66 250.15,69.14 250.25,69.34 250.47,69.86 250.61,70.19 250.71,70.45 250.84,70.77 251.02,71.25
GND on TOP (solid shape): 16.68,39.16 16.68,31.69 16.18,31.19 13.6,31.19 13.6,32.75 13.02,33.44 12.24,32.99 12.23,32.95 9.2,32.95 9.01,32.92 8.84,32.81 8.72,32.68 8.69,32.66 8.65,32.65 4.1,32.65 3.54,32.89 3.3,33.45 3.3,37.35 3.54,37.91 4.1,38.15 8.65,38.15 8.69,38.14 8.72,38.12 8.84,37.99 9.01,37.88 9.2,37.85 12.23,37.85 12.24,37.81 13.02,37.36 13.6,38.05 13.6,39.78 16.05,39.78
GND on TOP (solid shape): 14.11,100.6 16.34,100.6 16.59,100.35 16.59,100.24 16.07,99.72 16.07,97.68 14.66,96.27 14.66,95.97 13.33,94.63 9.53,94.63 9.27,94.9 7.89,94.9 7.07,94.08 5.35,94.08 5.35,94.33 4.77,95.02 3.99,94.56 3.98,94.53 1.4,94.53 0.84,94.76 0.6,95.32 0.6,95.53 0.54,95.91 0.24,96.47 0.2,96.72 0.2,97.7 0.44,98.26 1,98.5 1.1,98.5 1.6,98.7 1.8,99.2 1.8,100.3 1.89,100.51 2.1,100.6 9.49,100.6
GND on TOP (solid shape): 13.89,61.33 13.89,60.83 11.95,58.89 11.95,54.31 13.01,53.24 13.01,53.06 12.98,52.98 12.91,52.95 12.5,52.83 12.24,52.49 12.23,52.45 9.2,52.45 9.01,52.42 8.84,52.31 8.72,52.18 8.69,52.16 8.65,52.15 4.1,52.15 3.54,52.39 3.3,52.95 3.3,53.6 3.54,54.16 4.1,54.4 5.6,54.4 6.45,54.75 6.8,55.6 6.8,56.6 6.45,57.45 5.6,57.8 1,57.8 0.44,58.04 0.2,58.6 0.2,59.6 0.44,60.16 1,60.4 10,60.4 10.69,60.98 10.24,61.76 10.2,61.77 10.2,62.12 13.11,62.12
GND on TOP (solid shape): 123.21,78.78 123.47,79.03 123.72,78.78 123.72,78.38 124.33,78.38 124.49,78.53 124.49,78.78 124.74,79.03 125,78.78 125,78.38 125.61,78.38 125.76,78.53 125.76,78.78 126.02,79.03 126.27,78.78 126.27,78.32 126.02,78.07 126.02,76.93 126.1,76.86 126.1,76.35 125.84,76.1 125.59,76.35 125.59,76.65 125.5,76.74 124.86,76.74 124.86,76.35 124.6,76.1 124.35,76.35 124.35,76.74 123.62,76.74 123.62,76.36 123.37,76.1 123.11,76.36 123.11,76.74 122.38,76.74 122.38,76.35 122.13,76.1 121.88,76.35 121.88,76.74 121.48,76.74 121.48,77.37 121.55,77.37 121.55,77.74 121.52,77.74 121.52,78.38 121.93,78.38 121.93,78.78 122.18,79.03 122.43,78.78 122.43,78.38 123.06,78.38 123.21,78.53
GND on TOP (solid shape): 121.8,71.89 121.89,71.92 121.97,71.85 122.1,71.68 122.31,71.63 122.35,71.62 122.37,71.59 122.39,71.53 122.43,71.48 122.48,71.41 122.51,71.33 122.52,71.19 122.55,71.19 122.59,71.16 122.58,71.1 122.44,70.96 122.41,70.98 122,70.86 122.06,70.43 122.09,70.36 122.06,70.28 121.96,70.13 121.96,69.96 121.96,69.92 121.93,69.9 121.89,69.88 121.86,69.85 121.83,69.82 120.87,69.82 120.79,69.87 120.78,69.96 120.8,70.16 120.71,70.33 120.68,70.4 120.71,70.46 120.78,70.7 120.68,70.92 120.64,70.99 120.68,71.07 120.78,71.24 120.75,71.45 120.76,71.5 120.97,71.52 121.01,71.52 121.06,71.5 121.07,71.45 121.42,70.98 121.6,71.55 121.57,71.62 121.6,71.69 121.62,71.71
GND on TOP (solid shape): outline of 97 points within 114.76,74.43 120.12,83.05
GND on TOP (solid shape): 312.62,54.99 312.73,55.01 312.8,54.92 312.8,54.8 313.38,54.11 314.16,54.56 314.17,54.6 318.69,54.6 322.62,54.6 323.18,54.36 323.41,53.8 323.41,53.15 323.18,52.59 322.62,52.35 320.8,52.35 319.95,52 319.6,51.15 319.6,50.15 319.95,49.3 320.8,48.95 325.8,48.95 326.36,48.71 326.6,48.15 326.6,33.78 326.4,33.26 325.9,32.99 325.53,32.89 325.22,32.67 324.58,32.67 325.11,33.23 325.84,33.5 326.02,33.59 326.09,33.78 326.09,44.24 324.21,46.12 323.97,46.12 323.9,46.12 323.83,46.12 322.99,46.12 320.67,48.44 319.54,48.99 319.09,50.15 319.09,50.57 313.66,50.57 312.6,51.64 312.6,54.97
GND on TOP (solid shape): outline of 215 points within 94.24,95.34 104.9,100.68
GND on TOP (solid shape): 18.88,17.58 18.88,15.87 18.82,15.78 18.72,15.79 17.02,14.9 18.72,14.01 18.82,14.02 18.88,13.93 18.88,13.3 18.83,13.29 18.41,13.05 18.25,12.6 18.25,8.7 18.01,8.14 17.45,7.9 16.44,7.9 16.21,7.94 16,8.03 14.1,8.6 12.2,8.03 11.99,7.94 11.76,7.9 10,7.9 9.15,7.55 8.8,6.7 8.8,5.3 8.56,4.74 8,4.5 1,4.5 0.44,4.74 0.2,5.3 0.2,15.85 0.44,16.41 1,16.65 2.1,16.65 2.95,17 3.54,18.41 4.1,18.65 8.65,18.65 8.69,18.64 8.72,18.62 8.84,18.49 9.01,18.38 9.2,18.35 12.23,18.35 12.24,18.31 13.02,17.86 13.6,18.55 13.6,20.02 16.43,20.02
GND on TOP (solid shape): outline of 93 points within 26.84,83.09 32.6,85.59
GND on TOP (solid shape): outline of 212 points within 39.37,0.25 326.15,24.91
GND on TOP (solid shape): outline of 280 points within 0.25,52.99 326.15,118.8
GND on TOP (solid shape): outline of 2316 points within 15.75,78.99 33.68,91.23
GND on BOTTOM (solid shape): 19.06,26.17 17.84,26.17 17.84,41.29 19.06,41.29
GND on BOTTOM (solid shape): 19.06,42.75 17.84,42.75 17.84,54.79 7.59,54.79 7.59,56.01 19.06,56.01
GND on BOTTOM (solid shape): 12.04,80.26 12.04,78.71 11.63,78.3 10.15,78.3 10.04,78.41 10.04,80.23 10.42,80.61 11.68,80.61
GND on BOTTOM (solid shape): 55.63,63.79 55.63,62.45 55.5,62.32 53.85,62.32 53.72,62.45 53.72,63.79 53.84,63.9 55.51,63.9
GND on BOTTOM (solid shape): 89.28,86.26 89.28,85.57 88.83,85.11 87.1,85.11 87.01,85.2 87.01,86.3 87.09,86.38 89.17,86.38
GND on BOTTOM (solid shape): 89.41,90.87 89.41,89.76 89.23,89.58 87.09,89.58 86.97,89.69 86.97,90.94 87.15,91.12 89.17,91.12
GND on BOTTOM (solid shape): 93.98,77.56 93.98,76.42 93.86,76.29 90.62,76.29 90.55,76.36 90.55,77.5 90.74,77.69 93.86,77.69
GND on BOTTOM (solid shape): 159.39,103.92 159.39,101.28 159.25,101.14 158.2,101.14 158.02,101.31 158.02,103.87 158.24,104.09 159.23,104.09
GND on BOTTOM (solid shape): 166.08,98.35 166.08,97.48 165.86,97.26 164.56,97.26 164.47,97.36 164.47,98.33 164.56,98.42 166.01,98.42
GND on BOTTOM (solid shape): 176.02,108.57 176.02,105.26 175.85,105.09 174.97,105.09 174.65,105.4 174.65,108.49 174.98,108.82 175.77,108.82
GND on BOTTOM (solid shape): 183.67,109.23 183.67,106.03 183.53,105.89 182.53,105.89 182.35,106.06 182.35,109.18 182.55,109.38 183.52,109.38
GND on BOTTOM (solid shape): 189.84,70.4 189.84,68.29 189.52,67.97 186.08,67.97 185.84,68.21 185.84,69.98 186.82,70.96 189.28,70.96
GND on BOTTOM (solid shape): 308.01,53.16 318.05,53.16 318.05,51.94 306.79,51.94 306.79,57.1 308.01,57.1
GND on BOTTOM (solid shape): 308.36,98.65 308.36,95.73 308.1,95.47 306.83,95.47 306.52,95.79 306.52,98.9 306.64,99.03 307.98,99.03
GND on BOTTOM (solid shape): 318.05,70.04 308.01,70.04 308.01,65.99 306.79,65.99 306.79,71.26 318.05,71.26
GND on BOTTOM (solid shape): 19.06,17.06 16.99,17.06 16.99,14.79 7.01,14.79 7.01,16.01 15.77,16.01 15.77,18.28 17.84,18.28 17.84,25.14 19.06,25.14
GND on BOTTOM (solid shape): 89.41,80 89.41,79.36 88.91,78.86 84.75,78.86 84.71,78.9 84.71,80.04 84.77,80.1 89.31,80.1
GND on BOTTOM (solid shape): 24.26,47.72 24.26,45.94 23.83,45.51 23.83,44.42 23.7,44.29 22.99,44.29 22.74,44.54 22.74,47.97 22.86,48.1 23.88,48.1
GND on BOTTOM (solid shape): 73.41,90.19 73.41,88.56 73.2,88.36 71.63,88.36 71.55,88.44 71.55,89.2 71.66,89.3 72.82,89.3 72.98,89.45 72.98,90.24 73.05,90.32 73.28,90.32
GND on BOTTOM (solid shape): 134.8,100.93 134.8,99.49 134.72,99.41 132.55,99.41 132.07,99.89 132.07,101.41 132.14,101.48 134.25,101.48
GND on BOTTOM (solid shape): 189.83,79.41 189.83,77.47 189.83,77.47 189.83,77.29 189.6,77.06 186.43,77.06 184.91,78.58 183.13,78.58 183.01,78.71 183.01,79.34 183.32,79.66 189.58,79.66
GND on BOTTOM (solid shape): 288.17,69.44 288.17,68.64 288.13,68.6 288.13,67.68 287.81,67.36 285.03,67.36 284.93,67.47 284.22,67.47 284.13,67.55 284.13,69.53 284.29,69.69 287.91,69.69
GND on BOTTOM (solid shape): 23.43,54.68 23.43,53.87 23.29,53.73 20.39,53.73 20.28,53.83 20.28,55.05 20.54,55.3 22.82,55.3
GND on BOTTOM (solid shape): 203.46,41.75 203.46,40.61 203.2,40.35 200.28,40.35 199.9,40.73 199.9,41.89 199,42.79 199,43.31 199.51,43.82 201.39,43.82
GND on BOTTOM (solid shape): 41.49,57.97 41.49,52.29 40.87,51.67 40.87,51.67 40.58,51.38 39.12,51.38 38.91,51.59 38.91,52.43 39.19,52.72 39.61,52.72 39.78,52.88 39.78,57.96 39.92,58.1 41.37,58.1
GND on BOTTOM (solid shape): 46.35,98.03 48.74,98.03 48.85,97.91 48.85,97.39 48.65,97.19 48.65,96.08 48.91,95.82 48.91,95.4 48.68,95.18 45.3,95.18 45.18,95.29 45.18,97.93 45.3,98.04 46.33,98.04
GND on BOTTOM (solid shape): 163.94,70.14 165.12,70.14 165.19,70.21 166.57,70.21 166.73,70.05 166.73,68.87 166.46,68.6 164.8,68.6 164.8,68.6 163.96,68.6 163.94,68.6 163.71,68.6 163.49,68.82 163.49,70.07 163.64,70.22 163.87,70.22
GND on BOTTOM (solid shape): 26.06,85.74 26.12,85.74 26.23,85.62 26.23,85.41 25.98,85.15 25.98,84.66 25.61,84.29 25.61,83.86 25.65,83.82 25.65,83.43 25.63,83.41 23.12,83.41 22.74,83.79 22.74,85.69 22.8,85.76 26.04,85.76
GND on BOTTOM (solid shape): 32.23,37.81 32.23,37.31 32.11,37.18 31.12,37.18 30.86,36.92 30.86,35.47 31.07,35.26 32.13,35.26 32.18,35.21 32.18,33.78 32.11,33.7 30.15,33.7 29.92,33.93 29.92,37.83 30.04,37.94 32.11,37.94
GND on BOTTOM (solid shape): 53.72,104.62 53.72,103.68 54.31,103.09 54.84,103.09 54.85,103.08 54.85,101.96 54.66,101.77 53.34,101.77 53.02,101.45 52.06,101.45 51.89,101.62 51.89,102.59 51.7,102.79 51.7,104.48 52.22,105 53.34,105
GND on BOTTOM (solid shape): 16.51,85.12 16.51,82.14 16.44,82.06 15.55,82.06 15.45,82.12 15.33,82.14 15.05,82.14 14.86,82.33 14.86,83.91 14.61,84.17 13.08,84.17 12.83,84.42 12.83,84.75 13.03,84.96 15.01,84.96 15.31,85.25 16.39,85.25
GND on BOTTOM (solid shape): 35.33,47.95 35.33,46.98 35.79,46.53 35.79,43.9 36.42,43.27 36.42,41.97 36.25,41.8 35.13,41.8 34.69,41.36 33.35,41.36 33.09,41.62 33.09,43.01 33.22,43.15 34.67,43.15 35.08,43.57 35.08,45.13 34.7,45.51 34.7,46.5 35.08,46.88 35.08,47.95 35.13,48 35.28,48
GND on BOTTOM (solid shape): 187.12,111.17 187.12,109.63 186.97,109.48 186.35,109.48 186.12,109.25 186.12,108.35 186.04,108.27 186.04,107.71 186.29,107.47 187.06,107.47 187.52,107.02 187.52,105.7 187.43,105.61 185.83,105.61 185.63,105.81 185.63,107.58 185.33,107.87 185.33,109.04 185.41,109.11 185.41,111.17 185.51,111.27 187.02,111.27
GND on BOTTOM (solid shape): 326.2,99.6 325.96,99.04 325.4,98.8 314.88,98.8 314.88,100.22 315.89,101.23 326.2,101.23
GND on BOTTOM (solid shape): 63.04,70.53 64.7,70.53 64.78,70.44 64.78,70.03 64.65,69.89 62.71,69.89 62.64,69.97 62.63,69.97 62.51,70.1 62.45,70.14 62.38,70.18 62.36,70.2 59.31,70.2 59.18,70.33 59.18,71.21 59.57,71.6 60.2,71.6 60.33,71.72 61.85,71.72
GND on BOTTOM (solid shape): 24.83,89.69 24.83,89.31 25.16,88.97 25.17,88.97 25.25,88.89 25.53,88.89 25.57,88.85 25.57,88.25 25.6,88.22 25.6,86.72 25.46,86.58 25.28,86.58 25.15,86.71 25.15,86.96 25.02,87.09 24.01,87.09 23.94,87.15 23.94,87.6 24.24,87.9 24.24,89.7 24.25,89.71 24.8,89.71
GND on BOTTOM (solid shape): 177.14,112.67 177.14,112.16 177.03,112.05 176.6,112.05 175.92,111.37 175.92,110.76 175.64,110.48 171.64,110.48 171.53,110.6 171.53,111.32 171.53,111.32 171.53,112.16 171.64,112.27 173.26,112.27 173.32,112.21 173.32,111.5 173.56,111.26 174.5,111.26 174.61,111.37 175.03,111.37 175.22,111.56 175.22,112.67 175.34,112.78 177.03,112.78
GND on BOTTOM (solid shape): 67.26,77.1 67.26,76.78 67.97,76.07 68.15,76.07 68.16,76.06 68.3,76.03 68.45,76.06 68.46,76.07 68.52,76.07 68.61,75.98 68.61,70.81 68.77,70.64 68.77,70.2 68.56,69.98 66.35,69.98 66.12,70.21 66.12,71.42 66.44,71.74 66.44,75.95 66.4,75.99 66.4,77.17 66.45,77.22 67.13,77.22
GND on BOTTOM (solid shape): 180.42,103.55 180.42,101.03 180.98,100.47 182.69,100.47 183.01,100.15 185.6,100.15 185.69,100.06 185.69,98.28 185.61,98.2 185.41,98.2 185.36,98.25 185.36,99.42 185.22,99.56 183.83,99.56 183.72,99.45 183.72,98.32 183.62,98.22 183.61,98.22 183.34,97.95 181.07,97.95 180.87,98.15 180.87,98.91 180.71,99.07 177.56,99.07 177.36,99.27 177.36,103.33 177.73,103.7 180.27,103.7
GND on BOTTOM (solid shape): 38.61,39.13 38.61,37.71 38.09,37.19 37.79,37.19 37.78,37.2 37.63,37.23 37.49,37.2 37.48,37.19 36.78,37.19 36.36,36.77 36.36,35.44 36.45,35.35 37.24,35.35 37.31,35.27 37.31,35.13 37.26,35.08 35.37,35.08 35.35,35.1 35.35,37.29 35.56,37.5 35.69,37.5 35.82,37.62 35.82,39.21 36.13,39.53 38.21,39.53
GND on BOTTOM (solid shape): 104.6,74.89 105.04,74.89 105.14,74.92 105.28,74.92 105.39,74.88 105.49,74.88 105.56,74.85 105.59,74.79 105.59,74.71 105.37,74.71 105.24,74.65 105.18,74.65 105.05,74.71 103.72,74.71 103.61,74.82 103.61,75.12 103.79,75.29 104.2,75.29
GND on BOTTOM (solid shape): 105.25,66.59 105.33,66.43 105.49,66.35 105.53,66.33 105.54,66.3 105.54,65.89 105.46,65.81 103.88,65.81 103.83,65.84 103.84,65.9 103.88,65.94 103.88,66.44 104.01,66.56 104.56,66.56 104.64,66.64 105.25,66.64
GND on BOTTOM (solid shape): 166.91,104.37 166.91,101.44 166.57,101.11 164.81,101.11 164.81,101.1 164.39,100.68 164.39,100.39 164.28,100.29 163.64,100.29 163.59,100.34 163.59,100.89 163.61,100.91 163.98,100.91 164.05,100.98 164.08,100.98 164.23,101.12 164.24,101.12 164.24,101.14 164.35,101.24 164.35,101.66 164.55,101.87 165.54,101.87 165.79,102.13 165.79,103.04 165.76,103.07 165.76,103.07 164.89,103.95 164.89,104.51 165.05,104.67 166.6,104.67
GND on BOTTOM (solid shape): 28.21,92.5 28.21,90.38 28.29,90.3 28.36,90.3 28.38,90.28 28.68,90.28 28.83,90.14 28.83,89.92 28.73,89.83 28.51,89.83 28.51,89.83 28.38,89.83 28.23,89.68 28.23,89.32 28.08,89.18 27.86,89.18 27.72,89.32 27.72,89.78 27.64,89.86 27.64,90.41 27.48,90.58 26.97,90.58 26.91,90.64 26.91,91.3 27.26,91.65 27.26,92.51 27.36,92.62 28.09,92.62
GND on BOTTOM (solid shape): 70.17,92.32 70.17,86.77 70.48,86.46 70.48,84.69 71.12,84.04 71.57,84.04 72.46,83.15 72.46,82.59 73.17,81.88 73.17,79.3 72.58,78.71 70.36,78.71 69.83,79.24 69.83,81.12 69.01,81.95 69.01,82.8 68.82,82.98 67.72,82.98 66.22,84.48 66.22,87.02 66.39,87.19 68.43,87.19 68.58,87.34 68.58,92.4 68.64,92.45 70.03,92.45
GND on BOTTOM (solid shape): 227.72,31.34 228.04,31.34 228.09,31.29 228.09,30.31 228.07,30.24 228,30.21 227.75,30.04 227.73,29.74 227.72,29.64 227.64,29.6 222.8,29.6 222.7,29.7 222.7,31.22 222.83,31.34 227.71,31.34
GND on BOTTOM (solid shape): 126.48,66.47 126.53,66.34 126.53,66.27 126.47,66.16 126.48,64.93 126.67,64.74 126.67,64.52 126.57,64.43 126.33,64.43 126.17,64.59 126.17,65.26 126.29,65.39 126.29,66.14 126.26,66.24 126.26,66.38 126.3,66.51 126.3,66.59 126.33,66.66 126.4,66.69 126.48,66.69
GND on BOTTOM (solid shape): 85.98,65.77 85.98,64.32 83.7,62.03 83.7,60.59 83.36,60.25 75.74,60.25 75.2,60.8 75.2,65.15 75.22,65.2 75.23,65.25 75.24,65.28 75.48,65.39 75.59,65.63 75.63,65.65 75.7,65.66 75.76,65.71 76.08,66.02 85.73,66.02
GND on BOTTOM (solid shape): 24.27,60.29 24.5,60.2 24.73,60.29 24.86,60.29 25.08,60.2 25.31,60.29 26.29,60.29 26.42,60.17 26.42,59.72 26.26,59.57 25.77,59.57 24.59,58.39 21.27,58.39 20.83,58.83 20.83,59.77 21.13,60.08 23.66,60.08 23.88,60.29
GND on BOTTOM (solid shape): 104.6,72.24 105.05,72.24 105.18,72.29 105.24,72.29 105.37,72.24 105.49,72.24 105.56,72.21 105.59,72.14 105.59,72.07 105.46,72.07 105.24,72.01 105.17,72.01 105.11,72.03 105.06,72.05 104.47,72.05 104.22,71.81 104.03,71.81 103.97,71.84 103.93,71.9 103.85,72.09 103.67,72.2 103.66,72.2 103.61,72.25 103.7,72.33 104.5,72.33
GND on BOTTOM (solid shape): 240.47,28.23 240.47,27.44 242.19,25.72 242.19,25.11 242.16,25.08 242.16,21.86 242,21.7 237.44,21.7 237.15,21.98 237.15,23.26 237.19,23.29 239.54,23.29 239.93,23.69 239.93,23.91 239.99,23.98 239.99,24.76 240.01,24.77 240.01,25.01 239.93,25.09 239.93,25.09 238.95,26.07 237.55,26.07 236.93,26.69 235.67,26.69 235.26,26.28 234.01,26.28 233.62,26.67 232.66,26.67 232.59,26.73 232.59,26.95 232.69,27.05 233.71,27.05 234.18,27.52 237.13,27.52 237.37,27.76 237.37,28.05 237.5,28.18 238.7,28.18 238.94,28.42 240.29,28.42
GND on BOTTOM (solid shape): 90.35,81.31 90.58,81.23 90.8,81.31 91.63,81.31 91.89,81.21 92.15,81.31 93.02,81.31 93.16,81.29 93.29,81.31 94.29,81.31 94.43,81.29 94.56,81.31 94.87,81.31 95,81.18 95,80.1 94.87,79.98 90.24,79.98 90.05,80.17 90.05,81.25 90.11,81.31
GND on BOTTOM (solid shape): 51.18,79.6 52.45,79.6 52.96,79.09 52.96,78.2 53.01,78.15 53.01,78.09 53.07,78.09 53.22,77.95 53.72,77.95 53.85,77.82 55.25,77.82 55.3,77.87 56.77,77.87 56.92,78.02 56.92,79.57 57.05,79.7 59.01,79.7 59.02,79.69 60.11,79.69 60.71,79.09 60.71,76.93 60.45,76.68 59.69,76.68 58.98,77.39 58.5,77.39 58.47,77.41 55.98,77.41 55.63,77.06 55.63,76.29 55.37,76.04 54.87,76.04 54.74,76.17 54.74,76.93 54.49,77.18 53.22,77.18 52.96,77.44 52.96,77.82 52.85,77.93 52.85,77.97 52.14,77.97 52.14,77.95 51.44,77.95 50.29,79.09 50.29,79.72 50.42,79.85 50.93,79.85
GND on BOTTOM (solid shape): 55.63,74.14 55.63,73.97 55.55,73.84 55.54,73.7 55.55,73.67 55.37,73.5 54.87,73.5 54.36,72.99 54.36,71.85 54.42,71.79 54.42,71.71 54.5,71.71 54.61,71.6 54.99,71.6 55.25,71.34 55.25,69.82 55.17,69.82 55.17,69.36 54.87,69.06 53.98,69.06 53.85,69.18 53.34,69.18 52.89,69.64 52.89,69.77 52.76,69.77 52.71,69.82 52.2,69.82 52.15,69.77 52.12,69.77 52.12,69.74 52.07,69.69 52.07,69.31 51.82,69.06 51.31,69.06 50.93,69.44 49.15,69.44 49.02,69.56 49.02,69.94 49.66,70.58 49.66,71.6 49.79,71.72 50.55,71.72 50.68,71.85 50.68,73.12 51.06,73.5 51.06,74.01 51.18,74.14 54.49,74.14 54.74,74.39 55.37,74.39
GND on BOTTOM (solid shape): 75.4,88.29 75.4,86.72 75.47,86.64 75.47,86.63 75.71,86.39 76.67,86.39 76.74,86.46 76.82,86.46 76.87,86.51 76.87,86.92 77,87.04 78.87,87.04 79.81,86.11 79.81,85.53 79.8,85.52 79.8,85.23 79.44,84.87 77.92,84.87 77.55,85.24 77.55,85.48 77.44,85.71 77.19,85.79 77.11,85.79 76.85,86.06 76.74,86.06 76.73,86.06 74.44,86.06 74.43,86.06 73.67,86.06 73.59,86.14 73.59,86.65 73.78,86.85 73.78,87.29 73.89,87.39 73.89,88.28 73.98,88.37 75.32,88.37
GND on BOTTOM (solid shape): 44.13,31.81 44.13,23.17 43.64,22.68 42.45,22.68 42.3,22.82 39.95,22.82 39.6,23.18 39.6,29.34 42.58,29.34 42.59,29.29 42.6,29.24 42.62,29.19 42.64,29.14 42.68,29.1 42.72,29.07 42.76,29.04 42.81,29.01 42.86,29 42.91,28.99 42.96,28.99 43.02,29 43.07,29.01 43.11,29.04 43.16,29.07 43.2,29.1 43.23,29.14 43.26,29.19 43.28,29.24 43.29,29.29 43.29,29.34 43.29,29.4 43.28,29.45 43.26,29.5 43.23,29.54 43.2,29.59 43.16,29.62 43.11,29.65 43.07,29.67 43.02,29.69 42.96,29.7 42.91,29.7 42.86,29.69 42.81,29.67 42.76,29.65 42.72,29.62 42.68,29.59 42.64,29.54 42.62,29.5 42.6,29.45 42.59,29.4 42.58,29.34 39.6,29.34 39.6,31.52 38.71,32.4 38.71,34.03 38.86,34.18 41.76,34.18
