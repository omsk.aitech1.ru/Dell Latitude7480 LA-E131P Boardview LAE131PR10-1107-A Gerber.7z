# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SHD_IO3_R1: length 16
  TOP w0.102: RE372.2 247.36,36.47 RE377.1 246.39,36.56 245.67,35.83 243.69,35.83 243.01,36.52 239.6,36.52 v3(239.3,36.82) 238.82,37.3 236.46,37.3 235.88,36.72 234.28,36.72 RE373.1
SHD_IO3_R2: length 8.1
  TOP w0.102: v3(231.9,36.84) 232.44,36.84 RE373.2 232.84,37.29 v2(233.43,37.88)
  BOTTOM w0.102: UE9.7 234.42,42.47 233.56,41.61 233.56,38.01 v2(233.43,37.88)
SIM_DET: length 57.5
  IN2 w0.102: v2(288.78,69.88) 289.8,69.88 293.82,65.86 293.82,62.96 294.16,62.62 294.75,62.62 294.82,62.69 298.11,62.69 298.64,62.17 298.64,61.5 298.33,61.18 298.33,58.8 299.47,57.66 299.47,57.6 299.95,57.12 301.93,57.12 302.22,57.4 307.21,57.4 308.51,56.1 308.51,49.53 v2(310.2,47.84)
  BOTTOM w0.102: JNGFF2.58 278.2,72.54 278.76,71.98 280.34,71.98 282.16,73.8 286.65,73.8 288.69,71.76 288.69,69.97 v2(288.78,69.88) ; JSIM1.2 307.22,47.31 307.74,47.84 v2(310.2,47.84)
SIO_EXT_SCI#: length 156.5
  TOP w0.102: RC237.1 162.85,61.31 162.38,61.78 162.22,61.78 v1(161.16,62.83) v2(160.73,63.26) ; RE341.1 271.56,34.01 v2(271.66,34.01)
  IN1 w0.076: v2(142.42,71.35) 142.78,70.99 142.78,70.07 143.6,69.25 143.84,69.25 144.06,69.02 144.9,69.02 145.45,68.47
  IN1 w0.102: v2(160.73,63.26) 160.13,62.66 151.86,62.66 147.72,66.8 147.12,66.8 145.45,68.47
  IN2 w0.102: v2(184.43,67.55) 184.43,67.13 189.67,61.89 189.67,61.13 191.1,59.7 191.67,59.7 197.14,54.23 197.82,54.23 207.68,44.36 209.29,44.36 209.29,44.36 221.17,44.36 222.95,42.57 236.76,42.57 237.45,41.89 246.64,41.89 249.26,39.26 250.22,39.26 251.66,37.81 253.05,37.81 253.14,37.9 254.8,37.9 255.5,37.2 257.27,37.2 257.73,36.75 259.55,36.75 260.26,36.03 260.26,35.23 260.92,34.57 263.3,34.57 263.89,35.17 266.19,35.17 266.81,35.78 267.99,35.78 268.67,35.1 268.67,34.42 269.32,33.76 271.41,33.76 v2(271.66,34.01)
  BOTTOM w0.076: v2(142.42,71.35) 142.3,71.35 UC1.AN7
  BOTTOM w0.102: v2(160.73,63.26) 161,63.53 166.75,63.53 167.82,64.61 168.89,64.61 169.58,65.3 180.16,65.3 182.41,67.55 v2(184.43,67.55)
SIO_EXT_SCI#_EC: length 3
  TOP w0.102: UE1.M1 271.22,36.65 271.89,35.98 271.89,35.19 271.18,34.47 RE341.2
SIO_EXT_SMI#: length 212.5
  TOP w0.112: v2(279.21,41.81) 278.97,41.81 278.79,41.99 RE338.1 ; RC346.1 153.49,101.07 152.94,100.52 152.94,95.17 151.22,93.45 149.84,93.45 149.5,93.11 v2(149.5,92.66)
  IN1 w0.119: v2(267.86,63.32) 267.86,63.63 267.65,63.84 262.32,63.84 261.22,62.74 253.27,62.74 252.22,61.69 251.23,61.69 245.72,56.18 245.72,55.97 242.84,53.09 241.01,53.09 239.17,51.25 210.04,51.25 208.55,52.74 208.14,52.74 194.11,66.77 193.25,66.77 191.23,68.79 189.19,68.79 187.23,66.83 182.53,66.83 180.05,69.32 180.05,76.02 181.33,77.3 181.33,86.92 178.95,89.31 176.91,89.31 176.57,89.66 175.54,89.66 173.53,87.65 168.91,87.65 168.13,88.42 168.13,90.19 167.66,90.66 167.66,91.87 165.48,94.04 165.48,94.74 v2(165.36,94.86)
  BOTTOM w0.076: UC1.A6 142.67,88.13 143.13,87.67 143.42,87.67 144.21,88.47 144.21,91.12 144.77,91.67
  BOTTOM w0.112: v2(165.36,94.86) 165.36,94.87 165.14,95.1 153.7,95.1 151.86,93.26 150.64,93.26 150.41,93.03 150.41,92.87 150.21,92.66 v2(149.5,92.66) 145.76,92.66 144.77,91.67 ; v2(279.21,41.81) 279.55,42.15 279.55,43.71 279.31,43.96 278.56,43.96 276.55,45.96 276.55,49.4 276.16,49.8 275.22,49.8 274.52,50.5 274.52,51.92 273.27,53.17 273.27,55.02 272.22,56.08 270.77,56.08 269.3,57.56 269.3,59.7 v1(267.83,61.17) 267.5,61.5 267.5,62.15 267.86,62.51 v2(267.86,63.32)
SIO_EXT_SMI#_EC: length 9.9
  TOP w0.102: RE338.2 v2(276.84,41.99)
  TOP w0.107: 269.62,41.59 269.69,41.59 270.01,41.27 270.01,41.27 v2(270.01,41.27)
  BOTTOM w0.102: v2(276.84,41.99) 275.52,41.99 274.1,40.57 272.36,40.57 272.01,40.92 272.01,41.51 271.53,41.99 270.82,41.99 270.09,41.27 v2(270.01,41.27)
SIO_EXT_WAKE#: length 164.2
  TOP w0.102: v2(148.34,75.79) 148.54,75.58 RC283.1 ; v2(272.81,46.26) 272.54,45.99 271.83,45.99 271.43,45.59 UE1.M12
  IN2 w0.102: v2(180.11,63.48) 180.11,64.18 178.63,65.65 177.07,65.65 173.4,69.32 173.4,69.81 168.79,74.41 168.79,76.04 167.89,76.94 164.85,76.94 163.18,78.61 158.95,78.61 156.19,75.84 156.19,73.3 155.48,72.59 153.88,72.59 152.76,73.71 150.02,73.71 149.14,74.59 149.14,74.98 v2(148.34,75.79) ; v2(190.47,68.32) 190.47,67.84 190.75,67.56 191.83,67.56 210.01,49.38 232.35,49.38 233.34,48.4 236.8,48.4 237.27,48.87 243.71,48.87 250.08,55.24 256.39,55.24 256.51,55.36 263.83,55.36 264.07,55.6 266.82,55.6 267.39,55.03 268.38,55.03 270.44,52.98 270.44,52.5 271.13,51.8 271.13,48.6 272.33,47.4 272.33,47.15 272.81,46.66 v2(272.81,46.26)
  BOTTOM w0.076: v2(148.34,75.79) 148.33,75.77 146.53,75.77 145.82,76.48 UC1.AC1
  BOTTOM w0.102: v2(180.11,63.48) 180.35,63.48 181.36,64.48 v1(185.93,64.48) 186.87,64.48 190.47,68.08 v2(190.47,68.32)
SIO_PWRBTN#: length 271.4
  TOP w0.112: v2(270.02,45.18) 270.02,45.18 269.62,44.79 269.62,44.79
  IN1 w0.119: v2(87.63,91.66) 88.16,91.14 90.85,91.14 91.75,92.03 99.96,92.03 100.52,91.47 101.11,91.47 101.12,91.46 101.45,91.46 101.45,91.47 101.92,91.47 102.44,91.99 108.1,91.99 108.91,92.8 109.68,92.8 110.13,92.35 110.66,92.35 110.96,92.06 110.96,91.9 111.17,91.7 111.41,91.7 111.89,91.22 111.89,89.63 112.97,88.55 113.92,88.55 114.56,87.92 115.76,87.92 116.63,87.05 116.63,86.47 116.4,86.24 116.4,84.71 116.64,84.47 117.86,84.47 117.87,84.47 120.86,84.47 121.41,83.91 126.94,83.91 127.32,83.53 127.32,83.26 127.53,83.04 127.53,79.89 127.94,79.49 128.26,79.49 128.58,79.17 129.98,79.17 129.99,79.15 131.13,79.15 132.27,78.01 132.27,74.2 132.8,73.67 132.8,73.12 132.72,73.04 132.72,68.34 133.35,67.71 133.35,65.77 136.35,62.77 138.65,62.77 139.65,61.77 139.65,60.32 140.06,59.91 v2(140.16,59.91) 140.34,59.73 140.34,58.68 141.07,57.95 141.07,57.09 142.8,55.35 146.08,55.35 147.07,54.35 149.19,54.35 156.42,47.12 188.01,47.12 189.18,45.95 189.95,45.95 195.81,40.09 196.41,40.09 197.18,39.33 197.18,39.33 199.19,37.31 200.19,36.32 202.19,36.32 202.46,36.05 203.29,36.05 203.34,36.05 203.99,35.4 203.99,34.61 204.84,33.75 205.67,33.75 205.9,33.98 214.34,33.98 217.7,33.98 218.69,34.97 229.61,34.97 230.6,33.97 230.63,33.97 230.64,33.96 231.47,33.96 233.61,33.96 233.63,33.94 235.17,33.94 235.99,33.13 236.82,33.13 236.82,33.13 238.7,33.13 240.03,31.79 241.24,31.79 243.07,29.97 244.9,29.97 245.21,30.27 246.48,30.27 246.71,30.04 258.44,30.04 258.67,30.27 258.67,30.68 258.92,30.93 259.58,30.93 259.91,30.61 263.29,30.61 264.17,31.49 265.25,31.49 v2(265.65,31.89)
  IN2 w0.124: v2(270.02,45.18) 270.02,44.93 270.46,44.5 270.46,42.25 271.23,41.48 271.23,40.25 271.05,40.07 270.68,40.07 270.44,39.83 270.44,36.21 270.77,35.88 270.77,35.01 271.27,34.51 271.71,34.51 272.05,34.17 272.05,33.7 270.99,32.65 266.41,32.65 v2(265.65,31.89)
  IN3 w0.135: v2(87.63,91.66) 86.93,92.36 85.35,92.36 84.33,93.38 80.96,93.38 80.94,93.39 80.03,93.39 v2(79.63,93)
  BOTTOM w0.076: v2(140.16,59.91) 139.83,60.24 139.83,61.46 136.7,64.59 136.7,66.37 UC1.BA15
  BOTTOM w0.112: v2(79.63,93) 79.8,93.16 v1(79.8,94.13) 79.8,94.56 80.22,94.98 80.22,96.7 79.42,97.5 79.33,97.5 79.24,97.59 RC241.1 78.29,97.59 78.28,97.58 CC269.1 77.79,98.3 77.33,98.76 77.33,99.95 76.81,100.48 JXDP1.41
SIO_RCIN#: length 171.3
  TOP w0.112: RE339.1 278.08,37.71 v2(278.08,37.2) ; RC13.1 145.83,55.76 v2(145.83,56.28)
  IN1 w0.119: v2(274.26,31.35) 274.26,31.82 273.65,32.43 271.2,32.43 271.08,32.54 269.45,32.54 268.06,33.92 267.29,33.92 266.59,34.62 261.92,34.62 261.89,34.6 257.16,34.6 256.74,34.17 253.86,34.17 253.52,33.83 251.09,33.83 250.88,34.04 249.95,34.04 248.88,32.97 245.25,32.97 244.66,32.39 240.14,32.39 238.9,33.63 236.61,33.63 236.19,33.63 235.36,34.46 231.27,34.46 230.85,34.46 230.84,34.47 230.81,34.47 229.81,35.47 228.84,35.47 218.48,35.47 217.49,34.48 214.54,34.48 205.76,34.48 205.03,35.21 204.32,35.92 203.69,36.55 203.09,36.55 202.67,36.55 201.41,37.81 199.4,37.81 199.4,37.81 196.62,40.59 196.02,40.59 190.16,46.45 189.38,46.45 188.21,47.62 156.63,47.62 149.4,54.85 147.28,54.85 145.85,56.28 v2(145.83,56.28)
  BOTTOM w0.076: UC1.AW13 138.2,67.84 138.02,67.66 138.02,67.66 137.8,66.96 137.8,66.88 137.75,66.72 137.75,66.58 137.81,66.36 137.81,66.24 137.76,66.13 137.76,65.76 137.9,65.63 137.9,64.15 139.11,62.94 139.29,62.94 140.57,61.67 140.57,61.37 141.07,60.87 141.07,59.27 141.29,59.05
  BOTTOM w0.112: v2(278.08,37.2) 278.08,36.43 277.09,35.44 277.09,34.59 277.88,33.79 277.88,32.62 276.98,31.72 274.68,31.72 274.31,31.35 v2(274.26,31.35) ; v2(145.83,56.28) 145.83,56.51 143.71,58.63 141.71,58.63 141.29,59.05
SIO_RCIN#_EC: length 6.2
  TOP w0.112: UE1.N3 v3(273.39,38.39) 273.52,38.39 273.7,38.21 273.92,38.21 274.46,38.74 277.34,38.74 277.76,38.32 RE339.2
SIO_SLP_A#: length 287.2
  TOP w0.112: UE1.M11 271.62,45.19 v2(272.33,45.19)
  IN1 w0.084: 136.95,66.78 136.55,67.18 136.55,68.12 136.36,68.31 136.36,69.68 135.6,70.44 135.6,70.91 v2(136,71.31)
  IN1 w0.119: v2(272.86,35.57) 272.86,35.63 272.05,36.44 270.78,36.44 270.43,36.1 268.83,36.1 267.99,36.94 256.37,36.94 255,35.56 251.03,35.56 250.76,35.29 249.32,35.29 249.02,34.98 240.89,34.98 240.48,35.39 239.56,35.39 239.25,35.08 237.7,35.08 237.39,35.39 236.25,35.39 235.92,35.72 231.33,35.72 230.33,36.72 229.36,36.72 217.96,36.72 217.46,36.21 216.97,35.72 215.06,35.72 215.06,35.73 206.28,35.73 206.16,35.85 205.8,36.21 204.21,37.8 203.19,37.8 201.92,39.06 201.32,39.06 201.32,39.06 199.92,39.06 199.92,39.06 197.14,41.84 196.53,41.84 190.02,48.36 189.24,48.36 188.73,48.87 172.92,48.87 171.45,50.33 164.32,50.33 163.85,49.86 156.82,49.86 152.86,53.82 152.86,54.09 147.99,58.96 147.99,59.32 144.38,62.93 143.76,62.93 143.09,63.59 142.42,63.59 141.78,64.23 141.17,64.23 140.79,64.61 140.79,65.4 140.34,65.86 139.32,65.86 138.47,66.71 137.02,66.71 136.95,66.78
  IN2 w0.124: v2(272.86,35.57) 272.06,36.37 272.06,39.22 272.53,39.69 272.53,43.42 273.01,43.89 273.01,44.34 272.33,45.01 v2(272.33,45.19)
  IN3 w0.135: v2(272.33,45.19) 273.9,45.19 276.81,48.1 276.81,51.02 278.11,52.31 278.11,52.62 278.47,52.98 278.47,54.05 279.32,54.9 281.67,54.9 282.69,55.91 284.15,55.91 285.59,54.46 292.71,54.46 293.23,54.98 293.74,54.98 295.23,56.47 295.23,60.25 295.57,60.6 295.57,62.41 295.2,62.78 295.2,65.18 296.16,66.14 296.16,70.45 297.06,71.34 297.94,71.34 298.45,70.83 299.28,70.83 299.68,70.44 300.45,70.44 301.56,71.55 301.56,73.19 299.41,75.35 294.82,75.35 289.82,80.36 289.82,86.45 289.12,87.15 v2(289.12,98.01)
  BOTTOM w0.076: UC1.AN16 v2(136,71.31)
  BOTTOM w0.112: JAPS1.6 314.85,103.97 313.96,104.86 307.89,104.86 303.07,100.04 291.15,100.04 v2(289.12,98.01)
SIO_SLP_LAN#: length 270.2
  TOP w0.102: UZ2.5 301.84,60.3 302.52,59.62 v2(302.77,59.62) ; RC344.1 RC68.1 170.93,47.9 170.46,47.43 165.39,47.43 164.59,48.23 164.59,49.88 164.34,50.13 ; v2(284.35,45.88) 284.14,45.67 284.14,41.9 283.76,41.52 v1(283.76,41.41) 283.76,39.57 282.67,38.47 280.29,38.47 279.99,38.17 279.99,32.78 280.72,32.05 280.72,26.65 276.64,22.57 v2(276.64,22.51) ; 164.34,50.13 163.96,49.75 158.65,49.75 155.23,53.17 155.23,55.1 154.45,55.88 148.63,55.88 v2(148.34,56.17) ; 164.34,50.13 164.34,50.46 162.38,52.42 161.99,52.42 v2(160.68,53.73)
  TOP w0.107: v2(268.43,43.59) UE1.H9
  IN1 w0.102: v2(268.43,43.59) 268.83,43.99 268.83,44.53 269.09,44.79 273.52,44.79 273.77,45.04 275.26,45.04 275.5,44.79 276.17,44.79 277.01,45.63 278.77,45.63 279.01,45.88 v2(284.35,45.88) 287.57,45.88 289.7,48 289.7,49.5 291.6,51.41 291.6,53.99 293.9,56.29 293.9,56.48 296.59,59.17 v2(296.59,59.3)
  IN2 w0.102: v2(180.95,57.75) 180.95,56.89 183.97,53.87 184.76,53.87 198.75,39.87 198.75,39.74 199.51,38.98 201.04,38.98 204.37,35.66 206.86,35.66 208.38,34.13 214.94,34.13 217.16,31.91 227.46,31.91 229.05,30.32 232.78,30.32 233.47,29.64 237.86,29.64 238.24,29.26 245.96,29.26 246.42,28.8 248.13,28.8 248.96,27.97 248.96,25.79 251.84,22.9 252.64,22.1 256.85,22.1 258.54,23.78 259.88,23.78 261.34,22.32 268.4,22.32 268.98,21.75 276.02,21.75 276.64,22.37 v2(276.64,22.51)
  BOTTOM w0.076: UC1.AW15 136.92,67.79 137.08,67.63 137.08,67.64 137.24,67.3 137.24,65.83 137.08,65.67 137.08,64.74 140.36,61.46 140.36,61.29 140.9,60.75 140.9,58.59 141.29,58.2
  BOTTOM w0.102: 141.29,58.2 141.39,58.1 142.97,58.1 143.59,57.48 143.59,56.26 144.87,54.98 147.4,54.98 148.34,55.92 v2(148.34,56.17) ; v2(180.95,57.75) 178.71,57.75 173.41,52.45 164.31,52.45 163.36,53.4 163.36,53.79 163.05,54.1 162.05,54.1 161.8,53.85 161.8,53.44 161.66,53.29 161.12,53.29 v2(160.68,53.73) ; v2(302.77,59.62) 302.35,59.2 296.69,59.2 v2(296.59,59.3)
SIO_SLP_S0#: length 408.6
  TOP w0.102: v2(299.21,105.19) 298.45,104.43 270.51,104.43 269.24,103.16 v2(269.05,103.16) ; v2(132.78,110.65) 133.31,110.65 134.51,111.85 154.24,111.85 158.38,107.71 159.08,107.71 159.28,107.51 159.82,107.51 161.03,106.3 161.03,105.42 161.89,104.57 164.91,104.57 165.01,104.67 166.06,104.67 168.34,102.39 169.23,102.39 170.65,100.98 173.44,100.98 175.53,98.89 175.53,94.69 175.73,94.49 175.73,94.37 175.96,94.14 v2(175.96,93.88) 175.96,93.21 178.9,90.26 180.11,90.26 188.73,81.64 188.73,76.25 189.54,75.45 189.54,71.06 200.12,60.49 201.07,59.06 217.7,42.43 229.21,42.43 229.26,42.46 231.22,42.46 234.83,46.07 234.83,48.15 236.58,49.9 240.56,49.9 244.8,54.15 245.63,54.15 249.76,58.28 249.76,62.83 251.48,64.55 255.59,64.55 258.07,67.02 258.07,72.42 257.05,73.44 257.05,77.19 261.81,81.95 v2(261.81,89.06) ; v2(173.77,75.55) 174.07,75.55 174.46,75.93 176.05,75.93 176.78,75.2 176.98,75.2 176.98,75.2 177.87,75.2 178.09,74.98 178.09,74.66 177.77,74.34 177.77,73.57 177.55,73.34 177.22,73.34 175.22,71.34 175.22,65.39 174.27,64.44 174.27,63.62 170.44,59.78 168.09,59.78 167.52,59.22 164.15,59.22 164.08,59.15 159.58,59.15 158.37,60.36 153.3,60.36 151.32,62.34 150.77,62.34 147.69,65.42 145.94,65.42 144.63,66.73 140.44,66.73 139.27,67.89 139.27,68.86 v2(138.75,69.38)
  IN1 w0.102: v2(178.23,109.82) 180.38,107.68 180.38,107.28 181.65,106.01 184.35,106.01 v2(184.93,105.43) ; v2(261.81,89.06) 261.81,95.92 v2(269.05,103.16) ; v2(173.77,75.55) 172.08,75.55 v2(168.83,78.8)
  IN2 w0.102: 166.06,82.02 167.01,82.97 167.01,90.9 v2(166.77,91.14) ; 166.06,82.02 166.06,81.18 167.51,79.73 167.9,79.73 v2(168.83,78.8) ; 166.06,82.02 165.28,82.02 165.05,81.79 159.13,81.79 158.52,82.4 v2(158.41,82.4)
  IN3 w0.102: v2(319.35,102.45) 318.38,103.41 302.52,103.41 300.74,105.19 v2(299.21,105.19)
  BOTTOM w0.076: v2(138.75,69.38) 138.75,69.38 138.75,69.37 138.82,69.37 UC1.AT11
  BOTTOM w0.102: v2(132.78,110.65) 132.78,110.58 133.54,109.82 133.54,107.3 134.33,106.52 134.88,106.52 135.21,106.19 UZ35.1 ; v2(166.77,91.14) 167.91,92.28 168.67,92.28 170.2,93.81 172.21,93.81 172.69,94.29 175.56,94.29 v2(175.96,93.88) 176.34,93.88 176.58,94.13 176.58,101.36 177.09,101.87 v1(177.09,107.28) 177.09,108.41 178.23,109.56 v2(178.23,109.82) 178.01,110.05 PR426.1 ; v2(184.93,105.43) 185.17,105.67 PR425.1 ; JAPS1.15 v2(319.35,102.45) ; RZ363.1 v2(158.41,82.4) ; RZ112.1 169.04,79.01 v2(168.83,78.8)
SIO_SLP_S3#: length 563
  TOP w0.076: 25.11,79.75 25.11,79.92 25.28,80.09 25.28,80.85 25.5,81.06 25.5,81.64 UT1.D2
  TOP w0.102: v2(265.32,53.76) 264.93,53.37 v1(264.42,53.37) 263.96,53.83 260.92,53.83 259.72,52.63 UE3.2 259.72,52.45 259.72,52.01 259.45,51.74 258.11,51.74 257.65,52.2 UE5.1 257.65,53.54 257.1,54.08 254.65,54.08 254.32,53.75 254.32,52.77 254.4,52.69 RE280.1 254.12,52.28 248.71,46.87 248.71,42.84 249.28,42.28 249.28,40.66 249.74,40.19 v2(249.85,40.19)
  TOP w0.107: v2(270.02,43.59) 269.62,43.19
  TOP w0.112: 25.11,79.75 25.11,79.29 24.81,78.99 v2(24.81,78.54)
  IN1 w0.076: 145.45,63.65 144.99,63.65 144.99,63.63 144.47,63.11 143.84,63.11 143.13,63.82 142.57,63.82 141.78,64.61 141.78,65.07 140.36,66.5 139.18,66.5 138.49,67.18 137.3,67.18 137.04,67.45 137.04,68.37 137.19,68.52 137.28,68.61 137.28,70.32 v2(136.89,70.71)
  IN1 w0.102: 145.45,63.65 146.33,63.65 153.87,56.12 160.57,56.12 161.67,55.01 161.67,52.93 162.56,52.04 172.5,52.04 172.59,51.95 180.11,51.95 181.49,50.56 189.43,50.56 189.95,50.05 190.72,50.05 197.24,43.54 197.84,43.54 200.62,40.76 202.63,40.76 203.89,39.49 204.91,39.49 206.15,38.25 210.58,38.25 211.41,37.42 215.76,37.42 216.27,37.42 217.26,38.41 230.19,38.41 230.4,38.62 236.1,38.62 236.74,37.98 238.97,37.98 239.44,37.51 241.33,37.51 241.76,37.94 244.75,37.94 244.78,37.97 246.67,37.97 247.42,38.73 247.97,38.73 249.44,40.19 v2(249.85,40.19) ; v2(163.34,75.46) 162.84,75.95 162.84,78.96 162.72,79.09 161.74,79.09 160.54,80.3 160.54,85.3 163.28,88.05 163.28,92.67 162.81,93.14 162.81,94.41 160.15,97.07 160.15,100.55 159.62,101.09 159.62,105.12 v2(160.65,106.15) ; v2(312.59,101.94) 312.21,101.57 289.97,101.57 287.48,99.08 287.48,95.9 281.97,90.39 281.97,77.7 282.41,77.25 282.41,72.05 282.69,71.77 282.69,71.14 287.05,66.78 288.17,66.78 288.52,66.44 289.13,66.44 290.05,65.52 294,65.52 296.86,62.66 296.86,61.09 297.03,60.92 297.03,59.21 296.51,58.68 296.39,58.68 294.11,56.4 294.11,56.21 291.81,53.91 291.81,51.33 289.9,49.42 289.9,47.92 287.66,45.68 286.22,45.68 285.73,45.19 283.97,45.19 283.48,45.68 279.1,45.68 278.85,45.43 277.09,45.43 276.19,44.52 275.49,44.52 275.17,44.83 273.85,44.83 273.6,44.59 271.74,44.59 271.16,44.01 270.71,44.01 270.28,43.59 v2(270.02,43.59)
  IN2 w0.102: v2(270.02,43.59) 269.62,43.99 269.62,46.38 269.36,46.64 269.36,49.33 268.39,50.3 268.39,52.3 266.93,53.76 v2(265.32,53.76) ; v2(160.65,106.15) 159.64,107.16 158.88,107.16 158.63,107.41 158.06,107.41 151.38,114.09 122.94,114.09 120.41,111.56 117.9,111.56 117.72,111.74 102.61,111.74 102.32,111.45 92.27,111.45 92.06,111.23 78.75,111.23 77.12,112.86 71.73,112.86 70.31,114.28 63.09,114.28 58.18,109.37 40.76,109.37 37.06,105.67 35.7,105.67 35.03,105 35.03,103.18 33.31,101.47 30.98,101.47 29.46,99.94 29.46,98.74 31.29,96.9 31.29,94.88 33.99,92.19 33.99,83.67 34.73,82.92 35.25,82.92 35.77,82.41 35.77,81.45 36.45,80.76 36.72,80.76 37.24,80.25 37.24,79.33 36.88,78.98 35.45,78.98 34.65,79.77 33.49,79.77 31.96,81.3 26.8,81.3 26.36,80.86 26.36,80.1 v2(24.81,78.54) ; v2(136.89,70.71) 139,70.71 139.23,70.93 139.23,72.15 139.42,72.34 140.24,72.34 140.62,72.71 144.43,72.71 145.25,71.9 147.96,71.9 148.25,71.61 152.26,71.61 152.43,71.44 157.38,71.44 158.1,72.17 158.1,74.33 158.56,74.79 162.41,74.79 163.08,75.46 v2(163.34,75.46)
  BOTTOM w0.076: UC1.AP15 137.3,71.05 136.89,70.71 v2(136.89,70.71)
  BOTTOM w0.102: JAPS1.2 312.85,102.2 v2(312.59,101.94) ; v2(249.85,40.19) 249.51,39.85 249.51,34.84 248.44,33.78 246.03,33.78 245.85,33.95 245.85,34.84 245.63,35.06 245.03,35.06 244.88,34.92 242.81,34.92 QE11.2
SIO_SLP_S4#: length 614.8
  TOP w0.102: PR513.1 201.08,23.97 201.08,27.74 v2(200.2,28.62) ; v2(188.44,30.22) 188.36,30.3 188.36,34.99 188.08,35.27 188.08,38.41 187.45,39.04 187.45,40.45 187.94,40.94 188.81,40.94 189.05,41.18 189.05,46.45 v1(188.41,47.08) UZ34.2 188.41,49.49 187.45,50.45 187.45,50.59 187.4,50.64 187.4,51.32 187.42,51.33 187.42,52.1 187.43,52.12 187.43,52.38 187.45,52.41 187.45,60.26 v2(188.46,61.26) ; PR208.1 39.98,37.67 39.37,37.06 39.04,37.06 v2(39.03,37.08) ; v2(273.04,45.59) UE1.N12
  IN1 w0.102: v2(251.09,22.73) 251.09,22.43 252.04,21.48 255.58,21.48 256.55,22.45 259.1,22.45 260.28,21.27 274.35,21.27 v2(275.27,22.19) ; v2(273.04,45.59) 274.12,45.59 275.55,47.02 280.38,47.02 280.91,46.49 284.18,46.49 284.42,46.25 285.89,46.25 v2(286.23,46.6) 287.51,46.6 287.72,46.81 287.72,46.81 288.49,47.57 288.49,48.58 291.4,51.5 291.4,54.07 293.7,56.37 293.7,56.57 295.46,58.32 295.46,59.17 296.5,60.22 296.5,62.74 293.92,65.31 289.97,65.31 289.05,66.23 288.44,66.23 288.09,66.58 286.97,66.58 282.49,71.06 282.49,71.68 282.21,71.96 282.21,77.17 281.76,77.61 281.76,90.57 283.55,92.36 283.55,99.7 286.21,102.35 306.96,102.35 307.36,101.95 311.66,101.95 312.04,102.33 312.04,102.35 v2(313.75,102.35)
  IN2 w0.102: v2(188.46,61.26) 188.36,61.26 185.27,64.36 185.17,64.36 181.61,67.91 181.61,68.43 177.65,72.39 177.65,72.58 175.75,74.47 175.4,74.47 174.75,75.12 174.75,76.17 170.25,80.68 170.25,87.03 170.48,87.26 170.48,91.12 170.97,91.61 170.97,93.07 170.57,93.47 165.93,93.47 163.35,96.04 162.16,96.04 160.93,97.27 159.74,97.27 157.12,99.9 157.12,101.09 150.27,107.93 141.25,107.93 140.47,108.71 137.51,108.71 137.36,108.87 134.33,108.87 133.92,108.46 133.92,108.27 131.48,105.83 131.48,105.01 v2(131.26,104.79) 129.4,106.64 126.65,106.64 125.99,107.31 122.48,107.31 120.2,105.02 119.5,105.02 118.77,104.29 108.73,104.29 106.98,104.29 106.57,103.88 97.7,103.88 96.88,104.7 76.64,104.7 74.99,103.06 71.87,103.06 71.13,103.8 59.87,103.8 58.73,102.67 54.24,102.67 52.43,104.48 47.41,104.48 45.11,102.18 45.11,99.85 43.77,98.5 43.77,94.94 43.16,94.33 43.16,87.67 43.31,87.53 43.31,84.02 43.43,83.9 43.43,76.16 44.16,75.42 44.16,71.8 45.08,70.88 45.08,65.96 43.68,64.55 43.68,56.79 44.24,56.23 44.24,55.75 44.02,55.53 43.59,55.53 41.04,52.99 41.04,40.23 39.78,38.96 39.78,37.83 v2(39.03,37.08) ; v2(200.2,28.62) 200.67,29.1 218.44,29.1 221.05,31.7 227.16,31.7 228.86,30 232.81,30 233.38,29.43 237.78,29.43 238.15,29.06 245.88,29.06 246.9,28.04 248.52,28.04 248.65,27.91 248.65,25.17 v2(251.09,22.73)
  IN3 w0.102: v2(188.44,30.22) 188.44,28.82 189,28.27 191.6,28.27 193.91,25.96 194.86,25.96 196.6,27.71 199.28,27.71 v2(200.2,28.62)
  BOTTOM w0.076: UC1.BA16 136.37,66.93 136.37,64.4 139.47,61.29 139.47,59.29 141.23,57.53 141.23,56.82
  BOTTOM w0.102: v2(131.26,104.79) 131.33,104.86 131.33,104.91 131.61,105.19 UZ21.4 ; v2(286.23,46.6) 286.23,42.57 285.27,41.61 285.27,34.17 283.88,32.79 281.51,32.79 280.85,32.12 280.85,28.71 281.17,28.39 281.17,27.07 280.08,25.98 277.5,25.98 276.42,24.89 276.42,23.16 275.45,22.19 v2(275.27,22.19) ; v2(313.75,102.35) 314.35,102.95 JAPS1.5 ; 141.23,56.82 141.23,56.08 143.47,53.84 148.64,53.84 149.14,54.34 155.55,54.34 157.97,51.92 163.11,51.92 163.8,51.23 178.72,51.23 179.41,51.92 183.45,55.96 183.45,57.17 180.28,60.34 180.28,61.22 180.86,61.8 187.91,61.8 v2(188.46,61.26)
SIO_SLP_S5#: length 328.4
  TOP w0.102: v2(259.3,49.46) 259.34,49.5 259.84,49.5 259.96,49.38 260.75,49.38 261.14,49.77 261.14,50.48 260.8,50.82 260.8,51.86 261.62,52.69 261.62,53.46 261.79,53.63 263.78,53.63 264.02,53.39 264.02,53.26 264.27,53.02 265.4,53.02 267.34,54.96 267.34,55.47 v2(267.85,55.97) ; v2(190.91,67.96) 191.05,67.83 191.19,67.83 196.47,62.54 196.47,57.37 209.74,44.1 209.74,37.18 210.31,36.61 215.39,36.61 216.64,37.86 226.32,37.86 229.44,40.97 230.96,40.97 235.76,45.77 239.98,45.77 240.7,46.48 v2(242.51,46.48)
  TOP w0.107: v2(273.25,42.57) 272.21,42.57 UE1.N8
  IN1 w0.102: v2(313.22,101.9) 312.5,101.19 289.94,101.19 287.77,99.02 287.77,95.72 282.17,90.13 282.17,77.78 282.62,77.34 282.62,72.13 282.89,71.85 282.89,71.23 287.14,66.99 288.26,66.99 288.6,66.64 289.22,66.64 290.12,65.74 294.08,65.74 297.07,62.74 297.07,61.27 297.24,61.1 297.24,59.12 296.59,58.48 296.48,58.48 294.31,56.31 294.31,56.12 292.01,53.82 292.01,51.24 290.1,49.34 290.1,47.83 287.74,45.47 286.49,45.47 285.86,44.84 283.99,44.84 283.36,45.47 279.22,45.47 278.92,45.17 277.14,45.17 276.26,44.29 275.32,44.29 275.01,44.6 274.13,44.6 273.09,43.56 273.09,42.73 v2(273.25,42.57)
  IN2 w0.102: v2(267.85,55.97) 268.23,55.97 271.58,52.63 271.58,50.25 273.43,48.39 273.43,43.67 273.06,43.29 273.06,42.77 v2(273.25,42.57)
  BOTTOM w0.076: UC1.AY16 136.34,67.42 136.04,67.12 136.04,66.69 136.21,66.53 136.21,64.31 139.3,61.22 139.3,59.22 140.96,57.55 140.96,56.82
  BOTTOM w0.102: v2(190.91,67.96) 190.88,67.96 190.45,67.53 190.45,63.02 191.33,62.15 191.33,61.5 190.25,60.42 188,60.42 186.82,61.6 180.95,61.6 180.49,61.14 180.49,60.43 183.66,57.26 183.66,55.88 178.8,51.02 163.72,51.02 163.03,51.72 148.86,51.72 147.78,52.8 144.05,52.8 140.96,55.89 140.96,56.82 ; v2(242.51,46.48) 242.51,46.77 242.7,46.96 251.17,46.96 253.06,48.84 256.61,48.84 257.29,48.16 257.52,48 257.92,47.85 258.57,47.85 258.94,48.22 258.94,49.1 v2(259.3,49.46) ; v2(313.22,101.9) 313.22,102.42 313.85,103.05 JAPS1.4
SIO_SLP_SUS#: length 503.3
  TOP w0.102: v2(273.41,22.55) 273.41,21.76 272.77,21.12 263.02,21.12 v1(260.61,23.54) 259.5,24.64 257.57,24.64 254.87,21.95 244.16,21.95 243.38,22.72 242.73,22.72 242.33,23.12 242.33,24.93 241.14,26.12 241.14,29.34 240.43,30.05 240.09,30.05 240.09,30.05 236.36,30.05 235.1,31.31 233.36,31.31 230.91,33.75 217.02,33.75 216.71,33.44 207.43,33.44 205.47,35.4 204.45,35.4 RZ64.1 203.89,35.08 203.89,36.75 201.02,39.62 201.02,41.35 197.41,44.96 v2(197.41,45.43) ; v2(179.26,68.1) 180.84,66.52 181.1,66.52 181.21,66.41 181.32,66.41 185.51,62.23 185.51,60.3 187.19,58.61 187.19,50.17 187.76,49.61 UZ34.1 187.76,42.3 v2(188.24,41.82) ; v2(278.82,37.2) 278.82,37.7 279.1,37.98 279.1,38.88 RE349.1 ; v2(168.15,98.65) 167.97,98.65 165.93,96.61 162.79,96.61 v2(160.68,94.5) 160.68,80.75 163.69,77.74 v2(163.69,76.45)
  TOP w0.254: PR1315.1 43.52,45.47 v2(43.36,45.31)
  IN1 w0.102: v2(189.99,96.11) 189.99,93.36 188.88,92.25 182.48,92.25 180.71,94.01 178.76,94.01 177.24,95.54 172.08,95.54 169.31,98.3 168.5,98.3 v2(168.15,98.65)
  IN2 w0.102: v2(43.36,45.31) 44.65,46.6 44.65,49.72 46.63,51.7 46.63,53.27 45.73,54.17 45.73,59.91 47.2,61.38 47.2,64.6 47.9,65.3 47.9,66.6 48.59,67.29 48.59,76.37 47.15,77.81 47.15,85.17 47.72,85.74 47.72,88.17 47.08,88.8 47.08,101.45 48.87,103.24 51.19,103.24 53.27,101.16 56.71,101.16 56.98,101.43 61.85,101.43 62.32,101.9 68.3,101.9 68.47,101.72 68.47,100.75 69,100.22 75.27,100.22 76.37,101.31 97.07,101.31 97.83,100.55 98.82,100.55 99.26,100.11 102.04,100.11 102.66,99.49 105.12,99.49 107.52,101.9 119.24,101.9 120.34,103 122.33,103 123.9,104.57 128.3,104.57 130.55,102.31 132.56,102.31 134.93,104.68 134.93,105.19 135.65,105.9 149.31,105.9 150.35,104.87 150.35,103.82 150.81,103.37 152.43,103.37 155.42,100.38 155.42,99.22 159.05,95.6 160.02,95.6 160.68,94.93 v2(160.68,94.5) 161.23,94.5 164,91.73 167.2,91.73 167.42,91.51 167.42,82.61 168.1,81.93 168.1,80.35 169.41,79.04 169.41,78.24 169.72,77.93 170.55,77.93 171.71,76.78 171.71,74.68 173.67,72.72 173.76,72.72 175.72,70.76 176.6,70.76 v2(179.26,68.1) ; v2(179.03,111.49) 179.03,111.02 178.72,110.71 178.72,109.73 177.8,108.81 177.8,106.14 180.09,103.85 181.68,103.85 182.24,103.29 187.21,103.29 187.46,103.05 187.46,102.34 189.99,99.8 v2(189.99,96.11) ; v2(136.86,71.4) 137.15,71.4 137.36,71.61 137.36,72.7 137.64,72.99 138.28,72.99 138.42,73.12 138.67,73.12 138.73,73.18 139.04,73.18 139.13,73.09 140.23,73.09 140.25,73.12 145.62,73.12 145.65,73.15 146.14,73.15 146.17,73.12 146.22,73.12 146.23,73.12 146.37,73.12 146.83,73.58 149.08,73.58 149.71,72.95 152.73,72.95 153.83,71.85 157.21,71.85 157.69,72.34 157.69,74.5 158.89,75.69 159.07,75.69 159.07,75.69 162.42,75.69 162.99,76.26 163.51,76.26 v2(163.69,76.45)
  BOTTOM w0.076: UC1.AN15 137.21,71.7 v2(136.86,71.4)
  BOTTOM w0.102: v2(168.15,98.65) 167.7,98.2 166.73,98.2 PR504.1 ; v2(278.82,37.2) 278.82,36.35 279.47,35.71 279.47,28.66 280.04,28.09 280.04,27.74 279.75,27.46 277.54,27.46 274.31,24.22 274.31,23.46 v2(273.41,22.55) ; v2(189.99,96.11) 190.15,96.26 PR312.2 ; v2(179.03,111.49) 178.62,111.89 PR406.1 ; v2(188.24,41.82) 190.38,41.82 190.86,41.33 194.29,41.33 195.85,42.9 195.85,43.97 197.31,45.43 v2(197.41,45.43)
SIO_SLP_WLAN#: length 274
  TOP w0.102: RZ71.1 302.23,59.06 v2(302.8,59.06) 304.01,59.06 304.36,58.72 304.36,57.7 303.71,57.05 301.5,57.05 300.33,58.22 299.93,58.22 299.85,58.15 298.09,58.15 297.97,58.26 v1(293.5,58.26) v2(292.36,58.26)
  TOP w0.107: v2(264.51,43.6) 264.51,43.5 UE1.D9
  IN1 w0.102: v2(276.43,54.58) 276.43,54.12 277.07,53.49 278.09,53.49 278.65,52.93 283.58,52.93 285.81,55.15 287.72,55.15 290.27,57.7 291.98,57.7 292.36,58.07 v2(292.36,58.26) ; v2(302.8,59.06) 302.77,59.03 302.77,56.99 301.75,55.97 301.75,48.44 302.15,48.04 302.15,47.24 302.02,47.11 301.21,47.11 301.02,47.31 297.66,47.31 296.74,46.38 296.74,45.65 294.16,43.08 294.16,41.33 292.31,39.49 292.31,37.64 292.21,37.54 288.44,33.77 288.44,32.49 285.26,29.31 284.38,29.31 282.69,27.62 281.04,27.62 279.75,26.34 278.82,26.34 277.47,24.99 273.45,24.99 273.36,25.07 261.1,25.07 259.98,26.19 259.25,26.19 258.79,26.65 242.33,26.65 241.68,27.3 241.68,27.99 240.26,29.41 238.38,29.41 237.9,29.89 234.71,29.89 232.66,31.95 231.49,31.95 231.07,31.95 229.68,31.95 229.08,32.54 227.24,32.54 226.84,32.95 220.52,32.95 219.23,31.65 205.76,31.65 205.03,30.93 205.03,30.38 204.63,29.98 203.19,29.98 197.24,35.93 196.07,35.93 193.93,38.07 193.93,39.16 193.06,40.02 193.06,40.02 189.13,43.96 188.35,43.96 187.18,45.13 155.53,45.13 148.3,52.36 146.25,52.36 145.25,53.36 141.98,53.36 138.35,56.99 138.35,58.54 137.54,59.34 137.54,60.52 137.23,60.84 137.23,61.44 v2(137.16,61.5)
  IN3 w0.102: v2(264.51,43.6) 264.72,43.6 265.13,44 266.27,44 266.4,44.13 266.4,44.7 266.29,44.8 265.85,44.8 265.63,45.02 265.63,46.91 266.97,48.25 266.97,51.59 268.24,52.86 268.89,52.86 270.47,54.45 271.67,54.45 272.09,54.03 275.89,54.03 v2(276.43,54.58)
  BOTTOM w0.076: UC1.BB17 135.77,65.83 135.88,65.73 135.88,64.15 136.87,63.16 136.87,61.79 v2(137.16,61.5)
SLEEVE: length 4.2
  BOTTOM w1.27: 300.55,26.89 300.55,26.45 301.12,25.88 301.12,23.34 301.37,23.08
  vias: v1(301.69,21.37) v2(299.6,27.97) v2(300.17,27.97) v2(302.45,21.88) v2(302.45,21.29) v2(302.45,20.71)
SLEEVE_R: length 22.9
  TOP w0.127: CA12.1 v1(309.6,22.75)
  IN1 w1.27: 308.37,22.55 309.75,23.93 309.75,28.44 311.86,30.55 316.21,30.55 317.88,28.87 317.88,25.74 318.9,24.72 JHP1.3
  vias: v2(307.74,21.47) v2(308.37,21.47) v2(309.01,21.47)
SLOT2_CONFIG_0: length 32.5
  TOP w0.112: v2(275.89,45.17) 275.7,44.98 v3(275.22,44.98) 274.72,44.98 273.16,43.42 272.25,43.42 UE1.N9 ; RPE9.1 276.33,46.87 276.03,46.57 v2(275.85,46.57)
  BOTTOM w0.112: v2(275.89,45.17) 276.32,45.6 276.32,46.16 275.9,46.57 v2(275.85,46.57) 275.85,46.97 276.32,47.44 276.32,49.3 276.06,49.56 275.12,49.56 274.28,50.4 274.28,51.82 272.91,53.19 272.91,53.88 271.25,55.55 270.5,55.55 266.71,59.33 266.71,62 266.05,62.67 266.05,64.24 266.95,65.14 JNGFF2.13
SLOT2_CONFIG_1: length 28.3
  TOP w0.112: RPE9.2 276.34,46.37 275.98,46.02 v2(275.91,46.02) 275.86,45.97 274.13,45.97 273.66,45.5 273.66,45.27 272.84,44.45 271.69,44.45 UE1.M10
  IN2 w0.124: v2(278.94,64.56) 278.94,64.35 277.98,63.39 277.98,62.4 276.24,60.66 276.24,56.24 276.82,55.66 276.82,46.64 276.2,46.02 v2(275.91,46.02)
  BOTTOM w0.112: JNGFF2.61 278.94,65.82 v2(278.94,64.56)
SLOT2_CONFIG_2: length 29.2
  TOP w0.112: UE1.N10 272.34,43.67 272.8,43.67 273.9,44.76 273.9,45.3 v3(273.99,45.39) 274.16,45.56 v2(275.4,45.56) 275.47,45.62 276.1,45.62 276.35,45.87 RPE9.3
  IN2 w0.124: v2(275.4,45.56) 275.47,45.62 276.16,45.62 277.08,46.54 277.08,55.76 276.49,56.35 276.49,60.29 280.16,63.96 v2(280.16,64.36)
  BOTTOM w0.112: JNGFF2.67 280.45,64.64 v2(280.16,64.36)
SLOT2_CONFIG_3: length 61.2
  TOP w0.112: UE1.F4 v2(266.03,38.79) ; v2(274.91,44.15) 275.45,44.15 RPE9.4
  IN2 w0.124: v2(274.91,44.15) 275.27,43.79 275.27,43.05 275.7,42.62 275.7,35.29 271.6,31.2 267.89,31.2 v2(267.5,30.8)
  BOTTOM w0.112: JNGFF2.1 v1(261.95,63.79) 261.95,63.01 262.63,62.33 263.2,62.33 270.39,55.15 271.31,55.15 272.55,53.91 272.55,53.22 274.04,51.72 274.04,50.3 275.02,49.32 275.88,49.32 276.08,49.12 276.08,47.66 275.25,46.84 275.25,46.36 274.91,46.01 v2(274.91,44.15) ; v2(266.03,38.79) 266.2,38.79 266.59,38.41 266.96,38.41 267.29,38.07 267.29,34.58 266.52,33.8 266.52,31.54 266.99,31.07 267.24,31.07 v2(267.5,30.8)
SM_RCOMP0: length 11.6
  TOP w0.152: v2(135.08,70.04) 134.65,69.61 134.65,69.29 134.13,68.77
  TOP w0.381: 134.13,68.77 133.58,68.22 133.58,66.55 134.06,66.07 134.06,64.88 133.59,64.41 133.59,61.88 133.57,61.86 v1(133.57,61.82) 133.62,61.77 133.62,60.25 RC5.1
  BOTTOM w0.254: UC1.AR18 135.52,70.38 v2(135.08,70.04)
SM_RCOMP1: length 10.7
  TOP w0.152: 134.42,68.34 134.62,68.54 134.62,68.9 135.08,69.36 v2(135.08,69.4)
  TOP w0.381: RC6.1 134.66,63.98 v1(134.82,64.13) 134.88,64.19 134.88,64.73 134.55,65.07 134.55,66.27 134.06,66.75 134.06,67.99 134.42,68.34
  BOTTOM w0.254: v2(135.08,69.4) 135.52,69.73 UC1.AT18
SM_RCOMP2: length 11
  TOP w0.381: v2(135.08,68.77) 135.08,68.32 134.57,67.81 134.57,66.92 134.95,66.54 135.18,66.54 136.02,65.7 136.02,64.01 136.55,63.49 v1(136.55,61.05) 136.55,60.12 136.93,59.73 RC7.1
  BOTTOM w0.254: v2(135.08,68.77) 135.52,69.09 UC1.AU18
SML0_SMBCLK: length 211.8
  TOP w0.112: RC19.1 277.42,99.46 v2(276.48,98.52) 276.3,98.34 UL1.28 ; CC318.1 v3(166.24,80.38) v2(165.62,80.99) ; RC347.1 150.61,78.47 150.61,78.65 150.79,78.82 152.07,78.82 152.43,79.18 152.43,79.6 v2(152.64,79.81)
  IN1 w0.119: v2(165.62,80.99) 165.42,80.79 165.42,80.49 166.28,79.62 171.18,79.62 174.75,76.05 174.75,75.41 175.26,74.9 175.26,74.26 174.9,73.9 174.9,70.15 175.82,69.23 175.82,67.93 179.4,64.35 189.8,64.35 190.76,63.38 194.09,63.38 207.14,50.33 207.55,50.33 209.18,48.71 233.36,48.71 233.68,48.39 237.74,48.39 238.17,48.82 240.27,48.82 241.21,49.76 243.8,49.76 252.94,58.89 266.75,58.89 267.79,57.85 268.52,57.85 269.42,58.74 269.42,62.16 270.32,63.05 270.32,65.54 269.09,66.76 269.09,97.36 270.51,98.77 276.23,98.77 v2(276.48,98.52)
  IN3 w0.135: v2(152.64,79.81) 152.83,80 153.01,80 153.19,79.81 162.17,79.81 162.31,79.67 164.78,79.67 165.42,80.31 165.42,80.79 v2(165.62,80.99)
  BOTTOM w0.076: UC1.R9 141.05,80.63 141.42,80.27 141.42,80.07 141.64,79.85 142.9,79.85 143.59,79.16 143.59,79.04 143.86,78.77 143.86,78.43 144.16,78.13 145.2,78.13 145.41,78.02 145.88,78.02 145.98,78.11 146.62,78.11 146.77,77.97 147.2,77.97 147.78,77.4 148.85,77.4 149.94,78.49 150.68,78.49 150.7,78.47 150.72,78.47
  BOTTOM w0.112: 150.72,78.47 151.15,78.47 151.69,79 152.12,79 152.49,79.37 152.49,79.65 v2(152.64,79.81)
SML0_SMBDATA: length 205.9
  TOP w0.112: UL1.31 v2(275.1,98.34) 275.1,98.36 274.65,98.81 274.65,100.78 273.56,101.87 RC20.1 ; v2(152.06,79.81) 152.19,79.69 152.19,79.28 151.97,79.06 150.69,79.06 150.37,78.75 150.37,78.73 150.35,78.71 150.35,78.61 RC348.1
  IN1 w0.119: v2(165.04,80.99) 165.17,80.86 165.17,80.38 166.18,79.38 171.08,79.38 174.51,75.95 174.51,75.3 175.02,74.8 175.02,74.37 174.65,74 174.65,70.05 175.57,69.13 175.57,67.83 179.3,64.1 189.69,64.1 190.66,63.14 193.99,63.14 207.04,50.08 207.45,50.08 209.07,48.46 233.26,48.46 233.58,48.14 237.84,48.14 238.27,48.57 240.38,48.57 241.31,49.51 243.9,49.51 253.04,58.65 266.64,58.65 267.69,57.6 268.63,57.6 269.67,58.64 269.67,62.05 270.56,62.95 270.56,65.64 269.34,66.86 269.34,97.25 270.61,98.53 274.98,98.53 275.1,98.41 v2(275.1,98.34)
  IN3 w0.135: v2(152.06,79.81) 152.5,80.26 153.12,80.26 153.3,80.08 162.27,80.08 162.41,79.93 164.68,79.93 165.16,80.42 165.16,80.87 v2(165.04,80.99)
  BOTTOM w0.076: UC1.W2 145.01,78.47 145.15,78.33 145.43,78.2 145.77,78.2 145.89,78.32 146.71,78.32 146.85,78.17 147.29,78.17 147.86,77.6 148.77,77.6 149.86,78.69 150.68,78.69 150.7,78.71 150.72,78.71
  BOTTOM w0.112: v2(152.06,79.81) 152.25,79.63 152.25,79.47 152.02,79.24 151.59,79.24 151.05,78.71 150.72,78.71
SML1_SMBCLK: length 162.1
  TOP w0.112: RC15.1 150.31,80.41 v3(151.07,80.41) 151.49,79.99 v2(151.49,79.8) ; CC319.1 167.5,79.27 v2(167.5,78.87) ; v2(264.42,42.88) 264.42,42.79 UE1.D8
  IN1 w0.119: v2(261.38,56.76) 261.26,56.88 260.39,56.88 260.02,57.26 252.77,57.26 244.23,48.72 241.75,48.72 240.8,47.77 238.53,47.77 238.14,47.39 233.13,47.39 232.87,47.64 208.83,47.64 207.14,49.34 206.73,49.34 193.68,62.39 190.35,62.39 189.38,63.36 181.38,63.36 180.75,62.73 179.56,62.73 172.21,70.08 172.21,74.6 168.84,77.97 168.15,77.97 167.7,78.42 167.7,78.67 v2(167.5,78.87)
  IN3 w0.135: v2(151.49,79.8) 151.49,79.94 151.15,80.28 151.15,80.6 151.57,81.01 155.81,81.01 156.23,80.59 161.9,80.59 162.88,81.56 165.68,81.56 166.11,81.13 166.11,80.62 167.14,79.59 167.53,79.59 167.66,79.46 167.66,79.03 v2(167.5,78.87)
  BOTTOM w0.076: UC1.W3 144.41,78.67 144.57,78.67 144.79,78.75 144.92,78.75 144.92,78.75 145.15,78.68 145.28,78.68 145.42,78.74 146.54,78.74 146.58,78.79 147.45,78.79 147.68,79.02 151.01,79.02 151.32,79.33 151.32,79.63 v2(151.49,79.8)
  BOTTOM w0.112: v2(261.38,56.76) 261.58,56.95 261.9,56.95 262.15,56.7 262.15,56.26 263.65,54.76 263.65,54.28 262.87,53.51 262.87,52.35 263.97,51.25 263.97,45.02 264.05,44.95 264.05,44.11 264.12,44.04 264.12,43.19 v2(264.42,42.88)
SML1_SMBDATA: length 159.5
  TOP w0.112: v2(265.22,45.28) 265.22,45.19 UE1.E11 ; v2(150.93,79.8) 150.58,79.8 RC17.1
  IN1 w0.119: v2(261.4,57.32) 261.21,57.13 260.49,57.13 260.12,57.51 252.67,57.51 244.13,48.97 241.65,48.97 240.7,48.02 238.42,48.02 238.04,47.63 233.23,47.63 232.97,47.89 208.94,47.89 207.24,49.58 206.83,49.58 193.78,62.63 190.46,62.63 189.49,63.6 181.28,63.6 180.65,62.97 179.66,62.97 172.45,70.18 172.45,74.7 168.94,78.22 168.25,78.22 167.95,78.52 167.95,78.66 168.16,78.87 v2(168.17,78.87)
  IN3 w0.135: v2(168.17,78.87) 168.16,78.88 168.08,78.88 167.92,79.04 167.92,79.57 167.64,79.85 167.25,79.85 166.37,80.73 166.37,81.24 165.78,81.82 162.77,81.82 161.8,80.85 156.34,80.85 155.92,81.27 151.46,81.27 150.89,80.71 150.89,80.17 150.93,80.13 v2(150.93,79.8)
  BOTTOM w0.076: UC1.V3 144.16,78.87 144.62,78.87 144.76,78.91 144.95,78.91 144.97,78.91 145.17,78.85 145.25,78.85 145.38,78.91 146.41,78.91 146.5,78.99 147.37,78.99 147.6,79.22 150.93,79.22 151.12,79.42 151.12,79.61 v2(150.93,79.8)
  BOTTOM w0.112: v2(261.4,57.32) 261.54,57.19 262,57.19 262.39,56.8 262.39,56.36 263.88,54.86 263.88,54.18 263.11,53.41 263.11,52.45 264.21,51.35 264.21,45.91 264.84,45.28 v2(265.22,45.28)
SNB_+1VALWP:
  vias: v1(181.49,94.33)
SNK0_CONFIG1: length 2.9
  TOP w0.102: v2(29.26,82.91) UT1.N4
  BOTTOM w0.102: v2(29.26,82.91) 29.57,82.6 v3(29.57,82.54)
  BOTTOM w0.112: v3(29.57,82.54) 29.57,82.52 29.26,82.21 29.26,81.66 RT129.1 RT337.1
SNUB_1.8VALW: length 0.9
  BOTTOM w0.112: 163.83,98.81 v3(163.83,97.96)
SNUB_1V_PRIM: length 2.3
  BOTTOM w0.112: PR409.2 169.06,106.81 PC419.1 168.69,106.72 168.1,107.32 v3(168.05,107.32)
SNUB_1VS_VCCIO: length 2.1
  BOTTOM w0.112: v3(180.6,113.93) 181,113.52 PC401.1 181.82,113.01 PR405.2
SNUB_VCC_EDRAM: length 2.3
  TOP w0.112: v3(52.18,53.76) 52.33,53.9 PC1309.1 52.77,54.79 53.2,55.23 PR1305.2
SNUB_VCC_EOPIO: length 2.6
  TOP w0.112: PC1319.1 51.07,43.47 51.82,44.21 PR1319.2 v3(53.22,44.21)
SPKR: length 197.9
  TOP w0.102: v2(285.88,27.27) 285.95,27.21 v1(286.96,27.21) 289.89,27.21 290.08,27.01 292.41,27.01 293.3,27.9 RA12.2 ; RC183.1 161.14,61.53 160.81,61.86 160.06,61.86 158.99,60.78 154.1,60.78 152.17,62.06 151.49,62.74 151.16,62.74 147.77,66.14 146.78,66.14 146.68,66.03 146.19,66.03 144.73,67.49 144.49,67.49 143.89,68.09 143.89,68.19 v2(143.3,68.79)
  IN1 w0.076: 143.39,68.79 144.81,68.79 145.33,68.27
  IN1 w0.102: v2(237.39,38.77) 236.93,39.23 230.14,39.23 229.94,39.02 217.01,39.02 216.84,38.86 216.77,38.86 216,38.08 211.61,38.08 210.83,38.86 206.48,38.86 205.19,40.15 204.85,40.15 204.16,40.15 202.9,41.42 201.38,41.42 201.33,41.37 201.01,41.37 200.97,41.42 200.82,41.42 198.09,44.15 197.92,44.15 197.92,44.15 197.49,44.15 190.36,51.28 189.89,51.28 189.76,51.4 183.87,51.4 183.26,52.01 183.19,52.01 182.45,52.01 181.18,53.28 167.19,53.28 164.53,55.94 163.11,55.94 161.69,57.37 161.69,58.69 161.08,59.3 161.08,60.06 159.96,61.18 159.2,61.18 157.93,62.45 151.77,62.45 147.63,66.59 147,66.59 145.33,68.27 ; 143.39,68.79 v2(143.3,68.79)
  IN2 w0.102: v2(285.88,27.27) 285.24,27.27 284.42,26.45 280.68,26.45 278.98,24.75 269.32,24.75 268.95,25.11 266.13,25.11 265.74,25.51 265.74,26.49 265.61,26.61 260.91,26.61 259.53,27.99 259.15,27.99 257.77,29.37 254.16,29.37 253.56,29.98 252.36,29.98 251.67,30.67 251.67,32.02 251.04,32.65 249.59,32.65 248.83,33.4 248.07,33.4 246.01,35.47 242.88,35.47 242.43,35.92 238.15,35.92 237.91,35.68 v2(237.88,35.68)
  BOTTOM w0.076: v2(143.3,68.79) 143.3,68.71 UC1.AW5
  BOTTOM w0.102: v2(237.39,38.77) 237.43,38.73 237.43,36.17 237.88,35.72 v2(237.88,35.68)
SPKR_R: length 4.3
  TOP w0.102: v3(292.69,26.85) 292.81,26.98 RA12.1 RA51.1 CA72.1 295.73,26.98 CA27.1
SRTCRST#: length 15.8
  TOP w0.112: v2(135.08,71.31) 135.54,70.86 135.54,67.53 136.96,66.11 136.96,64.51 139.53,61.94 v1(139.53,60.99) CC24.1 RC56.1
  BOTTOM w0.076: UC1.AN18 v2(135.08,71.31)
SS_1V_PRIM: length 3.3
  BOTTOM w0.102: PC420.1 v3(167.68,111.87)
  BOTTOM w0.254: PU402.7 169.83,111.62 PR428.1 PC420.1
SS_1VS_VCCIO: length 3.6
  BOTTOM w0.102: PC410.1 186.95,115.09 v3(186.77,115.27)
  BOTTOM w0.254: PU401.7 186.51,112.88 PR427.1 186.92,114.15 PC410.1
SS_VCC_EDRAM: length 2.1
  TOP w0.254: PC1310.1 50.47,61.03 50.22,61.03 50.06,60.87 PU1301.7
SS_VCC_EOPIO: length 1.4
  TOP w0.254: PU1302.7 48.48,50.39 PC1320.1
SUSACK#: length 155.1
  TOP w0.107: 269.62,45.59 270.05,46.01 270.05,46.73 v2(270.32,47)
  IN1 w0.076: 145.43,64.22 143.43,66.21 141.68,66.21 140.66,67.23 139.54,67.23 138.33,68.44 138.33,69 138.21,69.13 138.21,70.78 v2(138.74,71.31)
  IN1 w0.102: v2(270.32,47) 269.76,46.45 262.73,46.45 261.91,45.62 260.48,45.62 258.6,43.74 258.6,43.13 256.44,40.97 251.43,40.97 251.2,40.74 249.57,40.74 247.76,38.93 247.34,38.93 246.58,38.18 244.7,38.18 244.67,38.14 241.46,38.14 241.25,38.36 238.94,38.36 238.76,38.18 236.91,38.18 236.27,38.82 230.31,38.82 230.1,38.61 217.18,38.61 217.01,38.45 216.94,38.45 216.16,37.67 215.87,37.67 211.44,37.67 210.66,38.45 206.31,38.45 205.02,39.75 204,39.75 202.73,41.01 201.54,41.01 201.5,40.96 200.83,40.96 200.82,40.96 200.71,40.96 197.92,43.74 197.32,43.74 190.81,50.25 190.03,50.25 189.49,50.79 183.47,50.79 182.94,51.33 181.02,51.33 180.19,52.15 172.68,52.15 172.59,52.24 166.86,52.24 163.99,55.11 162.28,55.11 160.87,56.52 154.19,56.52 146.49,64.22 145.43,64.22
  BOTTOM w0.076: UC1.AP11 139,71.05 v2(138.74,71.31)
SUSCLK: length 397.1
  TOP w0.112: v2(202.33,25.4) v1(203.89,26.96) v2(203.89,30.72) ; v2(137.81,61.22) 137.78,61.22 137.54,60.99 137.54,60.37 137.92,59.99 RC48.1 ; v2(287.25,32) 285.99,33.26 285.99,36.08 285.24,36.83 285.24,47.29 284.98,47.55 281.35,47.55 RZ56.2
  IN1 w0.119: v2(287.25,32) 285.26,30 281.95,30 280.86,28.92 280.86,28.14 279.54,26.83 278.62,26.83 277.27,25.48 273.66,25.48 273.57,25.57 261.95,25.57 260.38,27.14 242.54,27.14 242.17,27.5 242.17,28.19 240.46,29.9 238.58,29.9 238.1,30.38 234.92,30.38 232.86,32.44 231.28,32.44 230.87,32.44 230.87,32.44 230.04,32.44 230.04,32.44 229.88,32.44 229.28,33.04 227.45,33.04 227.04,33.44 219.28,33.44 217.99,32.15 205.56,32.15 205.13,31.72 205.05,31.72 204.05,30.72 v2(203.89,30.72) 203.66,30.72 203.03,31.35 202.55,31.35 199.08,34.82 199.08,35.3 195.9,38.49 195.29,38.49 189.33,44.45 188.55,44.45 187.38,45.62 155.73,45.62 148.5,52.85 146.45,52.85 145.45,53.85 142.18,53.85 138.84,57.19 138.84,58.74 138.05,59.53 138.05,60.98 v2(137.81,61.22)
  IN2 w0.124: v2(202.33,25.4) 201.76,25.97 193.38,25.97 192.15,27.2 185.97,27.2 183.5,24.73 181.59,24.73 181.4,24.53 175.92,24.53 175.2,23.82 173.83,23.82 173.12,24.53 167.39,24.53 166.61,25.31 164.64,25.31 164.39,25.56 160.19,25.56 158.77,24.14 116.23,24.14 114.06,21.97 82,21.97 79.84,24.13 47.48,24.13 39.28,15.93 24.68,15.93 v2(22.99,17.62)
  BOTTOM w0.076: v2(137.81,61.22) 137.99,61.4 137.99,62.28 136.04,64.22 136.04,66.24 135.77,66.51 UC1.BA17
  BOTTOM w0.112: v2(22.99,17.62) 22.99,18.24 RN99.2
SUSCLK_R: length 5.2
  BOTTOM w0.112: RN99.1 21.29,18.81 22.16,17.94 22.16,14.96 JNGFF3.68
SW2_DP1_AUXN: length 95.4
  TOP w0.104: v2(40.24,91.07) 40.03,90.87 39.8,90.87 39.4,90.47 39.16,90.47 CT175.1
  IN3 w0.135: v2(103.78,110.46) 103.96,110.27 103.96,110.11 103.83,109.98 102.68,109.98 100.81,111.84 93.72,111.84 91.38,109.5 70.03,109.5 69.11,110.42 61.45,110.42 60.66,109.64 55.44,109.64 52.64,106.84 49.2,106.84 47.36,105 47.36,94.23 46.17,93.04 46.17,92.63 45.53,91.99 45.03,91.99 42.8,89.76 41.78,89.76 40.66,90.87 40.43,90.87 v2(40.24,91.07)
  BOTTOM w0.104: UV7.29 108.88,110.82 108.78,110.71 108.21,110.71 v4(107.76,111.16) 107.04,111.88 104.93,111.88 103.95,110.9 103.95,110.63 v2(103.78,110.46) 103.96,110.27 103.96,108.64 102.62,107.29 102.62,106.71 RV70.1
SW2_DP1_AUXN_C: length 10.5
  TOP w0.094: UT1.W12 v2(31.86,86.16)
  TOP w0.104: CT175.2 38.2,90.4 37.93,90.4 37.79,90.54 36.07,90.54 35.8,90.28 35.16,90.28 v2(34.99,90.44)
  IN1 w0.119: v2(34.99,90.44) 34.81,90.26 34.1,90.26 33.85,90.01 33.85,88.17 33.15,87.47 32.74,87.47 32.19,86.92 32.19,86.49 v2(31.86,86.16)
SW2_DP1_AUXP: length 95.5
  TOP w0.104: CT169.1 39.22,90.26 39.48,90.26 39.88,90.67 40.06,90.67 v2(40.24,90.49)
  IN3 w0.135: v2(104.36,110.46) 104.21,110.3 104.21,110.01 103.93,109.74 102.58,109.74 100.71,111.6 93.82,111.6 91.48,109.26 69.93,109.26 69.01,110.18 61.55,110.18 60.76,109.4 55.54,109.4 52.74,106.6 49.3,106.6 47.6,104.9 47.6,94.13 46.41,92.94 46.41,92.53 45.63,91.75 45.13,91.75 42.9,89.52 41.68,89.52 40.56,90.63 40.38,90.63 v2(40.24,90.49)
  BOTTOM w0.104: UV7.28 108.82,110.42 108.72,110.51 108.12,110.51 107.86,110.78 107.82,110.78 107.4,111.2 107.4,111.24 106.95,111.68 105.01,111.68 104.15,110.82 104.15,110.67 v2(104.36,110.46) 104.16,110.26 104.16,108.55 102.82,107.21 102.82,106.69 RV76.1
SW2_DP1_AUXP_C: length 10.2
  TOP w0.094: UT1.Y12 32.77,86.54 32.57,86.54 32.51,86.48 v2(32.51,86.16)
  TOP w0.104: CT169.2 38.27,90.2 37.85,90.2 37.7,90.34 36.15,90.34 35.88,90.07 35.18,90.07 v2(34.98,89.87)
  IN1 w0.119: v2(34.98,89.87) 34.81,90.04 34.19,90.04 34.07,89.92 34.07,88.08 33.24,87.25 32.83,87.25 32.41,86.83 32.41,86.25 v2(32.51,86.16)
SW2_DP1_CADET: length 4.7
  TOP w0.102: v2(110.63,112.78) 109.84,111.99 v3(108.76,111.99) 108.46,111.99 108.08,112.36 RV73.1
  BOTTOM w0.102: v2(110.63,112.78) 110.93,112.47 UV7.33
SW2_DP1_HPD: length 117.2
  TOP w0.102: v3(112,112.26) 112.49,112.75 v2(112.78,112.75) ; UT1.Y6 32.83,83.88 v2(32.51,84.2)
  IN2 w0.102: v2(32.51,84.2) 33.58,85.27 33.58,92.02 30.8,94.8 29.58,94.8 28.71,95.67 28.71,99.77 30.81,101.87 33.14,101.87 34.62,103.36 34.62,105.4 35.41,106.18 36.99,106.18 40.59,109.78 57.99,109.78 59.08,110.87 59.08,112 60.28,113.2 61.08,113.2 62.86,114.98 70.48,114.98 71.98,113.47 77.39,113.47 78.45,112.41 91.19,112.41 92.05,113.28 102.5,113.28 103.38,112.4 112.42,112.4 v2(112.78,112.75)
  BOTTOM w0.102: UV7.38 112.93,112.59 v2(112.78,112.75)
  BOTTOM w0.112: v2(32.51,84.2) 32.9,84.59 33.67,84.59 RT29.1
SW2_DP1_N0: length 103.8
  TOP w0.104: CT176.1 36.47,87.93 36.75,87.93 36.91,88.09 v2(36.91,88.11)
  IN3 w0.135: v2(36.91,88.11) 37.25,87.77 39.22,87.77 40.08,88.63 40.08,89.5 39.16,90.43 39.16,91.64 39.89,92.37 40.63,92.37 41.09,91.91 41.09,91.52 41.62,90.99 42.92,90.99 46.6,94.66 46.6,106 49.35,108.74 53.41,108.74 55.08,110.42 60.17,110.42 60.94,111.18 66.69,111.18 67.41,111.91 70.29,111.91 71.78,110.42 89.61,110.42 92.45,113.25 103.76,113.25 104.94,112.07 106.42,112.07 107.03,111.46 112.07,111.46 113.31,112.7 113.31,112.95 v2(112.97,113.29)
  BOTTOM w0.104: v2(112.97,113.29) 113.04,113.29 113.2,113.13 113.2,112.96 113.41,112.76 113.41,112.51 113.33,112.44 UV7.39
SW2_DP1_N0_C: length 2.4
  TOP w0.076: 34.92,87.82 34.9,87.82 34.89,87.8 34.46,87.8 34.16,88.1 33.93,88.1 33.88,88.05 33.88,87.97 33.88,87.97 UT1.AC15
  TOP w0.104: 34.92,87.82 35.45,87.82 35.7,88.07 CT176.2
SW2_DP1_N1: length 99.9
  TOP w0.104: v2(38.58,88.92) 38.45,88.79 38.11,88.79 CT171.1
  IN3 w0.135: v2(38.58,88.92) 38.58,88.87 38.72,88.73 38.75,88.73 38.9,88.58 38.96,88.58 39.21,88.83 39.21,89.27 38.09,90.39 38.09,92.19 39.3,93.4 43.51,93.4 43.99,93.89 44.66,93.89 44.97,94.19 44.97,94.83 44.66,95.14 44.66,99.12 45.82,100.28 45.82,107 48.33,109.51 53.01,109.51 54.69,111.19 59.7,111.19 61.18,112.67 70.66,112.67 71.98,111.35 88.1,111.35 90.76,114.01 104.3,114.01 105.32,113 106.84,113 107.54,112.3 111.64,112.3 112.13,112.78 112.13,112.96 v2(111.8,113.29)
  BOTTOM w0.104: UV7.36 112.13,112.49 112.08,112.55 112.08,113.01 v2(111.8,113.29)
SW2_DP1_N1_C: length 4.3
  TOP w0.076: 34.92,88.73 34.9,88.73 34.89,88.71 34.4,88.71 34.37,88.75 34.36,88.75 34.3,88.81 34.3,88.96 34.25,89.02 33.89,89.02 33.8,88.93 33.8,88.86 33.88,88.78 UT1.AC17
  TOP w0.104: CT171.2 37.35,88.73 34.92,88.73
SW2_DP1_N2: length 102.3
  TOP w0.104: v2(36.85,89.83) 36.92,89.77 36.92,89.65 36.8,89.52 36.66,89.52 36.62,89.48 36.51,89.48 CT168.1
  IN3 w0.135: v2(36.85,89.83) 36.85,89.64 36.75,89.54 36.65,89.54 36.52,89.4 36.38,89.4 36.09,89.69 36.09,90.66 34.65,92.1 34.65,93.44 35.48,94.27 36.23,94.27 36.87,94.91 37.75,94.91 39.74,96.91 41.45,96.91 42.33,97.78 42.33,101.27 44.12,103.07 44.12,104.21 44.5,104.59 44.5,107.99 47.38,110.88 51.89,110.88 54.56,113.55 56.35,113.55 56.93,114.13 60.63,114.13 60.9,114.41 70.79,114.41 72.47,112.73 87.54,112.73 90.09,115.28 98.74,115.28 99.91,116.45 106.28,116.45 108.26,114.47 110.69,114.47 111,114.17 111,113.66 110.81,113.47 v2(110.64,113.47)
  BOTTOM w0.104: v2(110.64,113.47) 110.73,113.47 110.85,113.34 110.85,113.18 111.04,113 111.04,112.95 111.17,112.82 111.17,112.78 111.3,112.65 111.3,112.42 111.33,112.39 UV7.34
SW2_DP1_N2_C: length 2.6
  TOP w0.076: UT1.AC19 33.85,89.7 33.8,89.75 33.8,89.85 33.88,89.93 34.19,89.93 34.4,89.72 34.51,89.72 34.87,89.36 34.91,89.36 34.91,89.36 34.92,89.36
  TOP w0.104: 34.92,89.36 35.19,89.36 35.37,89.54 35.51,89.54 CT168.2
SW2_DP1_N3: length 94
  TOP w0.104: v2(36.9,92.23) 36.69,92.23 36.5,92.05 36.5,91.94 36.47,91.91 CT170.1
  IN3 w0.135: v2(109.46,113.16) 109.55,113.16 109.68,113.28 109.68,113.6 109.56,113.71 107.94,113.71 107.13,114.53 90.4,114.53 87.79,111.91 72.17,111.91 70.9,113.19 57.09,113.19 56.7,112.8 54.88,112.8 52.15,110.07 47.65,110.07 45.26,107.69 45.26,102.2 44.12,101.06 44.12,94.95 43.11,93.94 40.83,93.94 40.52,94.24 38.75,94.24 37.52,93.01 37.27,93.01 36.9,92.64 v2(36.9,92.23)
  BOTTOM w0.104: UV7.31 110.13,112.43 109.88,112.68 109.88,112.94 109.67,113.15 109.46,113.15 v2(109.46,113.16)
SW2_DP1_N3_C: length 2.7
  TOP w0.076: 34.92,90.9 34.62,90.9 34.32,90.6 34.32,90.55 34.16,90.39 34,90.39 33.93,90.46 33.93,90.58 33.97,90.62 UT1.AC21
  TOP w0.104: CT170.2 35.87,91.14 35.87,91.12 35.65,90.9 34.92,90.9
SW2_DP1_P0: length 103.8
  TOP w0.104: CT177.1 36.54,87.7 36.74,87.7 v2(36.91,87.53)
  IN3 w0.135: v2(36.91,87.53) 39.32,87.53 40.32,88.53 40.32,89.6 39.4,90.53 39.4,91.53 39.99,92.13 40.53,92.13 40.85,91.81 40.85,91.42 41.52,90.75 43.02,90.75 46.84,94.56 46.84,105.9 49.45,108.5 53.51,108.5 55.18,110.18 60.27,110.18 61.04,110.94 66.79,110.94 67.51,111.67 70.19,111.67 71.68,110.18 89.71,110.18 92.55,113.01 103.66,113.01 104.84,111.83 106.32,111.83 106.93,111.22 112.17,111.22 113.55,112.6 v2(113.55,113.29)
  BOTTOM w0.104: v2(113.55,113.29) 113.41,113.15 113.41,113.15 113.4,113.14 113.4,113.05 113.64,112.81 113.64,112.56 113.73,112.46 UV7.40
SW2_DP1_P0_C: length 2.4
  TOP w0.076: 34.92,87.6 34.9,87.6 34.89,87.62 34.38,87.62 34.38,87.62 33.77,87.62 33.71,87.68 UT1.AB15
  TOP w0.104: CT177.2 35.65,87.6 34.92,87.6
