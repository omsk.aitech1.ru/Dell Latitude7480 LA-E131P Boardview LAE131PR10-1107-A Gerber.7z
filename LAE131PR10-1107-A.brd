# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW2_DP1_P1: length 99.9
  TOP w0.104: CT172.1 38.52,88.27 v2(38.58,88.33)
  IN3 w0.135: v2(38.58,88.33) 39.06,88.33 39.46,88.73 39.46,89.37 38.33,90.49 38.33,92.09 39.4,93.16 43.61,93.16 44.09,93.64 44.76,93.64 45.21,94.09 45.21,94.93 44.9,95.24 44.9,99.02 46.06,100.18 46.06,106.9 48.43,109.27 53.11,109.27 54.79,110.95 59.8,110.95 61.28,112.43 70.56,112.43 71.88,111.11 88.2,111.11 90.86,113.77 104.2,113.77 105.22,112.76 106.74,112.76 107.44,112.06 111.74,112.06 112.37,112.68 112.37,113.28 v2(112.38,113.29)
  BOTTOM w0.104: v2(112.38,113.29) 112.3,113.21 112.3,113.12 112.28,113.1 112.28,112.9 112.31,112.87 112.31,112.64 112.37,112.59 112.37,112.55 112.53,112.38 UV7.37
SW2_DP1_P1_C: length 4.2
  TOP w0.076: UT1.AB17 33.75,88.56 34.29,88.56 34.33,88.53 34.91,88.53 34.91,88.52 34.9,88.51 34.92,88.51
  TOP w0.104: CT172.2 37.45,88.27 37.21,88.51 34.92,88.51
SW2_DP1_P2: length 102.4
  TOP w0.104: CT174.1 36.37,89.24 36.72,89.24 v2(36.82,89.14)
  IN3 w0.135: v2(36.82,89.14) 36.8,89.16 36.28,89.16 35.84,89.59 35.84,90.56 34.41,92 34.41,93.54 35.38,94.51 36.13,94.51 36.77,95.15 37.65,95.15 39.64,97.15 41.35,97.15 42.09,97.88 42.09,101.37 43.88,103.17 43.88,104.31 44.26,104.69 44.26,108.09 47.28,111.12 51.79,111.12 54.46,113.8 56.25,113.8 56.83,114.37 60.53,114.37 60.8,114.65 70.89,114.65 72.57,112.97 87.44,112.97 89.99,115.53 98.64,115.53 99.81,116.69 106.38,116.69 108.36,114.71 110.79,114.71 111.24,114.27 v2(111.24,113.34)
  BOTTOM w0.102: 111.41,112.87 111.54,112.74 111.54,112.52 111.53,112.52 111.73,112.32 UV7.35
  BOTTOM w0.104: 111.41,112.87 111.34,112.94 111.34,112.94 111.24,113.04 v2(111.24,113.34)
SW2_DP1_P2_C: length 2.6
  TOP w0.076: 34.81,89.13 34.42,89.52 34.24,89.52 34.19,89.46 33.78,89.46 33.67,89.56 UT1.AB19
  TOP w0.104: CT174.2 35.5,89.34 35.46,89.34 35.24,89.13 35.01,89.13 35.01,89.13 34.81,89.13
SW2_DP1_P3: length 94
  TOP w0.104: v2(36.48,92.65) 36.48,92.39 CT173.1
  IN3 w0.135: v2(110.09,113.29) 109.92,113.46 109.92,113.7 109.66,113.96 108.04,113.96 107.23,114.77 90.3,114.77 87.69,112.16 72.27,112.16 71,113.43 56.99,113.43 56.6,113.04 54.78,113.04 52.05,110.31 47.54,110.31 45.02,107.79 45.02,102.3 43.88,101.16 43.88,95.05 43.01,94.18 40.93,94.18 40.62,94.48 38.65,94.48 37.42,93.25 37.17,93.25 36.56,92.65 v2(36.48,92.65)
  BOTTOM w0.104: v2(110.09,113.29) 110.09,112.76 110.53,112.31 UV7.32
SW2_DP1_P3_C: length 2.8
  TOP w0.076: UT1.AB21 33.76,90.84 34.28,90.84 34.54,91.1 34.92,91.1
  TOP w0.104: 34.92,91.1 35.57,91.1 35.64,91.17 35.64,91.19 35.67,91.23 CT173.2
SW2_DP2_AUXN: length 250.3
  IN3 w0.135: v2(285.1,65.6) 284.93,65.43 283.75,65.43 282.44,66.74 277.99,66.74 275.2,69.53 267.62,69.53 265.52,67.42 263.79,67.42 263.05,66.69 260.28,66.69 255.69,62.1 254.6,62.1 243.91,51.41 241.57,51.41 241.11,50.96 240.79,50.96 238.17,48.33 238.07,48.33 233.68,48.33 232.96,49.05 209.32,49.05 196.67,61.7 196.67,62.91 193.65,65.93 193.65,68.33 191.78,70.2 191.78,72.25 191.39,72.65 191.39,82.14 190.65,82.87 190.65,88.32 187.64,91.33 183.52,91.33 180.9,93.95 180.9,98.42 179.96,99.36 178.29,99.36 175.94,101.71 171.11,101.71 168.95,103.86 168.6,103.86 164.08,108.39 163.87,108.39 163.81,108.45 159.27,108.45 158.79,108.93 154.74,108.93 151.57,112.1 122.8,112.1 120.99,110.29 110.15,110.29 109.86,110.58 106.81,110.58 106.15,111.25 105.5,111.25 105.17,110.91 105.17,110.6 v2(105.02,110.46)
  BOTTOM w0.104: RV71.1 104.46,106.74 104.46,107.63 105.22,108.39 105.22,110.26 v2(105.02,110.46) 105.16,110.59 105.16,110.95 105.4,111.19 106.36,111.19 107.53,110.02 UV7.27 ; CV150.1 287.28,60.86 286.36,61.77 v4(286.36,63.53) 286.36,64.75 285.67,65.45 285.25,65.45 v2(285.1,65.6)
SW2_DP2_AUXN_C: length 23
  BOTTOM w0.104: JNGFF1.20 282.99,40.05 285.72,42.78 285.72,53.74 285.51,53.96 285.51,56.11 285.57,56.18 285.6,56.18 286.04,56.61 286.04,56.66 v4(287.06,57.68) 287.28,57.89 CV150.2
SW2_DP2_AUXP: length 250.1
  IN3 w0.135: v2(105.61,110.46) 105.41,110.65 105.41,110.81 105.61,111 106.05,111 106.71,110.34 109.76,110.34 110.05,110.05 121.09,110.05 122.9,111.86 151.47,111.86 154.64,108.69 158.69,108.69 159.17,108.21 163.71,108.21 163.77,108.15 163.98,108.15 168.5,103.62 168.85,103.62 171.01,101.47 175.84,101.47 178.19,99.12 179.86,99.12 180.66,98.32 180.66,93.85 183.42,91.09 187.54,91.09 190.41,88.22 190.41,82.77 191.15,82.04 191.15,72.55 191.54,72.15 191.54,70.1 193.41,68.23 193.41,65.83 196.43,62.81 196.43,61.6 209.22,48.81 232.86,48.81 233.58,48.09 237.97,48.09 238.27,48.09 240.89,50.72 241.21,50.72 241.67,51.17 244.01,51.17 254.7,61.86 255.79,61.86 260.38,66.45 263.15,66.45 263.89,67.18 265.62,67.18 267.72,69.29 275.1,69.29 277.89,66.5 282.34,66.5 283.65,65.19 284.93,65.19 285.08,65.03 v2(285.08,64.93)
  BOTTOM w0.104: UV7.26 108.92,109.62 108.75,109.79 108.59,109.79 108.56,109.82 107.45,109.82 106.27,110.99 105.49,110.99 105.36,110.87 105.36,110.71 v2(105.61,110.46) 105.42,110.27 105.42,108.31 104.66,107.55 104.66,106.66 104.66,106.66 RV77.1 ; CV149.1 286.39,60.36 286.51,60.48 286.97,60.48 287.08,60.59 287.08,60.77 286.16,61.69 286.16,63.22 286.13,63.25 286.13,63.82 286.16,63.85 286.16,64.67 285.58,65.25 285.25,65.25 285.08,65.08 v2(285.08,64.93)
SW2_DP2_AUXP_C: length 23.1
  BOTTOM w0.104: CV149.2 287.08,58.37 287.08,58.02 286.69,57.64 286.69,57.6 v4(285.64,56.54) 285.31,56.21 285.31,53.87 285.52,53.66 285.52,42.87 282.91,40.25 282.17,40.25 281.87,40.55 JNGFF1.22
SW2_DP2_CADET: length 13.3
  TOP w0.102: RV74.1 103.71,112.27 104.51,111.46 v1(106.39,111.46) 113.62,111.46 v2(114.93,112.77)
  BOTTOM w0.102: UV7.43 v2(114.93,112.77)
SW2_DP2_HPD: length 224.6
  IN1 w0.102: v2(286.26,47.91) 285.44,48.72 283.15,48.72 280.12,51.75 279.69,51.75 279.24,51.3 275.79,51.3 v2(275.44,51.66)
  IN2 w0.102: v2(275.44,51.66) 275.34,51.66 274.51,52.48 274.51,55.21 273.81,55.91 271.12,55.91 269.6,57.43 265.55,57.43 263.47,59.51 259.64,59.51 258.86,58.73 251.87,58.73 242.97,49.83 210.24,49.83 191.1,68.96 190.57,68.96 188.81,70.72 188.81,71.9 186.19,74.51 185.48,74.51 176.63,83.36 176.63,87.26 177.34,87.97 177.34,89.46 177.47,89.59 177.47,90.97 175.38,93.07 175.38,94.99 171.71,98.66 171.71,99.79 168.53,102.96 168.16,102.96 163.08,108.05 159.29,108.05 159.1,108.23 158.44,108.23 151.69,114.98 121.15,114.98 v2(119.57,113.39)
  BOTTOM w0.102: v2(119.57,113.39) 118.95,114.01 117.71,114.01 v3(117.5,113.8) 117.47,113.77 117.47,112.99 116.93,112.45 UV7.48 ; JNGFF1.31 287.14,42.8 286.77,43.17 286.77,47.4 v2(286.26,47.91)
SW2_DP2_N0: length 229.3
  IN3 w0.135: v2(283.74,67.71) 283.56,67.9 283.13,67.9 282.1,68.93 278.61,68.93 276.66,70.88 266.74,70.88 264.64,68.78 263.11,68.78 262.32,67.99 259.78,67.99 255.16,63.37 254.07,63.37 252.99,62.29 251.48,62.29 245.66,56.47 245.66,55.58 243.39,53.31 241.8,53.31 241.27,53.31 238.36,50.4 209.92,50.4 197.98,62.34 197.98,63.47 195.05,66.4 195.05,68.77 193.82,69.99 193.82,72.23 192.67,73.38 192.67,83.18 191.94,83.91 191.94,96.18 189.72,98.41 189.21,98.41 188.59,99.03 186.65,99.03 186.18,99.5 186.18,99.78 185.46,100.49 181.37,100.49 180.27,101.59 179.02,101.59 176.99,103.63 172,103.63 165.91,109.72 159.8,109.72 159.05,110.47 155.1,110.47 152.18,113.39 121.8,113.39 121.1,112.7 118.55,112.7 118.27,112.98 118.27,112.98 118.04,113.21 118.04,113.21 v2(117.87,113.37)
  BOTTOM w0.102: 117.33,112.35 117.33,112.51 117.53,112.71 117.53,112.72 117.93,113.12 117.93,113.12 117.95,113.14 ; UV7.49 117.33,112.22
  BOTTOM w0.104: 117.95,113.14 117.95,113.3 v2(117.87,113.37) ; CV156.1 283.31,59.98 283.06,60.23 v4(283.06,61.44) 283.06,62.24 283.39,62.57 283.39,67.36 v2(283.74,67.71) ; 117.33,112.22 117.33,112.35
SW2_DP2_N0_C: length 20
  BOTTOM w0.104: JNGFF1.32 281.87,43.05 282.02,43.2 283.32,43.2 283.91,43.78 283.91,46.5 284.22,46.82 284.22,50.48 283.91,50.79 283.91,52.33 282.14,54.09 282.14,55.94 282.65,56.45 282.66,56.45 282.99,56.79 282.99,56.79 283.4,57.2 v4(283.4,58.07) CV156.2
SW2_DP2_N1: length 231.1
  IN3 w0.135: v2(116.47,113.32) 116.72,113.07 116.72,112.15 117.44,111.43 121.01,111.43 122.22,112.64 151.77,112.64 154.76,109.65 158.81,109.65 159.48,108.97 165.58,108.97 171.67,102.87 176.5,102.87 178.58,100.79 179.7,100.79 180.96,99.53 182.73,99.53 183.58,98.67 185.37,98.67 185.93,98.11 188.42,98.11 188.94,97.59 189.39,97.59 191.18,95.8 191.18,83.31 191.91,82.57 191.91,72.97 192.31,72.58 192.31,70.42 194.25,68.47 194.25,66.11 197.22,63.14 197.22,62.02 209.6,49.65 238.67,49.65 241.03,52.01 243.78,52.01 254.39,62.61 255.48,62.61 260.07,67.2 262.75,67.2 263.51,67.96 265.03,67.96 267.16,70.09 275.37,70.09 277.69,67.77 280.03,67.77 280.26,67.54 282.41,67.54 283.98,65.98 284.41,65.98 v2(284.57,65.83)
  BOTTOM w0.102: 116.33,112.54 116.13,112.34 UV7.46
  BOTTOM w0.104: v2(284.57,65.83) 284.41,65.99 284.3,65.99 284.18,65.86 284.18,62.38 285.31,61.25 CV152.1 ; 116.33,112.54 116.33,112.61 116.67,112.95 116.67,113.12 v2(116.47,113.32)
SW2_DP2_N1_C: length 21
  BOTTOM w0.104: CV152.2 v4(285.31,58.1) 285.31,57.82 284.64,57.15 284.64,56.63 284.61,56.6 284.61,51.18 284.92,50.87 284.92,46.55 285.03,46.44 285.03,43.25 283.47,41.69 281.94,41.69 281.8,41.55 JNGFF1.26
SW2_DP2_N2: length 263.9
  IN3 w0.135: v2(115.27,113.29) 115.26,113.29 115.26,113.9 115.8,114.44 152.75,114.44 155.64,111.54 159.39,111.54 160.21,110.72 166.36,110.72 167.28,109.8 170.65,109.8 170.85,109.6 174.99,109.6 175.82,108.76 175.82,106.53 178.57,103.78 179.68,103.78 181.78,101.68 184.71,101.68 185.84,102.81 187.27,102.81 188.67,101.42 188.67,100.89 191.16,98.39 192.38,98.39 192.99,97.78 192.99,84.57 193.68,83.88 193.68,74 194.86,72.81 194.86,70.39 196.17,69.08 196.17,66.72 198.99,63.9 198.99,62.76 210.29,51.45 238,51.45 241.02,54.48 243.03,54.48 244.18,55.63 244.18,56.58 244.18,56.78 250.7,63.3 252.59,63.3 253.66,64.37 254.75,64.37 259.41,69.03 259.61,69.03 261.95,69.03 262.81,69.89 264.15,69.89 267.16,72.91 276.35,72.91 279.32,69.94 282.36,69.94 282.55,70.14 283.75,70.14 286.28,67.61 v2(288.76,67.61)
  BOTTOM w0.104: CV148.1 295.17,42.28 295.42,42.53 295.42,45.23 294.85,45.8 294.85,46.9 294.46,47.29 294.46,50 295.59,51.13 295.59,53.58 295.02,54.15 295.02,57.45 291.28,61.19 291.28,61.93 290.87,62.33 290.87,64.89 290.45,65.31 290.45,66.74 289.59,67.61 v2(288.76,67.61) ; v2(115.27,113.29) 115.33,113.22 UV7.44
SW2_DP2_N2_C: length 5.5
  BOTTOM w0.104: JNGFF1.25 289.42,41.3 289.57,41.45 v4(290.59,41.45) 291.51,41.45 291.96,41.9 292,41.9 292.41,42.31 292.41,42.35 292.7,42.64 292.93,42.64 CV148.2
SW2_DP2_N3: length 268.8
  IN3 w0.135: v2(289.24,68.59) 286.37,68.59 284.07,70.89 283.66,70.89 281.68,72.88 277.57,72.88 276.76,73.69 266.81,73.69 264.42,71.3 263,71.3 261.83,70.13 259.44,70.13 254.72,65.42 251.25,65.42 244.06,58.23 243.17,58.23 239.13,54.19 236.97,54.19 235.06,52.28 210.67,52.28 199.79,63.16 199.79,64.19 196.93,67.05 196.93,69.44 195.64,70.72 195.64,73.11 194.46,74.29 194.46,97.47 192.66,99.27 191.36,99.27 189.46,101.17 189.46,102.76 188.61,103.61 185.54,103.61 185.04,103.11 182.51,103.11 181.76,103.86 180.78,103.86 180.05,104.59 178.92,104.59 176.66,106.84 176.66,108.99 175.3,110.35 171.17,110.35 169.87,111.65 166.33,111.65 166.16,111.48 160.52,111.48 159.7,112.3 155.96,112.3 152.9,115.36 115.26,115.36 114.13,114.23 v2(114.13,113.29)
  BOTTOM w0.104: v2(114.13,113.29) 114.13,113.29 UV7.41 ; CV145.1 295.38,40.14 296.1,40.86 296.1,42.96 296.13,42.99 296.13,43.82 296.1,43.85 296.1,45.68 295.53,46.25 295.53,47.6 295.18,47.96 295.18,49.74 296.28,50.84 296.28,53.89 295.73,54.44 295.73,57.71 291.96,61.48 291.96,62.21 291.56,62.62 291.56,65.17 291.2,65.53 291.2,67.4 290.11,68.48 289.35,68.48 v2(289.24,68.59)
SW2_DP2_N3_C: length 5.3
  BOTTOM w0.104: JNGFF1.19 290.13,39.8 290.14,39.79 290.83,39.79 291.58,40.53 v4(292.23,40.53) 292.23,40.53 292.58,40.53 292.59,40.53 292.98,40.53 CV145.2
SW2_DP2_P0: length 229.2
  IN3 w0.135: v2(283.59,68.3) 283.42,68.14 283.23,68.14 282.2,69.17 278.71,69.17 276.76,71.12 266.64,71.12 264.54,69.02 263.01,69.02 262.22,68.23 259.68,68.23 255.06,63.61 253.97,63.61 252.89,62.53 251.38,62.53 245.42,56.57 245.42,55.68 243.29,53.55 241.91,53.55 241.17,53.55 238.26,50.64 210.02,50.64 198.22,62.44 198.22,63.57 195.29,66.5 195.29,68.87 194.07,70.09 194.07,72.33 192.92,73.48 192.92,83.28 192.18,84.01 192.18,96.28 189.82,98.65 189.31,98.65 188.69,99.27 186.75,99.27 186.42,99.6 186.42,99.88 185.56,100.73 181.47,100.73 180.37,101.83 179.12,101.83 177.09,103.87 172.1,103.87 166.01,109.97 159.9,109.97 159.15,110.71 155.2,110.71 152.28,113.63 121.7,113.63 121,112.94 118.65,112.94 118.43,113.16 v2(118.43,113.37)
  BOTTOM w0.102: UV7.50 117.73,112.35 117.68,112.4 117.68,112.54 117.76,112.62 117.76,112.62 118.24,113.1 118.24,113.14 118.24,113.14 118.24,113.18 118.24,113.18
  BOTTOM w0.104: CV157.1 282.86,60.32 282.86,61.12 282.83,61.15 282.83,61.72 282.86,61.75 282.86,62.32 283.19,62.65 283.19,67.73 283.59,68.12 v2(283.59,68.3) ; 118.24,113.18 118.24,113.27 118.35,113.37 v2(118.43,113.37)
SW2_DP2_P0_C: length 20
  BOTTOM w0.104: JNGFF1.34 281.87,43.55 282.02,43.4 283.24,43.4 283.71,43.87 283.71,46.59 284.02,46.9 284.02,50.4 283.71,50.71 283.71,52.24 281.94,54.01 281.94,56.03 v4(282.68,56.76) 283.2,57.29 283.2,57.83 283.2,57.83 283.2,58.38 CV157.2
SW2_DP2_P1: length 231.2
  IN3 w0.135: v2(284.57,66.41) 284.38,66.22 284.08,66.22 282.51,67.79 280.36,67.79 280.13,68.01 277.79,68.01 275.47,70.33 267.06,70.33 264.93,68.2 263.41,68.2 262.65,67.45 259.97,67.45 255.38,62.86 254.29,62.86 243.68,52.25 240.93,52.25 238.57,49.89 209.7,49.89 197.46,62.12 197.46,63.24 194.49,66.21 194.49,68.57 192.55,70.52 192.55,72.68 192.15,73.07 192.15,82.67 191.42,83.41 191.42,95.9 189.49,97.83 189.04,97.83 188.52,98.35 186.03,98.35 185.47,98.91 183.68,98.91 182.83,99.77 181.06,99.77 179.8,101.03 178.68,101.03 176.6,103.12 171.77,103.12 165.68,109.21 159.58,109.21 158.91,109.89 154.86,109.89 151.87,112.88 122.12,112.88 120.91,111.67 117.54,111.67 116.96,112.25 116.96,113.25 117,113.28 117,113.29 v2(117.03,113.32)
  BOTTOM w0.104: CV153.1 285.11,60.66 285.11,61.16 283.98,62.29 283.98,65.95 284.22,66.19 284.34,66.19 v2(284.57,66.41) ; UV7.47 116.53,112.53 116.87,112.87 116.87,113.15 v2(117.03,113.32)
SW2_DP2_P1_C: length 21
  BOTTOM w0.104: CV153.2 285.08,58.4 285.08,57.87 284.41,57.2 v4(284.41,56.91) 284.41,51.1 284.72,50.79 284.72,46.47 284.83,46.36 284.83,43.34 283.38,41.89 282.04,41.89 281.87,42.05 JNGFF1.28
SW2_DP2_P2: length 263.9
  IN3 w0.135: v2(288.76,67.02) 288.42,67.36 286.18,67.36 283.65,69.9 282.65,69.9 282.46,69.7 279.22,69.7 276.33,72.59 267.18,72.59 264.25,69.65 262.91,69.65 262.05,68.79 259.51,68.79 254.85,64.13 253.76,64.13 252.69,63.06 250.8,63.06 244.42,56.68 244.42,55.53 243.13,54.24 241.12,54.24 238.1,51.21 210.19,51.21 198.74,62.66 198.74,63.8 195.92,66.62 195.92,68.98 194.62,70.29 194.62,72.71 193.44,73.9 193.44,83.78 192.75,84.47 192.75,97.68 192.28,98.15 191.06,98.15 188.42,100.79 188.42,101.32 187.17,102.57 185.94,102.57 184.81,101.44 181.68,101.44 179.58,103.54 178.47,103.54 175.58,106.43 175.58,108.66 174.89,109.35 170.75,109.35 170.55,109.56 167.18,109.56 166.26,110.48 160.11,110.48 159.29,111.3 155.54,111.3 152.65,114.2 115.9,114.2 115.5,113.8 115.5,113.62 v2(115.84,113.29)
  BOTTOM w0.104: v2(288.76,67.02) 289.15,67.41 289.5,67.41 290.25,66.66 290.25,65.23 290.67,64.81 290.67,62.25 291.08,61.84 291.08,61.11 294.82,57.36 294.82,54.07 295.39,53.5 295.39,51.21 294.26,50.08 294.26,47.2 294.65,46.82 294.65,45.72 295.21,45.15 295.21,42.61 295.09,42.49 294.9,42.49 294.77,42.61 294.77,43.08 294.67,43.19 CV147.1 ; v2(115.84,113.29) 115.56,113.02 115.56,112.62 115.73,112.45 UV7.45
SW2_DP2_P2_C: length 5.5
  BOTTOM w0.104: CV147.2 292.95,42.84 292.62,42.84 v4(292.04,42.27) 291.43,41.65 290.91,41.65 290.88,41.68 290.3,41.68 290.28,41.65 289.57,41.65 289.42,41.8 JNGFF1.27
SW2_DP2_P3: length 268.8
  IN3 w0.135: v2(114.71,113.29) 114.37,113.63 114.37,114.13 115.36,115.12 152.8,115.12 155.86,112.06 159.6,112.06 160.42,111.24 166.26,111.24 166.43,111.41 169.77,111.41 171.07,110.11 175.2,110.11 176.42,108.89 176.42,106.74 178.82,104.34 179.95,104.34 180.68,103.62 181.66,103.62 182.41,102.87 185.14,102.87 185.64,103.37 188.51,103.37 189.22,102.66 189.22,101.07 191.26,99.03 192.56,99.03 194.22,97.37 194.22,74.19 195.4,73.01 195.4,70.62 196.68,69.34 196.68,66.95 199.54,64.09 199.54,63.06 210.57,52.04 235.16,52.04 237.07,53.95 239.23,53.95 243.27,57.99 244.16,57.99 251.35,65.17 254.82,65.17 259.54,69.89 261.93,69.89 263.1,71.06 264.52,71.06 266.91,73.45 276.66,73.45 277.47,72.64 281.58,72.64 283.56,70.65 283.97,70.65 286.27,68.35 288.9,68.35 v2(289.24,68.01)
  BOTTOM w0.104: v2(114.71,113.29) 114.37,112.95 114.37,112.62 114.53,112.45 UV7.42 ; CV146.1 294.66,41.05 294.83,40.88 294.83,40.45 294.94,40.34 295.3,40.34 295.9,40.94 v4(295.9,43.47) 295.9,45.6 295.33,46.16 295.33,47.52 294.97,47.88 294.97,49.82 296.08,50.93 296.08,53.81 295.53,54.36 295.53,57.63 291.76,61.4 291.76,62.13 291.35,62.53 291.35,65.09 291,65.45 291,67.31 290.03,68.28 289.52,68.28 v2(289.24,68.01)
SW2_DP2_P3_C: length 5.4
  BOTTOM w0.104: CV146.2 293.04,40.73 292.53,40.73 292.5,40.76 291.93,40.76 291.9,40.73 291.49,40.73 290.76,40 290.49,40 290.49,40 v4(290.39,40) 290.3,40 290.29,40 289.72,40 289.42,40.3 JNGFF1.21
SW2_PS8338_CFG0: length 3.1
  BOTTOM w0.102: RV85.1 120.84,107.82 119.38,107.82 119.18,108.02 UV7.59
SW2_PS8338_P0: length 2
  BOTTOM w0.102: UV7.60 119.02,107.62 119.31,107.33 120.3,107.33 RV95.1
SW2_PS8338_P1: length 4.2
  BOTTOM w0.102: RV93.1 119.06,104.31 RV94.1 119.05,104.67 v3(118.48,105.24) 117.73,105.99 UV7.1
SW2_PS8338_PC10: length 5.9
  BOTTOM w0.102: UV7.56 118.86,109.22 119.06,109.41 119.27,109.41 120.13,108.55 v3(120.87,108.55) 121.11,108.55 121.46,108.2 122.71,108.2 RV90.1 RV91.1
SW2_PS8338_PC11: length 5
  BOTTOM w0.102: RV84.1 122.3,108.68 RV83.1 121.43,109.06 120.06,109.06 v3(119.82,109.3) 119.5,109.62 UV7.55
SW2_PS8338_PC20: length 3.6
  BOTTOM w0.102: RV82.1 121.72,110.58 RV81.1 v3(119.66,110.58) 119.09,110.02 UV7.54
SW2_PS8338_PC21: length 6.1
  BOTTOM w0.102: RV80.1 123.55,111.52 122.99,110.97 121.41,110.97 RV79.1 120.21,111.6 119.03,110.42 UV7.53
SW2_PS8338_PEQ: length 3.7
  TOP w0.102: v1(114.37,106.39) 114.37,106.39 v2(114.93,105.82) 115.22,105.54 RV87.1 115.17,105.12 RV88.1
  BOTTOM w0.102: UV7.8 v2(114.93,105.82)
SW2_PS8338_SW: length 2.2
  BOTTOM w0.102: UV7.18 110.93,105.3 RV89.1
SW_+1VALWP: length 1.6
  TOP w0.102: 185.04,96.74 185.04,95.79 v1(185.49,95.34)
  vias: v2(184.39,98.05) v2(184.98,98.06)
SW_USB20_N1: length 2.5
  TOP w0.104: UI3.11 296.54,68.85 296.72,68.66 298.09,68.66 298.24,68.81 LI7.1
SW_USB20_P1: length 2.5
  TOP w0.104: LI7.4 298.2,68.21 297.99,68.43 v4(297.4,68.43) 296.62,68.43 296.54,68.35 UI3.10
SYS_LED_MASK#: length 114.1
  TOP w0.102: v2(259.72,46.48) 259.85,46.48 259.85,46.48 260.62,46.48 261.52,45.59 UE1.A12 ; v2(299.19,72.11) v1(295.87,75.43) 292.61,78.69 292.61,79.85 293.23,80.47 QL2.2 294.23,80.47 294.51,80.18 294.51,79.7 294.81,79.41 295.69,79.41 295.93,79.64 295.93,80.39 296.03,80.49 QL1.5 QL1.2 ; UZ10.1 252.3,33.37 252.71,32.97 253.72,32.97 254.21,33.46 254.21,34.47 254.31,34.58 RE21.1 255.53,34.58 256.07,35.12 256.07,35.76 255.84,35.99 255.84,37.65 v2(256.21,38.02)
  IN1 w0.102: v2(299.19,72.11) 299.19,71.5 299.67,71.02 299.67,69.42 298.67,68.41 298.67,61.78 298.46,61.57 298.46,58.62 297.1,57.26 296.98,57.26 295.53,55.81 295.53,52.18 295.33,51.99 295.33,50.39 294.65,49.71 294.65,49.45 292.03,46.83 292.03,45.04 286.33,39.34 284.48,39.34 284.36,39.46 283.66,39.46 283.26,39.07 280.74,39.07 280.26,38.59 276.65,38.59 275.68,37.63 275.68,36.55 275.38,36.26 274.8,36.26 272.75,38.31 269.68,38.31 269.6,38.39 262.37,38.39 261.38,39.38 258.78,39.38 257.96,38.56 256.76,38.56 v2(256.21,38.02)
  BOTTOM w0.102: v2(259.72,46.48) 259.72,44.93 259.95,44.7 259.95,41.08 259.55,40.68 258.07,40.68 257.64,40.25 257.49,40.25 256.21,38.98 v2(256.21,38.02)
SYS_PWROK: length 309.3
  TOP w0.102: v2(154.88,106.52) 154.93,106.47 154.93,99.65 154.38,99.1 v1(154.38,98.77) 154.38,95.93 148.82,90.37 143.04,90.37 v2(142.46,89.78) ; RE56.1 268.1,34.96 v2(267.76,35.29) ; v2(131.85,110.62) 129.6,112.87 125.56,112.87 124.58,113.85 117.69,113.85 117.48,113.63 117.48,112.49 116.09,111.11 104.33,111.11 103.19,112.25 103.19,112.68 102.81,113.06 101.66,113.06 101.11,112.5 101.11,108.91 98.98,106.79 96.98,106.79 96.01,105.81 91.01,105.81 87.9,102.71 85.98,102.71 84.33,101.06 84.33,99.14 81.85,96.66 81.85,95.26 84.76,92.35 84.76,91.56 84.46,91.26 82.41,91.26 81.67,92 79.83,92 78.39,93.44 74.8,93.44 73.97,94.28 v2(73.97,96.91)
  TOP w0.107: v2(266.74,38.8) 266.83,38.8 UE1.G4
  IN1 w0.102: v2(154.88,106.52) 156.4,108.04 166.76,108.04 169.71,105.09 169.71,101.92 167.5,99.71 167.5,98.41 167.81,98.09 169.23,98.09 171.99,95.33 177.16,95.33 178.68,93.81 180.63,93.81 182.04,92.39 182.04,92.12 194.6,79.56 194.6,68.38 208.76,54.23 209.17,54.23 210.5,52.9 v2(212.41,52.9) ; v2(142.46,89.78) 142.54,89.87 142.54,94.78 141.57,95.76 141.57,96.36 140.12,97.81 140.12,104.88 134.99,110.01 132.46,110.01 v2(131.85,110.62)
  BOTTOM w0.076: v2(142.46,89.78) 142.57,89.67 142.57,88.62 142.4,88.44 142.4,87.91 UC1.B6
  BOTTOM w0.102: v2(212.41,52.9) 212.5,52.9 213.87,51.53 233.98,51.53 236.49,54.04 239.67,54.04 240.7,55.07 245.53,55.07 248.16,52.45 253.88,52.45 255.52,50.81 258.9,50.81 260.61,49.1 260.61,42.5 261.13,41.98 262.83,41.98 263.02,41.8 263.93,41.8 264.92,40.8 266.15,40.8 266.44,40.51 266.44,39.1 v2(266.74,38.8) 266.75,38.79 267.1,38.79 267.56,38.32 267.56,35.42 267.69,35.29 v2(267.76,35.29) ; RC129.1 v2(73.97,96.91)
SYS_RESET#: length 254.6
  TOP w0.112: v2(151.99,96.89) 152.28,96.6 v2(152.28,95.12)
  IN1 w0.119: v2(166.27,95.49) 166.72,95.04 168.61,95.04 172.31,91.34 178.34,91.34 182.34,87.34 182.34,86.92 182.34,75.49 181.82,74.97 181.82,74.31 182.12,74.01 185.42,74.01 186.36,74.95 188.29,74.95 188.98,74.26 189.94,74.26 190.3,74.62 191.31,74.62 191.74,74.19 191.74,69.7 193.66,67.77 194.52,67.77 208.55,53.74 208.97,53.74 210.3,52.41 234.86,52.41 236.58,54.13 242.46,54.13 244.36,56.03 244.36,56.38 250.67,62.69 251.8,62.69 252.85,63.74 259.32,63.74 267.14,71.57 267.14,97.4 273.39,103.65 311.96,103.65 313.61,105.3 315.88,105.3 v2(318.6,102.58)
  BOTTOM w0.076: 144.4,92.04 143.8,91.44 143.8,90.32 142.88,89.4 142.88,88.57 143.25,88.2 UC1.B5
  BOTTOM w0.112: v2(166.27,95.49) 166.16,95.61 v3(162.12,95.61) 153.51,95.61 153.02,95.12 v2(152.28,95.12) 152.28,94.51 151.52,93.75 150.15,93.75 149.56,93.16 145.56,93.16 144.44,92.04 144.4,92.04 ; JAPS1.13 318.35,102.84 v2(318.6,102.58) 318.6,101.82 CC302.1 ; RC291.1 150.94,97.6 RC224.2 151.81,97.07 v2(151.99,96.89)
SYS_RESET#_R: length 4
  BOTTOM w0.112: RC290.2 152.71,98.51 RC224.1 151.81,99.11 v1(151.24,99.68) 150.09,99.68 UC12.4
TBT_CIO_PLUG_EVENT#: length 223.3
  TOP w0.076: 32.74,80.28 32.74,80.49 32.49,80.74 32.49,81.12 32.37,81.24 32.37,81.66 UT1.W2
  TOP w0.112: 32.74,80.28 32.74,79.57 v2(33.4,78.91)
  IN1 w0.076: v2(137.81,76.97) 138.05,76.97 138.41,77.34 139.44,77.34 139.47,77.37 144.69,77.37 146.07,78.76 148.85,78.76 149.34,79.24 149.34,79.62 149.91,80.19
  IN1 w0.102: v2(150.75,101.34) 151.29,100.8 151.29,99.76 152.43,98.62 152.43,95.87 151.46,94.9 151.46,94.53 151.64,94.35 151.64,91.75 150.96,91.07 150.96,85.52 152.76,83.72 152.76,81.46 152.31,81.01 151.45,81.01 151.17,80.73 150.45,80.73 149.91,80.19
  IN2 w0.102: v2(33.4,78.91) 34.88,78.91 35.94,77.84 37.07,77.84 37.95,78.72 37.95,81.43 38.15,81.64 38.15,82.71 35.43,85.44 35.43,87.76 34.6,88.6 34.6,92.44 34.14,92.9 34.14,94.93 34.46,95.26 34.46,96.21 33.49,97.18 33.49,100.1 37.64,104.25 37.64,104.91 41.29,108.56 58.52,108.56 62.8,112.83 70.61,112.83 71.39,112.05 76.78,112.05 78.57,110.27 92.26,110.27 92.46,110.47 102.48,110.47 103,109.95 105.85,109.95 106.04,110.14 120.14,110.14 123.2,113.2 151.04,113.2 158.06,106.18 v2(158.45,106.18)
  BOTTOM w0.076: UC1.AB12 138.66,77.43 138.34,77.12 137.96,77.12 v2(137.81,76.97)
  BOTTOM w0.102: v2(158.45,106.18) 158.45,105.86 v1(155.25,102.66) 153.93,101.34 v2(150.75,101.34) 150.55,101.54 RT391.1 ; RT371.1 35.79,77.95 34.83,78.91 v2(33.4,78.91)
TBT_DP_RBIAS: length 9
  TOP w0.102: UT1.N6 v2(29.91,84.21)
  IN3 w0.102: v2(34.8,83.53) 34.8,83.99 33.68,85.11 31.04,85.11 30.89,85.26 29.75,85.26 29.52,85.03 29.52,84.6 v2(29.91,84.21)
  BOTTOM w0.102: v3(35.1,83.13) 34.8,83.43 v2(34.8,83.53)
  BOTTOM w0.112: RT35.1 34.8,83.89 v2(34.8,83.53)
TBT_FORCE_PWR: length 226.3
  TOP w0.102: v2(26.66,82.91) UT1.H4
  IN2 w0.102: v2(26.66,82.91) 26.66,82.13 27.23,81.55 32,81.55 33.57,79.98 34.73,79.98 35.52,79.19 36.81,79.19 37.04,79.42 37.04,80.16 36.64,80.56 36.37,80.56 35.56,81.36 35.56,82.33 35.17,82.72 34.65,82.72 33.78,83.58 33.78,92.1 30.88,95.01 29.67,95.01 28.92,95.76 28.92,99.69 30.9,101.67 33.22,101.67 34.83,103.27 34.83,105.16 35.64,105.97 37.08,105.97 40.68,109.57 58.08,109.57 63.03,114.53 70.35,114.53 71.81,113.07 77.21,113.07 78.68,111.59 92.01,111.59 92.15,111.73 102.31,111.73 102.52,111.94 115.11,111.94 115.66,112.49 121.05,112.49 122.88,114.32 151.44,114.32 158.14,107.61 158.8,107.61 159.06,107.36 160.21,107.36 v2(161.41,106.16)
  BOTTOM w0.076: UC1.B7 141.99,87.97 141.65,88.32 141.65,89.78 142.92,91.05 142.92,92.08 143.64,92.8
  BOTTOM w0.102: v2(161.41,106.16) 160.88,105.62 159.15,105.62 158.83,105.94 158.83,106.52 158.26,107.09 v1(152.21,107.09) 149.49,107.09 147.7,105.3 147.7,101.75 147.85,101.6 147.85,100.08 147.68,99.9 147.68,97.69 147.96,97.41 147.96,96.1 147.25,95.39 145.82,95.39 144.94,94.5 144.76,94.5 144.52,94.25 144.52,93.68 143.64,92.8
  BOTTOM w0.112: v2(26.66,82.91) 25.82,82.07 25.82,81.44 25.44,81.06 25.44,78.43 RT27.1
TBT_I2C_SCL: length 21.3
  TOP w0.076: UT1.U2 31.45,81.66 31.45,80.87 31.25,80.67 31.25,80.31 31.27,80.3 31.27,80.28 ; 29.9,64.84 29.76,64.7 29.76,64.4 29.51,64.15 29.51,63.56 UT5.D2
  TOP w0.112: v2(31.04,75) 30.86,75.18 30.86,75.53 31.13,75.8 RT19.1 30.86,76.28 30.86,77.78 31.7,78.62 31.7,79.52 31.27,79.95 31.27,80.28 ; 29.9,64.84 v2(29.96,64.9)
  IN1 w0.119: v2(29.96,64.9) 30.07,65.01 30.41,65.01 30.72,65.32 30.72,66.14 30.17,66.7 30.17,70.98 30.89,71.7 30.89,74.85 v2(31.04,75)
TBT_I2C_SDA: length 21.1
  TOP w0.076: 31.03,80.28 31.03,80.3 31.05,80.31 31.05,80.76 31.25,80.96 31.25,81.04 31.19,81.1 31.1,81.1 31,81.2 31,81.54 31.07,81.6 31.17,81.6 31.23,81.54 UT1.U1 ; 29.53,64.84 29.53,64.55 29.26,64.28 UT5.D1
  TOP w0.112: 31.03,80.28 31.03,79.85 31.46,79.42 31.46,78.72 30.62,77.88 30.62,76.28 RT18.1 30.36,75.8 30.62,75.53 30.62,75.14 v2(30.48,75) ; v2(29.96,65.49) 29.53,65.06 29.53,64.84
  IN1 w0.119: v2(30.48,75) 30.65,74.83 30.65,71.81 29.92,71.08 29.92,66.59 30.48,66.04 30.48,65.42 30.31,65.26 30.19,65.26 v2(29.96,65.49)
TBT_JTAG_TCK: length 3.9
  TOP w0.102: v2(30.56,82.91) UT1.T4
  BOTTOM w0.112: RT6.1 32.01,81.1 31.51,81.1 v1(31.38,81.22) 30.95,81.65 30.95,82.51 v2(30.56,82.91)
TBT_JTAG_TDI: length 2.3
  TOP w0.076: UT1.Y4 v2(32.51,82.9)
  BOTTOM w0.102: RT8.1 33.24,84.11 v3(33.14,84.21)
  BOTTOM w0.112: RT8.1 32.9,82.9 v2(32.51,82.9)
TBT_JTAG_TDO: length 2.1
  TOP w0.102: v2(31.86,82.91) UT1.W4
  BOTTOM w0.112: v2(31.86,82.91) 32.41,82.35 RT5.1
TBT_JTAG_TMS: length 2.5
  TOP w0.102: UT1.V4 v2(31.21,82.91)
  BOTTOM w0.112: v2(31.21,82.91) 32.54,81.57 RT7.1
TBT_PCIE_RBIAS: length 5.2
  TOP w0.112: UT1.N16 v2(29.91,88.76)
  BOTTOM w0.102: v3(33.07,91.22) 32.3,91.22 RT34.1
  BOTTOM w0.112: v2(29.91,88.76) 29.91,89 30.54,89.63 31.33,89.63 31.93,90.23 31.93,90.85 RT34.1
TBT_PWR_EN: length 14.4
  BOTTOM w0.076: UC1.D7 141.99,86.64 142.42,86.21 143.65,86.21 144.2,86.76 144.2,87.33 144.71,87.84 144.71,88.31 144.87,88.47 144.87,88.75 144.53,89.1 144.53,90.72 145.12,91.31
  BOTTOM w0.102: T269.1 150.75,92.47 150.46,92.18 145.99,92.18 145.12,91.31
TBT_RBIAS: length 2.3
  TOP w0.102: UT1.H6 v2(26.65,83.55)
  BOTTOM w0.112: RT39.2 27.24,84.08 27.18,84.08 v2(26.65,83.55)
TBT_RESET_N_EC: length 398.7
  TOP w0.102: UT1.F4 v2(26.01,82.9) ; RT110.2 27.76,55.27 v2(27.67,55.18) ; v2(279.21,40.7) 279.25,40.67 RE506.1
  IN1 w0.102: v2(21.41,73.59) 21.41,73.15 20.63,72.37 20.63,67.35 21.19,66.8 21.66,66.8 25.77,62.68 25.77,59.76 27.13,58.41 27.13,58.09 26.87,57.83 26.87,55.98 v2(27.67,55.18)
  IN2 w0.102: v2(279.21,40.7) 279.21,40.01 279.44,39.78 279.44,31.76 277.75,30.07 273.51,30.07 273.46,30.03 268.63,30.03 267.68,29.08 266.74,29.08 266.29,29.52 264,29.52 262.48,31.04 261.44,31.04 260.27,32.21 260.27,33.46 258.39,35.33 256.54,35.33 255.78,36.09 255.49,36.09 254.93,35.53 253.1,35.53 252.68,35.95 249.37,35.95 246.56,38.77 242.51,38.77 242.28,39 238.77,39 238.31,39.46 222.81,39.46 220.26,42.01 210.63,42.01 209.81,41.18 209.08,41.18 208.26,42.01 207.87,42.01 206.76,42.01 203.62,45.14 202.97,45.14 201.05,47.07 201.05,47.43 196.76,51.72 196.18,51.72 190.6,57.3 190.07,57.3 186.22,61.15 186.09,61.15 180.1,67.14 180.1,67.86 177,70.96 176.13,70.96 174.23,72.86 173.92,72.86 173.87,72.91 173.83,72.91 171.96,74.78 171.96,76.81 170.64,78.13 169.8,78.13 169.61,78.32 169.61,79.12 168.3,80.43 168.3,82.02 167.62,82.7 167.62,91.59 167.29,91.93 164.19,91.93 163.38,92.75 163.38,92.75 161.34,94.79 161.11,94.79 160.1,95.8 159.14,95.8 155.64,99.3 155.64,100.49 152.56,103.57 150.89,103.57 150.55,103.91 150.55,104.95 149.4,106.11 135.56,106.11 134.73,105.27 134.73,104.76 132.48,102.51 130.64,102.51 128.36,104.79 123.83,104.79 122.24,103.2 120.25,103.2 119.21,102.15 107.44,102.15 104.98,99.7 102.74,99.7 102.12,100.31 99.35,100.31 98.91,100.76 97.91,100.76 97.15,101.52 76.28,101.52 75.19,100.42 69.16,100.42 68.67,100.91 68.67,101.81 68.38,102.1 62.23,102.1 61.76,101.63 56.9,101.63 56.63,101.36 53.39,101.36 51.32,103.44 48.79,103.44 46.79,101.44 46.79,83.8 46.95,83.64 46.95,77.73 48.39,76.29 48.39,67.38 47.69,66.68 47.69,65.38 47,64.69 47,61.98 v2(45.04,60.01)
  IN3 w0.102: v2(27.67,55.18) 27.67,54.26 28.88,53.05 29.66,53.05 31.55,54.95 31.55,56.95 33.42,58.82 43.84,58.82 v2(45.04,60.01)
  BOTTOM w0.102: RT11.1 23.83,79.23 23.83,75.88 23.38,75.43 21.75,75.43 21.16,74.84 21.16,73.84 v2(21.41,73.59)
  BOTTOM w0.112: RT11.1 24.69,80.09 24.69,80.96 25.38,81.64 25.38,82.27 v2(26.01,82.9)
TBT_RESET_N_EC_R: length 15.6
  TOP w0.102: v2(270.86,42.79) 270.45,42.39 UE1.L8 ; v1(281.65,41.58) RE506.2 280.34,42.31 279.74,42.92 v2(279.15,42.92) 279.06,43 278.64,43 RE95.1
  BOTTOM w0.102: v2(279.15,42.92) 278.98,43.08 276.32,43.08 274.01,40.77 272.52,40.77 272.25,41.04 272.25,42.13 271.56,42.82 270.89,42.82 v2(270.86,42.79)
TBT_ROM_CLK: length 20.3
  TOP w0.076: 34.92,81.69 34.7,81.91 34.7,82.15 34.29,82.56 33.77,82.56 33.53,82.8 UT1.AB4
  TOP w0.112: 34.92,81.69 v2(35.08,81.53)
  BOTTOM w0.112: v2(35.08,81.53) 34.86,81.31 34.86,80.14 34.32,79.6 33.45,79.6 32.87,79.01 32.87,78.28 v3(33.94,77.21) 34.42,76.73 34.42,75.85 33.52,74.95 32.9,74.95 30.59,72.65 29.02,72.65 27.21,70.83 UT2.6
TBT_ROM_CS#: length 14.9
  TOP w0.076: 34.81,81.11 34.75,81.17 34.75,81.37 34.5,81.63 34.5,82.01 34.16,82.34 UT1.AC3
  TOP w0.102: RT2.1 34.88,74.09 v2(34.04,74.09)
  TOP w0.112: 34.81,81.11 34.98,80.94 v2(35.31,80.94)
  BOTTOM w0.102: v2(35.31,80.94) 35.54,80.94 35.87,80.61 35.87,78.68 36.44,78.1 36.44,77.68 37.44,76.68 37.44,75.99 36.96,75.51 35.27,75.51 v3(34.83,75.07) 34.04,74.28 v2(34.04,74.09) 34.04,73.48 33.94,73.37 UT2.1
TBT_ROM_DI: length 22.2
  TOP w0.076: UT1.AB3 33.76,82.11 34.16,82.11 34.32,81.95 34.32,81.53 34.52,81.32 34.52,80.99
  TOP w0.112: 34.52,80.99 34.52,80.77 34.93,80.36 v2(35.49,80.36)
  BOTTOM w0.102: v2(35.49,80.36) 35.44,80.31 v3(35.44,79.34) 35.44,78.78 36.24,77.98 36.24,77.6 37.24,76.6 37.24,76.07 36.87,75.71 34.97,75.71 33.73,74.47 33.1,74.47 30.79,72.15 29.26,72.15 26.67,69.56 UT2.5
TBT_ROM_DO: length 16.4
  TOP w0.076: UT1.AC4 34.33,82.8 34.86,82.26
  TOP w0.102: v2(34.44,72.94) 34.75,73.25 RT3.1
  TOP w0.112: v2(35.12,82.14) 34.99,82.26 34.86,82.26
  BOTTOM w0.102: UT2.2 34.18,72.1 34.44,72.37 v2(34.44,72.94) 34.62,73.12 34.62,74.43 35.5,75.3 37.11,75.3 37.64,75.84 37.64,77.21 v3(37.4,77.45) 36.1,78.76 36.1,80.71 35.57,81.24 35.57,81.69 v2(35.12,82.14)
TBT_ROM_HOLD#: length 2.7
  BOTTOM w0.102: RT1.1 23.88,72.92 v3(24.66,72.14) 24.69,72.1 UT2.7
TBT_ROM_WP#: length 15.4
  TOP w0.076: UT1.V1 31.69,80.8 v2(31.78,80.71)
  TOP w0.102: v2(34.38,71.54) 34.38,71.61 34.99,72.23 RT4.1
  IN3 w0.102: v2(31.78,80.71) 31.87,80.8 32.3,80.8 34.47,78.63 34.47,75.69 34.9,75.25 34.9,72.06 v2(34.38,71.54)
  BOTTOM w0.102: UT2.3 33.99,70.83 34.38,71.22 v2(34.38,71.54) ; v2(31.78,80.71) 31.78,79.85 v3(31.94,79.69)
TBT_RSENSE: length 1.9
  TOP w0.102: UT1.J6 27.32,84.19 v2(26.65,84.19)
  BOTTOM w0.112: v2(26.65,84.19) 26.65,84.35 27.08,84.78 RT39.1
TBT_SRC_CFG1: length 6.6
  TOP w0.076: 33.64,80.28 33.45,80.46 33.45,80.77 33.07,81.15 UT1.AA1
  TOP w0.102: RT338.1 RT30.1
  TOP w0.112: RT338.1 36.68,77.97 35.63,79.03 35.31,79.03 34.23,80.1 33.81,80.1 33.64,80.28
TBT_TMU_CLK_OUT: length 4.4
  TOP w0.076: UT1.V2 31.92,81.65 31.92,81.14 32.13,80.93 32.13,80.28
  TOP w0.112: RT28.1 32.23,79.47 32.13,79.57 32.13,80.28
TBTA_AUXN: length 39.6
  TOP w0.102: UT1.W15 v2(31.85,88.11)
  TOP w0.112: v2(27.6,69.82) 27.44,69.66 27.21,69.66 26.7,70.17 25.66,70.17 25.19,69.7 25.19,69.39 CT81.1
  IN3 w0.135: v2(27.6,69.82) 27.75,69.67 28.38,69.67 28.64,69.92 32.87,69.92 34.55,68.24 38.06,68.24 38.53,68.71 38.53,71.24 38.13,71.65 38.13,74.84 37.32,75.65 37.32,77.12 37.71,77.52 37.71,83.9 37.41,84.2 35.94,84.2 32.88,87.26 32.34,87.26 32.04,87.56 32.04,87.93 v2(31.85,88.11)
TBTA_AUXN_C: length 6.3
  TOP w0.076: UT5.J2 26.51,63.56 26.51,64.09 25.96,64.64 25.93,64.64 25.92,64.66
  TOP w0.112: CT81.2 25.16,68.47 25.16,68.11 25.14,68.09 25.14,67.9 RT95.1 25.15,67.29 25.15,67.02 25.61,66.56 25.61,64.97 25.92,64.66
TBTA_AUXP: length 39.8
  TOP w0.102: UT1.Y15 32.57,87.78 32.51,87.84 v2(32.51,88.11)
  TOP w0.112: CT80.1 25.45,69.34 25.45,69.59 25.64,69.77 25.77,69.91 26.59,69.91 27.1,69.4 27.44,69.4 v2(27.6,69.24)
  IN3 w0.135: v2(27.6,69.24) 27.75,69.39 28.5,69.39 28.75,69.64 32.76,69.64 34.44,67.96 38.18,67.96 38.82,68.6 38.82,71.36 38.41,71.76 38.41,74.96 37.6,75.77 37.6,77 38,77.4 38,84.02 37.53,84.49 36.06,84.49 32.99,87.55 32.46,87.55 32.32,87.68 32.32,87.93 v2(32.51,88.11)
TBTA_AUXP_C: length 5.7
  TOP w0.076: UT5.J1 26.74,63.83 26.74,64.19 26.12,64.8 26.12,64.83 26.1,64.84
  TOP w0.112: 26.1,64.84 25.87,65.08 25.87,66.67 25.41,67.13 25.41,67.3 RT96.1 25.41,67.9 25.41,67.98 25.43,68 25.43,68.47 CT80.2
TBTA_BOT_N: length 42.2
  TOP w0.076: v2(24.5,60.53) 24.61,60.53 24.72,60.64 24.72,60.69 24.93,60.9 25.26,60.9 25.44,60.73 25.68,60.73 UT5.L7
  IN1 w0.119: v2(24.5,60.53) 24.59,60.53 24.69,60.43 24.69,60.37 24.83,60.24 24.83,60.08 24.66,59.91 24.09,59.91 22.68,61.32 18.13,61.32 17.02,62.43 17.02,74.77 14.23,77.55 14.23,78.86 v2(14.54,79.17)
  IN2 w0.124: v2(16.96,88.89) 16.83,88.76 16.83,88.54 16.75,88.46 16.75,87.41 15.99,86.66 15.99,85.19 16.14,85.04 16.14,82.7 15.64,82.21 15.06,82.21 14.4,81.55 14.4,79.3 v2(14.54,79.17)
  BOTTOM w0.112: v2(16.96,88.89) 16.32,89.54 16.13,89.54 16.02,89.65 16.02,89.65 16,89.66 15.77,89.66 RT122.2
TBTA_BOT_N_R: length 8.7
  BOTTOM w0.112: RT122.1 14.37,89.52 14.09,89.52 DT20.1 13.65,89.53 12.49,89.53 12.25,89.76 10.47,89.76 10.25,89.98 v4(8.32,89.98) 6.87,89.98 JUSBC1.B7
TBTA_BOT_P: length 42.2
  TOP w0.076: v2(25.08,60.53) 25.59,60.53 25.62,60.56 26.01,60.56 UT5.K7
  IN1 w0.119: v2(13.98,79.17) 13.98,77.45 16.76,74.66 16.76,62.32 18.03,61.06 22.58,61.06 23.98,59.65 24.77,59.65 25.08,59.97 v2(25.08,60.53)
  IN2 w0.124: v2(16.44,88.71) 16.45,88.69 16.45,87.54 15.69,86.78 15.69,85.07 15.84,84.92 15.84,82.82 15.52,82.5 14.93,82.5 14.11,81.67 14.11,79.29 v2(13.98,79.17)
  BOTTOM w0.112: v2(16.44,88.71) 16.55,88.82 16.55,88.93 16.21,89.28 16.02,89.28 15.91,89.38 15.91,89.38 15.89,89.4 15.72,89.4 15.59,89.27 RT123.2
TBTA_BOT_P_R: length 8.7
  BOTTOM w0.112: RT123.1 14.37,89.26 14.09,89.26 DT19.1 13.64,89.26 12.38,89.26 12.14,89.5 v4(10.66,89.5) 10.36,89.5 10.14,89.72 6.87,89.72 JUSBC1.B6
TBTA_CC1: length 51.8
  TOP w0.203: 25.2,59.72 25.38,59.72 25.47,59.81 UT5.L9
  TOP w0.254: 24.82,59.52 25.02,59.72 25.2,59.72
  TOP w0.305: 24.82,59.52 24.77,59.47 23.12,59.47 22.72,59.07 RT104.2 22.67,58.85 CT86.1 21.85,58.98 22.25,59.39 22.25,60.01 22.01,60.25 21.02,60.25 19.94,59.18 17.89,59.18 v2(17.23,59.84) ; v2(13.21,90.15) 13.11,90.15 12.88,90.38 DT7.1 11.73,90.38 11.59,90.24 10.73,90.24 10.38,90.6 JUSBC1.A5
  IN1 w0.305: v2(17.23,59.84) 16.99,59.59 15.99,59.59 15.09,60.5 15.09,68.41 14.1,69.4 14.1,73.73 14.13,73.76 14.13,75.13 11.7,77.56 11.7,80.12 12.24,80.66 v2(12.36,80.66)
  IN2 w0.305: v2(12.36,80.66) 12.36,81.95 12.24,82.06 12.24,84.02 12.74,84.52 12.74,89.69 v2(13.21,90.15)
TBTA_CC2: length 52
  TOP w0.127: UT5.L10 25.61,59.31 25.49,59.19 25.32,59.19 25.27,59.14
  TOP w0.254: 24.64,58.65 24.79,58.65 25.27,59.14
  TOP w0.305: 24.64,58.65 24.35,58.36 23.03,58.36 22.72,58.06 RT105.2 CT85.1 21.31,57.25 19.08,57.25 16.7,59.64 16.7,60.07 v2(16.77,60.14)
  IN1 w0.305: v2(12.59,78.85) 12.59,77.82 16.02,74.38 16.02,62 16.92,61.11 16.92,60.29 v2(16.77,60.14)
  IN2 w0.305: v2(15.23,87.23) 15.03,87.23 14.68,86.88 14.68,83.63 13.36,82.31 13.36,80.07 12.92,79.64 12.92,79.18 v2(12.59,78.85)
  BOTTOM w0.102: 7.08,89.06 7.01,88.99 6.23,88.99 6.17,89.05 JUSBC1.B5
  BOTTOM w0.305: v2(15.23,87.23) 15.12,87.33 DT16.1 14.16,87.33 13.59,87.9 12.69,87.9 v3(12.28,88.31) 11.71,88.88 10.13,88.88 9.95,89.06 7.08,89.06
TBTA_DBG_CTL1: length 5.2
  TOP w0.076: UT5.E4 28.76,62.71 v2(28.84,62.79)
  BOTTOM w0.102: v2(28.84,62.79) 30.6,64.55 v1(30.6,65.39) 30.6,65.45 29.73,66.31 RT106.1
TBTA_DBG_CTL2: length 4.1
  TOP w0.076: v2(29.73,62.24) 29.69,62.24 UT5.D5
  BOTTOM w0.102: v2(29.73,62.24) 29.76,62.26 v1(30.27,62.26) RT107.1
TBTA_DEBUG1: length 3.5
  TOP w0.076: 24.67,63.84 25.2,63.31 UT5.L2
  TOP w0.102: RT92.2 23.6,64.94 23.6,64.91 24.67,63.84
TBTA_DEBUG2: length 4.7
  TOP w0.076: UT5.K2 26.01,63.56 25.29,63.56 24.67,64.18
  TOP w0.112: RT93.2 24.01,65.42 24.01,64.84 24.47,64.37 24.47,64.37 24.67,64.18
TBTA_DEBUG3: length 6.3
  TOP w0.076: 24.67,63.2 25.06,62.81 UT5.L3
  TOP w0.112: 24.67,63.2 24.42,63.45 24.08,63.45 23.62,63.91 v2(23.23,63.91)
  BOTTOM w0.102: v2(23.23,63.91) 22.93,63.91 RT89.2 22.33,64.1 22.25,64.18 v3(22.25,65.42)
TBTA_DEBUG4: length 5.1
  TOP w0.076: UT5.K3 26.01,63.06 25.15,63.06 24.67,63.54
  TOP w0.112: v2(23.38,64.48) 23.74,64.48 24.67,63.55 24.67,63.54
  BOTTOM w0.102: v2(23.38,64.48) 23.7,64.16 23.7,63.77 RT90.2
TBTA_HPD: length 44.2
  TOP w0.102: UT1.M4 v2(28.61,82.91)
  IN3 w0.135: v2(25.88,58.36) 26.01,58.49 26.01,62.35 26.5,62.84 26.5,67.62 26.09,68.04 26.09,70.02 26.99,70.93 27.86,70.93 28.55,71.62 30.89,71.62 31.12,71.85 32.59,71.85 33.45,70.99 34.93,70.99 35.53,71.59 35.53,75.51 35.29,75.75 35.29,77.39 35.59,77.69 35.59,78.4 32.21,81.78 29.24,81.78 28.61,82.41 v2(28.61,82.91)
  BOTTOM w0.112: v2(28.61,82.91) 28.61,81.79 RT23.1 ; v2(25.88,58.36) 26.3,57.95 26.71,57.95 26.98,58.22 26.98,58.5 27.5,59.02 RT73.1
TBTA_HPD_R: length 2.2
  TOP w0.102: UT5.C10 v2(29.76,59.78)
  BOTTOM w0.102: v3(30.37,59.33) 29.91,59.78 v2(29.76,59.78)
  BOTTOM w0.112: RT73.2 29.35,59.38 v2(29.76,59.78)
TBTA_I2C_INT: length 37.2
  TOP w0.076: UT5.C1 29.76,64.14 30.38,64.76 30.38,64.84
  TOP w0.102: UT1.J4 v2(27.31,82.91)
  TOP w0.112: v2(30.83,67.03) 30.63,66.83 30.63,65.35 30.38,65.09 30.38,64.84
  IN1 w0.102: v2(27.31,82.91) 26.72,82.32 26.72,82.09 25.35,80.71 25.35,78.28 24.18,77.11 24.18,75.76 22.05,73.63 22.05,69.46 21.39,68.8 v2(21.16,68.8)
  IN2 w0.102: v2(30.83,67.03) 30.01,67.85 22.82,67.85 21.87,68.8 v2(21.16,68.8)
  BOTTOM w0.112: v2(27.31,82.91) v1(26.75,82.35) 26.62,82.22 26.62,78.57 27.28,77.91 RT16.1
TBTA_LSRX: length 38.9
  TOP w0.102: UT1.A4 23.66,82.8 22.6,83.86 21.93,83.86 v2(21.76,83.69)
  TOP w0.112: v2(19.84,60.45) 19.74,60.55 19.74,61.24 19.28,61.69 19.28,62.33 19.88,62.92 21.31,62.92 21.58,62.65 21.83,62.65 RT88.1 ; v2(21.76,83.69) 21.36,83.69 RT21.1
  IN3 w0.135: v2(21.76,83.69) 21.56,83.88 21.26,83.88 20.29,82.92 20.29,78.47 19.58,77.76 19.58,76.78 18.96,76.15 18.96,68.56 19.12,68.4 19.12,65.82 19.36,65.57 19.36,61.59 19.69,61.27 19.69,60.6 v2(19.84,60.45)
  BOTTOM w0.112: v2(19.84,60.45) 19.69,60.6 19.69,60.72 19.81,60.84 v4(21.24,60.84) 22,60.84 22.9,61.74 22.9,62.06 RT90.1
TBTA_LSRX_R: length 3.7
  TOP w0.076: 25.4,62.32 25.51,62.22 25.51,62.21 25.66,62.06 26,62.06 26.25,62.31 UT5.K4
  TOP w0.112: 25.4,62.32 25.36,62.37 23.8,62.37 23.5,62.67 23.35,62.67 RT88.2
TBTA_LSTX: length 39.7
  TOP w0.102: v2(21.76,84.32) 21.96,84.12 22.7,84.12 23.56,83.26 UT1.A5
  TOP w0.112: v2(19.27,60.45) 19.47,60.65 19.47,61.13 19.02,61.58 19.02,62.44 19.77,63.19 21.42,63.19 21.69,62.92 21.79,62.92 RT87.1 ; v2(21.76,84.32) 21.75,84.33 21.13,84.33 RT22.1
  IN3 w0.135: v2(21.76,84.32) 21.6,84.17 21.14,84.17 20,83.03 20,78.58 19.3,77.88 19.3,76.89 18.67,76.27 18.67,68.44 18.83,68.28 18.83,65.7 19.08,65.45 19.08,61.48 19.41,61.15 19.41,60.59 v2(19.27,60.45)
  BOTTOM w0.112: RT89.1 22.64,62.09 22.64,61.85 21.89,61.1 19.7,61.1 19.43,60.83 19.43,60.61 v2(19.27,60.45)
TBTA_LSTX_R: length 3.1
  TOP w0.076: UT5.L4 25.49,62.58 24.67,62.58
  TOP w0.112: 24.67,62.58 23.96,62.58 23.61,62.93 23.36,62.93 RT87.2
TBTA_MRESET: length 2.2
  TOP w0.076: UT5.E11 28.76,57.65
  TOP w0.112: 28.76,57.65 28.76,57.28 28.64,57.16 RT86.1
TBTA_RESET_N_EC_R: length 2.4
  TOP w0.076: 28.03,57.69 28.26,57.92 UT5.F11
  TOP w0.112: 28.03,57.69 27.72,57.38 27.72,56.73 RT110.1
TBTA_ROM_CLK_PD: length 23.5
  TOP w0.102: v2(26.59,51.66) 26.8,51.45 RT54.2 ; UT5.A3 31.94,62.81
  TOP w0.112: 31.94,62.81 32.89,62.81 33.19,63.11 33.19,63.65 v2(33.9,64.36)
  IN3 w0.102: v2(26.59,51.66) 26.27,51.98 26.27,54.89 27.8,56.42 27.8,57.47 28.7,58.37 29.39,58.37 30.37,59.35 30.37,64.12 31.05,64.8 33.47,64.8 v2(33.9,64.36)
TBTA_ROM_CLK_PD_R: length 12.7
  TOP w0.102: RT54.1 v2(30.7,51.45)
  BOTTOM w0.102: JDB1.2 25.65,45.47 26.87,46.69 v3(26.87,46.91) 26.87,48.52 27.28,48.92 27.28,50.35 28.39,51.47 UT6.6 30.69,51.47 v2(30.7,51.45)
TBTA_ROM_CS#_PD: length 28.2
  TOP w0.076: 31.85,63.06 30.51,63.06 UT5.B3
  TOP w0.112: v2(26.59,48.84) 26.28,48.84 RT57.2 ; 31.85,63.06 32.61,63.06 32.76,63.21 32.76,63.85 v2(33.9,65)
  IN3 w0.102: v2(26.59,48.84) 25.73,49.7 25.73,51.71 25.09,52.35 25.09,54 27.6,56.51 27.6,57.59 28.6,58.6 29.3,58.6 30.14,59.45 30.14,64.18 30.96,65 v2(33.9,65)
TBTA_ROM_CS#_PD_R: length 8.8
  TOP w0.102: v2(24.36,48.53) 24.36,48.53 v3(23.97,48.93)
  TOP w0.112: RT51.1 RT57.1 v2(24.36,48.53)
  BOTTOM w0.102: JDB1.5 24.15,45.39 24.45,45.69 24.45,48.44 v2(24.36,48.53)
  BOTTOM w0.112: UT6.1 23.96,48.93 v2(24.36,48.53)
TBTA_ROM_DI_PD: length 22
  TOP w0.076: 31.85,62.57 31.46,62.57 31.45,62.56 30.51,62.56 UT5.B4
  TOP w0.112: v2(33.91,63.72) 33.4,63.21 33.4,63.02 32.95,62.57 31.85,62.57 ; RT55.2 v2(26.68,52.86)
  IN3 w0.102: v2(33.91,63.72) 33,63.72 32.22,64.5 31.04,64.5 30.59,64.05 30.59,59.26 29.48,58.15 29.29,58.15 28.58,57.44 28.58,56.91 26.47,54.8 26.47,53.08 v2(26.68,52.86)
TBTA_ROM_DI_PD_R: length 13.4
  TOP w0.112: v2(30.18,52.34) RT55.1
  BOTTOM w0.102: v2(30.18,52.34) 29.78,52.74 UT6.5 28.11,52.74 27.12,51.75 27.12,50.84 25.88,49.61 25.88,46.74 v3(25.34,46.19) 25.15,46 JDB1.3
TBTA_ROM_DO_PD: length 22.8
  TOP w0.102: UT5.A4 33.13,62.31 v2(33.91,63.09)
  TOP w0.112: v2(26.6,51.03) 26.32,51.03 RT56.2
  IN3 w0.102: v2(26.6,51.03) 27.25,51.68 27.25,55.29 28.78,56.83 28.78,57.35 29.31,57.88 29.5,57.88 30.86,59.24 30.86,64.04 31.13,64.3 32.13,64.3 33.35,63.09 v2(33.91,63.09)
TBTA_ROM_DO_PD_R: length 10.4
  TOP w0.112: RT56.1 RT52.1 v2(24.36,50.43)
  BOTTOM w0.102: 22.48,50.2 24.13,50.2 v2(24.36,50.43) 25.02,49.77 v3(25.02,47.5) 25.02,46.45 24.65,46.08 JDB1.4
  BOTTOM w0.112: UT6.2 22.48,50.2
TBTA_ROM_HOLD#_PD: length 5.1
  TOP w0.102: v2(30.41,50.39) 30.29,50.27 30.29,49.57 30,49.28 v3(29.81,49.28) 29.27,49.28 RT50.1
  BOTTOM w0.102: UT6.7 30.22,50.2 v2(30.41,50.39)
TBTA_ROM_WP#_PD: length 5.1
  TOP w0.112: RT53.1 v2(24.36,52.34)
  BOTTOM w0.102: UT6.3 v3(20.28,51.47)
  BOTTOM w0.112: v2(24.36,52.34) 23.35,52.34 22.48,51.47 UT6.3
TBTA_ROSC: length 5.4
  TOP w0.076: 27.6,64.84 27.6,64.57 27.51,64.48 27.51,63.56 UT5.G2
  TOP w0.112: v2(27.17,65.51) 27.6,65.08 27.6,64.84
  BOTTOM w0.102: v2(27.17,65.51) 28.2,64.48 v3(28.2,63.95)
  BOTTOM w0.112: v2(27.17,65.51) 26.93,65.75 RT100.1
TBTA_RX1N: length 20.5
  TOP w0.076: v2(22.7,90.34) 22.78,90.42 arc(22.92,90.52) 23.09,90.55 23.45,90.55 arc(23.51,90.54) 23.56,90.5 23.63,90.44 arc(23.68,90.4) 23.75,90.39 24,90.39 24.06,90.45 24.06,90.57 24.02,90.62 23.87,90.62 UT1.A21
  BOTTOM w0.175: JUSBC1.B10 5.91,91.56 arc(6.11,91.7) 6.35,91.74 7.11,91.74 arc(7.36,91.79) 7.58,91.93 arc(7.77,92.06) 8,92.11 11.18,92.11 arc(11.47,92.05) DT14.1 11.76,91.95 arc(11.97,92.08) 12.21,92.13 12.21,92.13 arc(13.1,91.99) 13.91,91.59 arc(14.66,91.39) 15.36,91.73 arc(16.32,92.08) 17.17,91.51 arc(17.88,90.61) 18.83,89.97 arc(19.76,89.82) 20.63,90.18 arc(21.12,90.44) 21.67,90.49 arc(21.87,90.48) 22.08,90.47 arc(22.2,90.46) 22.31,90.45 v2(22.7,90.34)
TBTA_RX1P: length 20.4
  TOP w0.076: v2(22.7,90.93) 22.78,90.84 arc(22.92,90.75) 23.09,90.72 23.5,90.72 arc(23.54,90.72) 23.58,90.74 arc(23.6,90.75) 23.62,90.77 23.63,90.78 arc(23.7,90.83) 23.79,90.84 24.03,90.84 arc(24.1,90.83) 24.17,90.78 UT1.B21
  BOTTOM w0.175: JUSBC1.B11 5.83,92.22 arc(6.07,92.06) 6.35,92.01 7.11,92.01 arc(7.26,92.04) 7.39,92.12 arc(7.67,92.31) 8,92.37 11.17,92.37 arc(11.45,92.43) 11.69,92.59 DT13.1 arc(11.94,92.45) 12.21,92.4 arc(13.18,92.25) 14.06,91.81 arc(14.63,91.66) 15.17,91.92 arc(16.35,92.34) 17.4,91.64 arc(18.06,90.8) 18.95,90.21 arc(19.73,90.08) 20.46,90.39 arc(21.04,90.7) 21.7,90.76 arc(21.97,90.74) 22.23,90.73 arc(22.3,90.74) 22.36,90.75 v2(22.7,90.93)
TBTA_RX2N: length 19.3
  TOP w0.076: UT1.B15 24.11,88.08 23.78,88.08 arc(23.7,88.07) 23.64,88.03 23.54,87.93 23.1,87.93 23.1,87.94
  TOP w0.175: JUSBC1.A10 8.25,88.1 arc(8.38,88.01) 8.53,87.98 8.59,87.98 9.18,87.87 arc(9.5,87.65) 9.56,87.27 arc(9.55,87.14) 9.6,87.02 arc(9.98,86.64) 10.51,86.5 10.97,86.5 11.15,86.5 arc(11.42,86.55) DT9.1 11.67,86.67 arc(11.75,86.61) 11.84,86.56 arc(11.99,86.5) 12.16,86.47 12.68,86.44 12.68,86.44 arc(13.2,86.22) 13.56,85.8 arc(14.45,85.15) 15.5,85.5 16.04,86.05 arc(16.64,86.63) 17.26,87.17 arc(18.38,87.73) 19.63,87.73 20.86,87.44 arc(21.08,87.46) 21.25,87.61 arc(21.47,87.85) 21.79,87.94 23.1,87.94
TBTA_RX2P: length 19.3
  TOP w0.076: 23.1,87.67 23.17,87.67 23.24,87.75 23.5,87.75 arc(23.56,87.74) 23.6,87.71 23.63,87.68 arc(23.69,87.64) 23.76,87.63 23.98,87.63 24.05,87.7 24.05,87.78 23.97,87.86 UT1.A15
  TOP w0.175: 23.1,87.67 21.79,87.67 arc(21.61,87.62) 21.48,87.49 arc(21.19,87.22) 20.79,87.18 19.57,87.47 arc(18.44,87.47) 17.43,86.97 arc(16.81,86.43) 16.23,85.86 16.23,85.86 15.69,85.31 arc(14.41,84.89) 13.33,85.68 arc(13.04,86.01) 12.64,86.18 12.63,86.18 12.18,86.21 12.15,86.21 arc(11.89,86.16) 11.66,86.01 DT10.1 11.46,86.18 arc(11.4,86.22) 11.33,86.23 10.97,86.23 10.51,86.23 arc(9.85,86.41) 9.37,86.88 arc(9.29,87.1) 9.3,87.34 arc(9.27,87.51) 9.13,87.61 8.55,87.71 8.53,87.72 arc(8.37,87.69) 8.24,87.6 JUSBC1.A11
TBTA_SBU1: length 46.9
  TOP w0.102: RT108.2 22.18,60.61 20.95,60.61 20.07,59.74 18.49,59.74 17.68,60.55 16.49,60.55 v2(16.21,60.27)
  TOP w0.112: JUSBC1.A8 8.52,89.1 8.58,89.04 9.8,89.04 10,88.83 11.54,88.83 12.4,87.98 13.62,87.98 14.26,87.33 DT8.1 14.78,87.33 v2(15.25,87.8)
  IN1 w0.102: v2(16.21,60.27) 16.21,60.31 16.56,60.67 16.56,61.03 15.72,61.87 15.72,74.26 12.21,77.77 12.21,79.37 v2(12.38,79.55)
  IN2 w0.124: v2(12.38,79.55) 13.04,80.2 13.04,82.44 13.95,83.35 13.95,86.84 14.91,87.8 v2(15.25,87.8)
TBTA_SBU1_R: length 2.9
  TOP w0.076: 24.67,59.82 24.73,59.82 24.89,59.99 25.31,59.99 25.38,60.06 26.01,60.06 UT5.K8
  TOP w0.112: RT108.1 23.88,59.82 24.67,59.82
TBTA_SBU2: length 48
  TOP w0.102: RT109.2 20.97,60.92 19.99,59.94 18.58,59.94 17.54,60.98 16.33,60.98 v2(16.18,60.83)
  IN1 w0.102: v2(12.38,80.11) 12,79.73 12,77.69 15.52,74.17 15.52,61.49 v2(16.18,60.83)
  IN2 w0.124: v2(13.21,90.74) 13.28,90.74 13.65,90.37 13.65,89.66 13.06,89.07 13.06,84.39 12.56,83.89 12.56,82.43 12.78,82.21 12.78,80.5 v2(12.38,80.11)
  BOTTOM w0.112: JUSBC1.B8 5.87,90.72 7.07,90.72 7.19,90.61 10.36,90.61 10.72,90.25 v3(11.72,90.25) 12.47,90.25 DT15.1 12.85,90.38 v2(13.21,90.74)
TBTA_SBU2_R: length 2.5
  TOP w0.076: 24.78,60.15 24.8,60.17 25.24,60.17 25.38,60.31 UT5.L8
  TOP w0.112: RT109.1 24.11,60.48 24.11,60.36 24.31,60.15 24.78,60.15
TBTA_TOP_N: length 40.9
  TOP w0.076: v2(23.99,61.73) 24.47,61.25 25.7,61.25 UT5.L6
  TOP w0.112: v2(17.05,89.91) 16.93,89.79 16.93,89.58 16.6,89.24 15.89,89.24 RT121.1
  IN1 w0.119: v2(23.99,61.73) 23.99,61.73 23.81,61.73 23.68,61.86 23.68,62.5 22.84,63.34 19.99,63.34 19.02,64.31 19.02,68.92 17.9,70.03 17.9,75.45 15.25,78.1 15.25,79.84 15.36,79.95 15.36,80.36 15.47,80.47 15.72,80.47 15.84,80.35 15.84,80.17 v2(15.76,80.08)
  IN2 w0.124: v2(15.76,80.08) 15.66,79.98 15.48,79.98 15.36,80.11 15.36,80.3 15.62,80.57 16.01,80.57 17.21,81.77 17.21,86.54 17.79,87.13 17.79,89.37 17.36,89.8 17.1,89.8 17.05,89.85 v2(17.05,89.91)
TBTA_TOP_N_R: length 7.4
  TOP w0.112: RT121.2 14.37,89.26 14.09,89.26 DT12.1 13.65,89.25 12.36,89.25 12.28,89.33 10.2,89.33 9.79,89.74 8.62,89.74 8.6,89.72 8.48,89.6 JUSBC1.A7
TBTA_TOP_P: length 41
  TOP w0.076: v2(23.29,61.72) 23.48,61.72 23.84,61.36 24.09,61.36 24.37,61.08 25.47,61.08 25.49,61.06 25.89,61.06 26.14,61.31 UT5.K6
  TOP w0.112: v2(16.27,89.95) 16.26,89.95 16.26,89.93 16.32,90 16.5,90 16.63,89.88 16.63,89.65 16.49,89.51 15.72,89.51 15.59,89.63 RT120.1
  IN1 w0.119: v2(14.95,80.08) 15,80.03 15,78 17.65,75.34 17.65,69.93 18.76,68.81 18.76,64.21 19.89,63.09 22.73,63.09 23.43,62.39 23.43,61.86 v2(23.29,61.72)
  IN2 w0.124: v2(14.95,80.08) 15.06,80.2 15.06,80.45 15.48,80.87 15.89,80.87 16.91,81.89 16.91,86.67 17.49,87.25 17.49,89.25 17.23,89.5 16.7,89.5 16.27,89.94 v2(16.27,89.95)
TBTA_TOP_P_R: length 7.4
  TOP w0.112: JUSBC1.A6 8.48,90.1 8.6,89.98 8.61,89.98 8.64,90.01 9.9,90.01 10.31,89.59 12.39,89.59 12.47,89.52 13.64,89.52 DT11.1 14.09,89.52 14.37,89.52 RT120.2
TBTA_TX1N: length 2.9
  TOP w0.076: 22.46,89.58 22.48,89.58 22.53,89.63 23.46,89.63 arc(23.54,89.61) 23.6,89.57 23.64,89.53 arc(23.7,89.49) 23.77,89.48 24.04,89.48 arc(24.1,89.49) 24.16,89.52 24.33,89.7 UT1.B19
  TOP w0.175: 22.46,89.58 21.95,89.58 arc(21.76,89.54) CT96.1
