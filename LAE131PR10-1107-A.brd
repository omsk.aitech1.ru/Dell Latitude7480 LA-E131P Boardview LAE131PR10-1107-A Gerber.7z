# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 68.9
  TOP w0.102: v3(306.12,22.65) 305.57,22.09 v2(304.97,22.09)
  TOP w0.203: v2(304.14,29.29) 304.14,29.73 303.65,30.22 UA1.25 ; UA1.38 302.11,35.85 302.62,36.37 303.02,36.37 CA57.2
  TOP w0.381: CA57.2 303.84,36.47 v2(303.84,36.47) ; v2(307.88,27.22) 307.88,27.29 307.39,27.78 CA8.2
  TOP w0.508: JHP1.7 v2(316.35,25.17) ; CA2.2 v2(304.73,13.54) ; CA9.2 305.89,26.04 v2(305.7,25.85) ; CA52.2 303.78,39.28 v2(304.36,38.69) ; CA25.2 300.69,25.88 300.69,25.25 300.62,25.19 v2(299.81,25.19) 299.36,24.73 RA37.1 ; CA41.2 v2(296.42,27.04) ; CA1.1 v2(304.97,22.09) ; CA58.2 v2(305.14,38.64) ; CA4.2 v2(303.91,17.95) 303.59,17.63 302.9,17.63 302.14,16.86 302.14,15.89 RA36.1 ; CA3.2 v2(304.92,17.06)
  GND1 w0.203: 312.65,14.3 JHP1.5 ; JHP1.5 314.75,14.3 ; JHP1.5 314.75,13.65 ; JHP1.5 313.7,13.65 ; JHP1.5 312.65,13.65 ; JHP1.7 317.4,24.45 ; JHP1.7 316.35,24.45 ; JHP1.7 315.3,24.45 ; JHP1.7 315.3,23.8 ; JHP1.7 317.4,23.8
  IN1 w0.508: JHP1.5 313.26,13.86 v2(309.44,13.86) 309.44,13.11 311.54,11.01 v2(312.27,11.01)
  VCC w0.203: 313.7,13.65 JHP1.5 ; JHP1.5 312.65,13.65 ; JHP1.5 314.75,13.65 ; JHP1.7 316.35,24.45 ; JHP1.7 315.3,24.45 ; JHP1.7 317.4,24.45
  IN2 w0.508: v2(303.84,36.47) 303.84,36.47 303.84,38.17 v2(304.36,38.69)
  IN3 w0.508: v2(296.42,27.04) 296.42,26.55 297.78,25.19 v2(299.81,25.19)
  GND2 w0.203: 312.65,14.3 JHP1.5 ; JHP1.5 312.65,13.65 ; JHP1.5 313.7,13.65 ; JHP1.5 314.75,13.65 ; JHP1.5 314.75,14.3 ; JHP1.7 317.4,23.8 ; JHP1.7 315.3,24.45 ; JHP1.7 315.3,23.8 ; JHP1.7 316.35,24.45 ; JHP1.7 317.4,24.45
  BOTTOM w0.508: DA2.2 312.9,10.2 312.27,10.83 v2(312.27,11.01) ; v2(304.14,29.29) 303.16,30.27 RA35.1
  vias: v1(308.55,27.02) v1(309.34,29.32) v2(308.15,31.01) v2(308.15,27.89)
VBAT1_ISL88738: length 3
  BOTTOM w0.203: PU901.31 62.57,94.72 62.79,94.94 62.79,95.8 PC950.2 62.99,96 PR940.2
VBUS1_ECOK: length 308.8
  TOP w0.254: PR1222.1 40.47,95.92 PR1220.1 ; v2(271.46,58.49) 271.75,58.21 UE2.13 ; v2(33.68,103.24) 33.68,101.69 34.93,100.45 34.93,98.76 35.37,98.32 36.89,98.32 37.15,98.06 39.12,98.06 39.22,98.16 39.77,98.16 40.11,97.82 40.11,97.53 40.47,97.17 PR1220.1 ; PR1220.1 40.97,97 41.12,97.15 43.66,97.15 PR1257.1
  IN2 w0.254: v2(271.46,58.49) 271.46,58.28 271.16,57.97 270.37,57.97 270.29,58.05 267.4,58.05 265.43,60.02 252.72,60.02 243.53,50.84 241.83,50.84 241.47,50.48 210.31,50.48 191.26,69.53 190.68,69.53 189.29,70.92 189.29,72.98 186.85,75.42 186.33,75.42 177.32,84.43 177.32,86.62 178.72,88.01 178.72,90.81 176.82,92.7 176.82,94.84 175.77,95.89 175.77,97.84 171.64,101.98 171.64,102.69 164.88,109.44 160.66,109.44 153.24,116.86 90.84,116.86 88.21,114.23 81.57,114.23 78.92,116.88 62.51,116.88 62.09,116.46 62.09,116.05 58.6,112.56 58.6,111.07 57.91,110.38 40.52,110.38 39.17,109.04 36.32,109.04 34.9,107.61 34.9,106.47 33.68,105.25 v2(33.68,103.24)
VBUS2_ECOK: length 350.8
  TOP w0.254: v2(26.9,97.28) 28.32,97.28 28.93,97.89 31.26,97.89 31.31,97.83 34.19,97.83 34.8,97.22 34.8,96.23 35.56,95.47 v2(35.88,95.47) 35.92,95.43 36.76,95.43 36.76,95.44 38.79,95.44 39.2,95.03 PR1242.1 ; UE2.16 273.33,55.96 273.08,55.71 271.38,55.71 270.22,56.86 v1(270.22,58.13) 270.22,58.18 270.51,58.47 v2(270.89,58.47) ; v2(46.5,82.57) 45.19,82.57 44.57,81.95 43.53,81.95 42.61,82.87 42.61,85.69 43.5,86.58 v2(44.1,86.58)
  IN2 w0.254: v2(26.9,97.28) 26.9,99.59 28.16,100.84 28.16,101.28 31.45,104.57 32.08,104.57 34.32,106.8 34.32,108.55 35.59,109.82 39.3,109.82 40.98,111.51 53.26,111.51 56.59,114.85 56.59,116.14 57.69,117.24 79.06,117.24 81.72,114.59 88.06,114.59 90.69,117.21 153.39,117.21 160.34,110.27 164.56,110.27 171.99,102.84 171.99,102.12 176.41,97.71 176.41,95.76 177.18,94.99 177.18,92.85 179.07,90.96 179.07,87.87 177.68,86.47 177.68,84.58 186.43,75.82 187.01,75.82 189.66,73.18 189.66,71.06 190.68,70.04 191.26,70.04 210.46,50.83 240.46,50.83 241.38,51.75 243.76,51.75 252.62,60.6 265.56,60.6 267.75,58.41 270.83,58.41 v2(270.89,58.47)
  BOTTOM w0.254: v2(44.1,86.58) 43.72,86.96 41.34,86.96 40.08,85.71 38.77,85.71 37.57,86.91 36.82,86.91 36.3,87.43 36.3,88.06 36.01,88.35 36.01,90.57 34.35,92.24 34.35,94.45 35.37,95.47 v2(35.88,95.47) ; PR20.2 47.14,82.36 PR24.1 46.74,82.34 v2(46.5,82.57)
VCC_EDRAM_SENSE: length 73.8
  TOP w0.254: PR1311.2 53.35,63.04 62.89,63.04 67.42,58.5 96.59,58.5 103.18,65.1 103.67,65.1 104.93,66.35 104.93,68.83 v1(105.35,69.25) 105.62,69.51 105.62,73.64 107.67,75.7 108.11,75.7 108.64,75.17 109.37,75.17 109.63,75.42 109.63,75.85 109,76.47 108.54,76.47 v2(108.49,76.53)
  BOTTOM w0.254: UC1.AC63 109.64,76.54 108.5,76.54 v2(108.49,76.53)
VCC_GT_SENSE: length 78.5
  TOP w0.254: PC618.2 49.7,65.12 PR622.1 49.9,64.7 v2(49.85,64.65)
  IN3 w0.254: v2(100.73,82.88) 100.69,82.93 93.05,82.93 88.84,87.13 88.84,88.37 86.54,90.67 85.58,90.67 85.05,90.14 75.62,90.14 73.24,87.76 72.89,87.76 70.59,85.46 70.59,84.05 70.93,83.7 70.93,81.84 70.93,80.68 70,79.75 66.86,76.61 66.56,76.61 65.6,75.66 64.84,75.66 64.53,75.36 64.53,75.24 61.87,72.57 61.09,72.57 60.11,71.59 60.11,71.25 55.49,66.64 51.84,66.64 v2(49.85,64.65)
  BOTTOM w0.076: 104.29,83.3 105.02,83.3 105.32,83.42 105.54,83.63 UC1.J70
  BOTTOM w0.127: 103.67,83.19 104.18,83.19 104.29,83.3
  BOTTOM w0.254: v2(49.85,64.65) 49.85,65.26 PC617.1 49.05,65.3 PC620.1 ; RC161.1 100.12,82.88 v2(100.73,82.88) 101.77,82.88 102.09,83.19 103.67,83.19
VCCEOPIO_SENSE: length 72.8
  TOP w0.254: PR1323.2 50.63,52.08 51.86,52.08 56.06,56.28 59.36,56.28 60.17,55.47 68.07,55.47 69.73,57.12 96.4,57.12 103.66,64.38 104.25,64.38 105.77,65.91 105.77,68.14 107.06,69.44 107.06,72.1 107.37,72.41 109.17,72.41 109.45,72.13 v2(109.45,71.97)
  BOTTOM w0.254: v2(109.45,71.97) 109.61,71.97 UC1.AL63
VCCIO_SENSE: length 165.3
  TOP w0.254: v2(131.42,71.96) 131.39,71.96 130.85,72.5 RC165.1 ; v2(172.24,96.23) 172.02,96.01 172.02,89.14 175.16,86 177.12,86 180.51,82.6 180.51,72.46 179.63,71.58 179.63,69.74 178.68,68.79 178.68,67.27 180.35,65.6 180.99,65.6 184.69,61.89 184.69,59.96 186.36,58.3 186.36,43.4 186.02,43.06 186.02,42.13 v2(186.06,42.09)
  IN1 w0.254: v2(183.61,114.15) 183.17,113.81 183.11,113.82 182.37,113.24 181.75,112.62 179.32,112.62 177.66,110.96 177.66,101.64 v2(172.24,96.23) ; v2(131.42,71.96) 130.96,71.5 130.96,66.98 131.88,66.06 131.88,64.66 132.47,64.08 133.02,64.08 135.83,61.27 135.83,60.37 136.22,59.98 136.22,58.79 136.68,58.34 136.68,56.35 143.04,49.99 143.04,49.97 145.04,47.98 147.59,47.98 154.94,40.63 185.43,40.63 185.98,41.18 185.98,42.02 v2(186.06,42.09)
  BOTTOM w0.254: v2(183.61,114.15) 183.85,114.39 PR422.2 ; UC1.AM23 131.82,72.35 v2(131.42,71.96)
VCCSA_B+: length 1
  TOP w0.102: v1(74.96,91.34) 75.08,91.22 75.08,90.38
  vias: v2(74.03,90.53) v2(74.61,90.53)
VCCSENSE: length 118.5
  TOP w0.203: PR648.1 57.03,72.89 PC639.1 ; PR648.1 56.67,72.9 v2(56.33,72.57) ; PR648.1 57.01,73.7 PC653.1 56.96,73.78 PC651.2
  IN2 w0.254: v2(126.4,94.55) 126.33,94.62 126.33,95.08 124.05,97.35 116.59,97.35 115.77,96.54 106.94,96.54 106.49,96.98 98.75,96.98 98,97.73 82.83,97.73 82.76,97.66 79.12,97.66 78.76,98.01 70.87,98.01 69.9,97.05 55.44,97.05 50.83,92.43 50.83,89.58 50.17,88.93 50.17,85.02 49.36,84.21 49.36,80.52 50.52,79.36 51.21,79.36 51.8,78.77 53.51,78.77 54.66,77.62 54.66,73.35 55.44,72.57 v2(56.33,72.57)
  BOTTOM w0.076: UC1.E32 126.83,86.37 126.83,86.85 126.85,86.87 126.85,87.17 126.83,87.19 126.83,87.43 126.85,87.45 126.85,87.97 126.76,88.06
  BOTTOM w0.254: v2(126.4,94.55) 126.38,94.52 126.38,92.56 127,91.94 127,91.12 RC140.1 126.76,90.63 126.76,88.06
VCCST_PWRGD: length 239.3
  TOP w0.112: 260.5,59.11 UE4.4 ; 260.5,59.11 260.61,59.23 261.51,59.23 261.69,59.04 v2(261.69,57.97) ; 260.5,59.11 260.5,59.5 259.8,60.2 258.1,60.2 247.66,49.75 v1(247.66,45.43) 247.66,41.87 v2(247.93,41.59) ; RE308.1 271.52,53.57 v2(271.02,54.07)
  IN2 w0.124: v2(246.12,39.67) 242.83,39.67 242.64,39.85 239.12,39.85 238.54,40.43 228.2,40.43 227.56,41.07 222.4,41.07 220.62,42.85 207.52,42.85 207.51,42.85 207.11,42.85 197.4,52.57 196.53,52.57 190.95,58.14 190.44,58.14 180.95,67.64 180.95,68.21 177.35,71.81 176.63,71.81 174.69,73.76 174.18,73.76 172.81,75.13 172.81,77.16 169.22,80.75 169.22,91.2 167.56,92.85 164.47,92.85 160.68,96.65 159.48,96.65 156.49,99.64 156.49,100.83 150.02,107.31 140.98,107.31 140.21,108.07 135.65,108.07 132.99,105.42 132.99,105.04 131.93,103.98 130.9,103.98 128.86,106.02 124.09,106.02 123.81,106.3 122.35,106.3 120.45,104.4 119.76,104.4 118.75,103.4 106.96,103.4 105.31,101.75 v2(102.82,101.75)
  IN3 w0.135: v2(247.93,41.59) 247.93,41.48 v2(246.12,39.67)
  BOTTOM w0.076: 105.25,97.05 CC301.1 105.97,97.04 RC71.1
  BOTTOM w0.112: v2(102.82,101.75) 102.82,100.25 104.45,98.62 104.45,97.2 104.64,97.01 RC123.1 105.07,97.05 105.25,97.05 ; RC71.1 105.81,95.98 105.03,95.98 104.4,95.34 RC78.1 ; v2(261.69,57.97) 264.66,57.97 266.27,56.36 267.68,56.36 267.69,56.36 268.01,56.36 268.01,56.36 268.54,56.36 270.83,54.07 v2(271.02,54.07)
VCCST_PWRGD_CPU: length 8.3
  BOTTOM w0.076: RC78.2 104.4,92.97 v3(105.69,91.68) 105.77,91.6 106.98,91.6 108.96,89.62 108.96,88.27 UC1.B65
VCCST_PWRGD_EC: length 12.3
  TOP w0.102: v3(273.52,52.6) 273.17,52.95 RE308.2 272.35,52.87 v2(272.35,52.29)
  TOP w0.107: v2(270.01,44.37) 269.62,43.99
  BOTTOM w0.102: v2(272.35,52.29) 272.35,52.21 272.07,51.94 272.07,48.01 272.43,47.66 272.43,46.25 271.75,45.57 270.67,45.57 270.44,45.34 270.44,45.07 270.02,44.65 270.02,44.39 v2(270.01,44.37)
VCCSTG_EN: length 109.6
  TOP w0.102: RZ120.1 180.08,49.16 v2(180.49,49.57)
  IN2 w0.102: v2(190.69,56.6) 190.26,57.03 190.02,57.03 186.1,60.94 185.98,60.94 179.34,67.58 178.51,67.58 173.58,72.51 173.52,72.51 171.4,74.63 171.4,76.8 170.47,77.73 169.64,77.73 169.21,78.15 169.21,78.95 167.9,80.27 167.9,81.82 167.22,82.5 167.22,91.42 167.12,91.53 163.92,91.53 161.48,93.96 160.59,93.96 160.21,94.34 160.21,94.95 159.77,95.39 158.97,95.39 155.22,99.14 155.22,100.29 152.35,103.16 150.72,103.16 150.14,103.74 150.14,104.79 149.23,105.7 136.72,105.7 136.07,105.05 v2(136.07,104.93)
  BOTTOM w0.102: UZ35.4 133.91,107.55 134.69,106.77 135.46,106.77 136.4,105.84 v3(136.4,105.64) 136.4,105.26 v2(136.07,104.93) 134.74,103.6 133.97,103.6 RZ320.2 133.24,103.88 UZ19.4 ; v2(180.49,49.57) 180.49,50.37 182.38,52.26 183.29,52.26 187.63,56.6 v2(190.69,56.6)
VDD_ISL88738: length 30.7
  TOP w0.254: PR919.1 58.87,90.63 v2(58.46,91.05) 57.7,91.8 PC933.1
  IN2 w0.254: v2(66.65,89.07) 66.75,89.17 66.75,91.31 64.42,93.64 60,93.64 59.29,92.93 59.29,91.75 58.58,91.05 v2(58.46,91.05)
  IN3 w0.254: v2(61.37,97.68) 61.37,97.54 64.63,94.28 64.63,93.09 67.07,90.66 67.07,89.49 v2(66.65,89.07)
  BOTTOM w0.203: PU901.18 58.49,91.02 v2(58.46,91.05)
  BOTTOM w0.254: v2(61.37,97.68) 61.37,98.47 60.6,99.24 PR918.2 ; v2(66.65,89.07) 66.53,89.19 PR915.2
VDDP_ISL88738: length 2.5
  BOTTOM w0.203: PC932.2 64.93,88.29 PR915.1 64.93,89.24 64.42,89.75 64.42,89.76 63.87,90.3
VIN_1.8VALW: length 1.1
  BOTTOM w0.102: 167.58,104.23 167.58,104.81 v1(167.23,105.16)
VIN_1V_PRIM:
  vias: v2(175.64,113.98) v2(176.27,113.96) v3(176.53,114.46)
VIN_1VS_VCCIO:
  vias: v1(190.44,111.41) v2(188.91,108.24) v2(188.95,107.64)
VIN_VCC_EDRAM:
  vias: v1(46.94,55.04)
VIN_VCC_EOPIO: length 1.8
  TOP w0.102: PC1312.1 v1(46.85,40.61)
VSS_EDRAM_SENSE: length 71.4
  TOP w0.254: v2(109.11,75.64) 108.77,75.64 v1(108.58,75.84) 108.36,76.05 107.52,76.05 105.26,73.79 105.26,70.02 103.54,68.31 103.54,65.96 96.44,58.86 67.57,58.86 63.03,63.39 52.82,63.39 PR1312.2
  BOTTOM w0.254: UC1.AE63 110.09,75.93 109.8,75.64 v2(109.11,75.64)
VSS_GT_SENSE: length 89.4
  TOP w0.203: PU602.6 52.79,68.11 v2(53.01,67.89)
  TOP w0.254: PC619.2 49.05,63.98 v2(49.91,63.98)
  IN2 w0.254: v2(49.91,63.98) 50.27,63.62 51.06,63.62 51.95,64.52 51.95,66.07 52.99,67.11 52.99,67.86 v2(53.01,67.89)
  IN3 w0.254: v2(49.91,63.98) 49.63,63.98 49.38,64.23 49.38,64.9 51.63,67.14 55.28,67.14 59.6,71.46 59.6,71.8 60.88,73.08 61.66,73.08 63.92,75.35 63.92,75.35 64.02,75.45 64.02,75.57 64.62,76.17 65.39,76.17 66.35,77.12 66.65,77.12 69.79,80.26 69.79,80.26 69.83,80.3 70.42,80.89 70.42,81.63 70.42,83.49 70.08,83.84 70.08,85.67 72.67,88.27 73.03,88.27 75.41,90.65 84.84,90.65 85.37,91.17 86.75,91.17 89.35,88.58 89.35,87.35 93.26,83.43 100.61,83.43 v2(100.71,83.53)
  BOTTOM w0.076: UC1.J69 105.99,83.73 105.72,84 105.43,84 105.3,83.95 105.28,83.95 105.21,83.87 105.21,83.61 105.12,83.53 104.99,83.47 104.56,83.47 104.44,83.59
  BOTTOM w0.127: 103.67,83.7 103.69,83.7 103.75,83.64 103.86,83.64 103.9,83.59 104.44,83.59
  BOTTOM w0.254: PC620.2 48.11,65.04 v1(49.13,64.02) 49.18,63.98 v2(49.91,63.98) ; 103.67,83.7 101.88,83.7 101.71,83.53 v2(100.71,83.53) 100.17,84.08 RC163.1
VSSEOPIO_SENSE: length 75.6
  TOP w0.254: PR1324.2 50.31,52.27 50.48,52.44 51.71,52.44 55.91,56.63 59.51,56.63 60.32,55.82 67.93,55.82 69.58,57.47 96.25,57.47 103.51,64.74 103.82,64.74 105.34,66.25 105.34,68.24 106.02,68.93 106.02,71.95 v1(106.64,72.57) 107.39,73.32 110.89,73.32 v2(111.07,73.51)
  BOTTOM w0.254: UC1.AJ62 110.8,73.78 v2(111.07,73.51)
VSSIO_SENSE: length 164.2
  TOP w0.254: RC167.1 132.6,72.23 v2(132.34,71.96) ; v2(185.47,42.09) 185.51,42.13 185.51,43.27 185.85,43.61 185.85,58.09 184.19,59.75 184.19,61.68 180.78,65.09 180.14,65.09 178.18,67.06 178.18,69 179.13,69.96 179.13,71.79 179.27,71.94 179.27,71.94 180,72.67 180,82.39 176.91,85.49 174.95,85.49 171.52,88.93 171.52,96.35 v2(171.76,96.59)
  IN1 w0.254: v2(185.47,42.09) 185.47,41.39 185.22,41.13 155.2,41.13 154.93,41.4 154.89,41.4 147.8,48.49 145.25,48.49 143.55,50.18 143.55,50.2 137.19,56.57 137.19,58.55 136.73,59 136.73,60.19 136.34,60.58 136.34,61.48 133.23,64.59 132.68,64.59 132.39,64.87 132.39,66.27 131.47,67.19 131.47,68.65 131.88,69.06 131.88,71.5 v2(132.34,71.96) ; v2(171.76,96.59) 177.15,101.98 177.15,111.17 179.11,113.13 181.54,113.13 182.03,113.62 182.79,114.22 182.8,114.28 v2(183.24,114.62)
  BOTTOM w0.254: UC1.AM22 132.73,72.35 v2(132.34,71.96) ; PR412.2 182.98,114.37 v2(183.24,114.62)
VSSSENSE: length 116.6
  TOP w0.203: PU602.18 55.67,72.56 56.35,73.23 v2(56.35,73.31) 56.34,73.32 56.34,74.07 PC653.2 56.96,74.67 PC654.2
  IN2 w0.254: v2(56.35,73.31) 56.12,73.08 55.65,73.08 55.17,73.56 55.17,77.83 53.72,79.28 52.01,79.28 51.42,79.87 50.73,79.87 49.87,80.73 49.87,84 50.68,84.81 50.68,88.72 51.33,89.37 51.33,92.22 55.65,96.54 70.11,96.54 71.08,97.5 78.55,97.5 78.91,97.15 82.97,97.15 83.04,97.22 97.78,97.22 98.54,96.47 106.28,96.47 106.73,96.03 115.99,96.03 116.8,96.84 123.84,96.84 125.82,94.87 v2(125.82,94.55)
  BOTTOM w0.076: UC1.E33 126.39,86.69 126.27,86.82 126.27,87.11 126.33,87.17 126.33,87.46 126.26,87.52 126.26,87.83 126.34,87.91 126.34,88.02 126.41,88.08
  BOTTOM w0.254: v2(125.82,94.55) 125.87,94.5 125.87,92.35 v3(126.25,91.97) 126.5,91.73 126.5,91.21 RC141.1 126.41,90.85 126.41,88.08
32KHZ_OUT: length 4.5
  TOP w0.102: UE1.F3 266.01,37.97 v2(265.98,37.97) ; CE54.1 265.72,35.5 v2(265.72,35.71)
  BOTTOM w0.102: v2(265.98,37.97) 266.02,37.93 266.02,37.4 265.72,37.1 v2(265.72,35.71)
+AC_IN: length 6.9
  TOP w0.508: PQ1215.3 38.61,101.37 37.21,102.77 37.21,104.42 37.57,104.78 39.88,104.78
+BL_PWR_SRC: length 22.3
  TOP w0.102: v1(81.42,114.27) v2(82.2,113.49) ; v2(82.2,113.49) 82.56,113.12 v1(82.56,112.25) ; v2(82.2,113.49) 82.63,113.93 v1(83.31,113.93)
  IN3 w0.102: v2(65.22,116.41) 65.22,116.05 65.98,115.28 71.41,115.28 72.92,113.77 78.32,113.77 78.44,113.89 79.48,113.89 79.87,113.49 v2(82.2,113.49)
  vias: v2(63.12,109.02) v2(63.69,109) v2(64.27,109.01) v2(64.83,108.99)
+CHARGER_SRC:
  vias: v1(47.72,81.2) v2(50.9,82.91) v2(50.92,82.32) v2(50.92,81.74) v2(50.92,81.15) v2(51.46,82.93) v2(51.53,82.35) v2(51.53,81.18) v2(51.56,81.76) v2(54.23,80.1) v2(54.68,79.66)
+COINCELL: length 12.5
  TOP w0.127: v1(311.95,11.74) 311.49,11.28 PR2.1
  TOP w0.508: PC2.2 PR2.1 v2(309.93,11.28)
  IN3 w0.508: v2(306.32,15.39) 306.32,14.9 v2(309.93,11.28)
  BOTTOM w0.508: JRTC1.1 305.85,15.86 v2(306.32,15.39)
+DC_IN: length 64.1
  TOP w0.508: PR1201.1 38.78,66.65 39.19,66.24 39.42,66.24 39.88,65.78 v2(40.01,65.78)
  IN2 w0.508: v2(48.14,106.51) 46.02,106.51 44.78,105.27 42.74,105.27 ; v2(40.01,65.78) 40.01,65.78 39.61,65.78 39.2,66.19 39.2,67.17 41.24,69.21 41.24,71.88 42.17,72.81 42.17,83.43 42.09,83.51 42.09,86.12 40.18,88.03 40.18,89.35 39.17,90.37 39.17,90.9 38.33,91.74 38.33,94.61 37.59,95.34 37.59,102.55 39.43,104.38
  BOTTOM w0.102: v1(42.7,62.95) 43.01,63.25 PU2.2
  BOTTOM w0.508: v2(48.14,106.51) 48.14,107.19 48.85,107.9 51.02,107.9 53.07,105.85 53.84,105.85 55.13,104.55 55.14,104.55 55.61,104.08
+DC_IN_SS: length 13
  BOTTOM w0.508: 53.76,96.77 55,98.01 56.04,98.01 56.52,98.49 v1(56.73,98.49) 57.81,98.49 59.4,100.08 59.73,100.08 60.24,100.6 61.92,100.6 62.44,100.07 64.98,100.07 PD904.2
+DCIN_JACK: length 9.2
  BOTTOM w0.102: 47.07,105.2 47.07,105.77 45.88,106.96 45.88,107.95 v1(45.16,108.67) ; v1(43.33,108.58) 43.33,108.16 v1(44.48,107.02) 45.35,107.02 46.46,105.91 46.46,105.43
+DCPRTC: length 7.8
  TOP w0.254: CC214.1 137.38,69.65 137.37,69.64 137.37,68.96 137.38,68.95 137.38,68.46 v1(139,66.83) 140,65.84 v2(140,65.41)
  BOTTOM w0.254: UC1.BB10 139.95,65.45 v2(140,65.41)
+DDR_VREF_A_CA: length 109.1
  TOP w0.127: v3(89.68,22.31) 89.68,23.29 v2(89.24,23.72)
  TOP w0.508: RD17.1 171.24,28.45 ; 171.24,28.45 171.24,29.17 v2(171.33,29.26) ; 171.24,28.45 RD16.1 RD15.2 ; v2(89.24,23.72) 89.27,23.75 CD26.1 CD25.1
  IN1 w0.508: 89.31,24.45 89.84,24.99 109.72,24.99 111.16,26.43 111.16,28.38 113.22,30.44 114.92,30.44 116.01,29.35 116.01,27.36 116.9,26.47 119.37,26.47 120.47,27.58 124.88,27.58 125.26,27.19 147.33,27.19 148.13,27.99 149.6,27.99 150.1,28.5 150.1,30.23 149.62,30.71 149.62,33.81 151.18,35.37 170.62,35.37 171.33,34.66 v2(171.33,29.26)
  BOTTOM w0.305: JDIMM1.164 89.08,23.89 v2(89.24,23.72)
+DDR_VREF_A_DQ: length 6.6
  TOP w0.254: T132.1 104.32,63.37 106.83,65.88 106.83,66.38 v2(106.7,66.52)
  BOTTOM w0.254: UC1.AY68 106.66,66.55 v2(106.7,66.52)
+DDR_VREF_B_CA: length 14.1
  TOP w0.102: RD30.1 166.66,28.58 166.66,29.66 v3(166.25,30.08)
  TOP w0.254: CD58.1 164.14,28.12 CD57.1 163.25,27.55 163.23,27.54 v2(163.19,27.54) ; 167.9,28.12 167.9,28.53 168.02,28.66 v2(168.02,29.11) ; 167.9,28.12 168.26,28.12 168.26,28.13 RD28.2 ; 167.9,28.12 RD29.1 167.1,28.12 RD30.1
  IN2 w0.508: v2(163.19,27.54) 163.62,27.97 166.88,27.97 v2(168.02,29.11)
  BOTTOM w0.305: v2(168.02,29.11) 168.18,28.96 JDIMM2.164
+DDR_VREF_B_DQ: length 220.3
  TOP w0.254: RD30.2 165.06,29.04 CD62.1 165.11,29.04 165.26,28.89 165.37,28.89 165.63,28.63 165.63,27.8 166.07,27.36 166.26,27.36 166.42,27.21 166.42,26.77 v2(166.59,26.59)
  IN1 w0.508: v2(137.34,23.12) 151.35,23.12 154,25.78 158.71,25.78 160.34,27.4 161.82,27.4 162.27,26.95 163.9,26.95 164.52,27.57 166.08,27.57 166.59,27.06 v2(166.59,26.59) ; v2(66.94,57.94) 50.89,41.89 50.37,41.89 47.03,38.55 47.03,38.03 45.28,36.28 45.28,32.6 43.99,31.31 43.99,26.83 45.14,25.68 66.05,25.68 66.49,25.24 66.82,25.24 69.3,22.76 v2(71.32,22.76)
  BOTTOM w0.152: UC1.BA67 107.3,66.46 106.96,66.12 106.97,66.12 106.97,65.8 106.8,65.63 106.68,65.63
  BOTTOM w0.203: 102.16,63.17 102.16,63.39 103.86,65.09 105.85,65.09 106.4,65.63 106.68,65.63
  BOTTOM w0.508: v2(66.94,57.94) 67.2,57.69 98.81,57.69 v3(101.65,60.53) 102.16,61.04 102.16,63.17 ; v2(71.32,22.76) 72.41,21.67 120.7,21.67 123.23,24.2 133.13,24.2 134.21,23.12 v2(137.34,23.12)
+DDR_VREF_CA: length 230.1
  TOP w0.508: v2(172.48,26.69) 172.9,27.11 CD31.1 172.62,27.54 RD17.2
  IN1 w0.508: v2(64.41,58.45) 64.41,56.84 50.47,42.91 49.95,42.91 45.96,38.92 45.96,38.4 44.26,36.7 44.26,35.85 44.26,33.02 42.94,31.69 v2(42.94,29.34)
  IN3 w0.508: v2(42.94,29.34) 42.94,27.25 45.34,24.85 58.36,24.85 59.23,25.72 61.44,25.72 61.6,25.87 67.89,25.87 68.65,25.1 68.65,25.1 69.1,24.66 73.15,24.66 74.94,22.86 120.52,22.86 123.26,25.61 127.63,25.61 129.52,23.72 151.45,23.72 153.1,25.37 158.31,25.37 159.43,26.48 161.28,27.11 162.24,27.11 162.75,26.94 164.14,26.94 164.84,27.64 167.07,27.64 167.28,27.43 171.74,27.43 v2(172.48,26.69)
  BOTTOM w0.203: 102.85,63.51 104.13,64.79 107.18,64.79 107.32,64.93 107.32,65.34 107.65,65.67 107.65,67.05 107.42,67.29 UC1.AY67
  BOTTOM w0.381: 102.85,63.51 v3(102.85,62.48) 102.85,62
  BOTTOM w0.508: 102.85,62 102.85,59.91 99.61,56.67 66.19,56.67 v2(64.41,58.45)
+EC_DEBUG_VCC: length 1.3
  TOP w0.102: v3(304.48,72.94) 304.48,73.09 304.08,73.5 v2(303.52,73.5)
+LCDVDD: length 8.8
  TOP w0.102: v1(74.83,117.7) 72.82,117.7 CV21.1 ; v1(74.83,117.7) v1(77.01,117.7) ; v1(74.83,117.7) 74.83,117.37 v1(75.92,116.27)
  BOTTOM w0.254: JEDP1.26 71.2,116.76 v2(71.53,116.42) ; v2(70.75,116.42) 70.7,116.47 JEDP1.25
+LINE1-VREFO-L: length 2.3
  TOP w0.203: UA1.31 305.1,32.62 305.17,32.54 RA57.1
+LINE1-VREFO-R: length 2.5
  TOP w0.203: UA1.30 303.88,32.22 303.93,32.27 305.01,32.27 RA58.1
+MIC2-VREFO: length 10.5
  TOP w0.254: RA6.1 299.54,26.5 RA5.1 298.71,26.26 v2(299.09,25.88)
  IN1 w0.254: v2(304.24,31.82) 304.27,31.79 304.27,30.63 299.51,25.88 v2(299.09,25.88)
  BOTTOM w0.102: v2(304.24,31.82) v3(304.74,31.82)
+PBATT: length 213.2
  TOP w0.508: v2(73.67,92.23) 74.9,92.23 76.15,90.98 81.25,90.98 81.4,90.83 81.99,90.24 83.95,90.24 84.88,90.24 85.78,91.14 85.78,93.39 85.43,93.74 85.43,96.12 87.33,98.02 87.33,98.82 88.38,99.86 88.97,99.86 93.17,104.06 96.09,104.06 97.8,105.77 99.41,105.77 101.39,107.76 104.54,107.76 106.75,109.97 117.4,109.97 117.86,110.43 126.72,110.43 128.02,111.73 129.83,111.73 131.55,110.02 133.26,110.02 134.68,111.44 154,111.44 158.13,107.31 158.91,107.31 159.12,107.11 159.49,107.11 160.05,106.55 160.05,105.84 161.72,104.16 164.43,104.16 165.12,103.47 165.12,103.06 166.44,101.74 169.31,101.74 170.48,100.57 173.25,100.57 175.12,98.7 175.12,94.53 175.33,94.32 175.33,93.27 178.74,89.86 179.94,89.86 188.33,81.47 188.33,76.08 189.13,75.28 189.13,70.62 199.2,60.55 199.2,59.2 213.17,45.23 v1(213.17,42.32) v2(213.17,40.61)
  IN1 w0.508: v2(73.67,92.23) 73.9,92.46 73.9,94.09 72.67,95.32 72.04,95.32 71.21,96.15 v2(71.21,96.27)
  BOTTOM w0.254: 67.43,98.88 67.4,98.85 67.05,98.85 66.1,97.9 64.91,97.9 64.43,98.38 64.06,98.38 63.67,97.99 63.67,97.1 PR940.1
  BOTTOM w0.508: 67.43,98.88 68.65,98.88 69.34,98.18 69.34,97.88 70.91,96.31 71.17,96.31 v2(71.21,96.27)
+PECI_VREF: length 10.6
  TOP w0.102: v2(272.89,51.16) 272.98,51.07 273.46,51.07 v3(273.56,50.97)
  TOP w0.254: UE1.J11 269.22,45.18 v2(269.22,45.18)
  TOP w0.381: RE59.1 271.54,51.06 CE25.1 272.79,51.06 v2(272.89,51.16)
  IN3 w0.508: v2(272.89,51.16) 272.65,51.16 269.73,48.24 269.73,46.72 269.93,46.52 269.93,45.95 269.22,45.23 v2(269.22,45.18)
+PWR_SRC: length 207.7
  TOP w0.508: v2(102.19,112.37) v1(102.19,110.97) 102.19,109.42 99.15,106.38 97.4,106.38 96.06,105.04 91.76,105.04 88.48,101.76 86.74,101.76 86.21,101.23 86.21,99.64 83.03,96.46 83.03,95.18 85.17,93.05 85.17,91.39 84.63,90.85 84.29,90.85 84.29,90.85 82.25,90.85 82.01,91.09 82.01,91.09 81.51,91.59 76.4,91.59 75.08,92.91 73.4,92.91 73.27,92.78 72.55,92.78 71.87,93.45 69.7,93.45 ; v2(73.79,105.86) 73.79,103.73 72.25,102.19 v2(72.25,100.82) 72.25,99.22 69.77,96.73 v2(69.77,95.61) ; CZ3.1 v2(101.54,115.4) ; RZ85.1 279.64,27.91 v2(279.66,27.93) ; QV1.4 59.87,106.5 59.87,105.67 CV13.2 ; v2(60.76,105.89) 60.67,105.79 60.6,105.79 CV13.2 ; CV13.2 60.17,104.54 RV4.2
  TOP w2.032: 42.42,48.35 42.48,48.41 42.48,58.26
  IN1 w0.508: v2(279.66,27.93) 278.74,27.93 276.98,26.17 273.94,26.17 273.36,26.76 263.8,26.76 263.72,26.84 261.8,26.84 260.8,27.83 243.51,27.83 240.75,30.6 238.87,30.6 238.21,31.26 235.32,31.26 v2(234.87,31.71)
  IN1 w1.016: 184.3,102.89 186.39,102.89 188.04,101.24 188.04,99.13 188.9,98.27 190.98,98.27 191.31,98.6 192.06,98.6
  IN2 w0.508: v2(73.79,105.86) 73.79,106.37 71.98,108.18 63.04,108.18 60.84,105.98 60.84,105.97 v2(60.76,105.89)
  IN3 w0.508: v2(67.97,101.34) 68.17,101.53 71.54,101.53 v2(72.25,100.82)
  BOTTOM w0.254: PR102.2 30.66,41.07 31.12,40.6
  BOTTOM w0.508: PD901.2 68.48,100.83 v2(67.97,101.34) ; PR929.2 66.01,92.54 67.02,93.55 67.16,93.55 v2(67.17,93.54)
  BOTTOM w1.016: 193.42,94.84 193.42,93.57 192.56,92.7 192.56,81.93 191.96,81.34 191.96,69.75 193.61,68.1 193.61,66.01 200.05,59.57 200.05,52.37
  vias: v2(42.32,46.11) v2(42.87,46.5) v2(43.29,46.92) v2(43.72,47.36) v2(60.21,58.48) v2(60.23,57.87) v2(60.21,57.27) v2(60.23,56.66) v2(60.81,58.5) v2(60.82,57.89) v2(60.81,57.3) v2(60.82,56.69) v2(61.39,58.51) v2(61.41,57.91) v2(61.39,57.31) v2(61.41,56.7) v2(62,58.51) v2(62.02,57.91) v2(62,57.31) v2(62.02,56.7) v2(62.61,58.51) v2(62.63,57.91) v2(62.61,57.31) v2(62.63,56.7) v2(67.19,95.07) v2(67.19,94.48) v2(67.5,95.64) v2(67.77,95.08) v2(67.76,94.48) v2(67.77,93.87) v2(67.76,93.26) v2(68.03,92.74) v2(68.11,95.64) v2(68.38,95.08) v2(68.37,94.48) v2(68.38,93.87) v2(68.37,93.26) v2(68.75,95.63) v2(68.91,94.77) v2(68.89,94.16) v2(68.9,93.54) v2(68.91,92.94) v2(183.09,104.62) v2(183.71,104.62) v2(193.45,96.48) v2(193.47,95.9)
+PWR_SRC_R: length 2.7
  TOP w0.508: v2(275.85,28.73) 275.85,28.42 v1(276.35,27.91) RZ85.2
+REGCTL_PNP10: length 1.5
  TOP w0.203: UL1.7 275.5,90.55 275.08,90.14
  vias: v1(274.64,89.38)
+RREF: length 1.7
  TOP w0.102: RR4.1 292.56,49.96 292.23,49.62 292.17,49.62 v1(291.66,49.12)
+RSVD_VCC3P3_1: length 5.4
  TOP w0.203: RL6.1 269.56,90.16 270.96,90.16 271.12,90.32 v3(271.63,90.32) 272.42,90.32 273.1,91 UL1.1
+RTC_CELL: length 269.7
  TOP w0.254: v2(137.53,64.8) 137.65,64.8 139.2,63.25 139.22,63.25 140.65,61.82 140.65,59.55 140.95,59.25 140.95,58.47 RC56.2
  TOP w0.305: CC270.1 141.61,56.99 142.04,57.42 v2(142.06,57.42) 141.82,57.67 RC57.2 ; CC213.1 134.5,72.04 134.98,72.52 135.07,72.52 135.07,72.53 v2(135.08,72.53)
  TOP w0.381: RC56.2 140.57,57.95 141.23,57.3 CC270.1
  TOP w0.508: v2(248.66,30.43) 248.66,30.29 249.16,29.79 249.91,29.79 250.29,30.17 RE31.1 250.99,29.95 251.84,29.1 v1(252.01,29.1) 253.34,29.1 253.8,28.64 v2(254.14,28.64) ; v2(308.23,10) 308.75,10.52 PD3.1 PC3.1 ; RA54.2 301.58,24.07 301.58,24.03 302.08,23.52 v2(302.36,23.52) ; RE508.2 259.84,32.11 259.84,32.84 RE32.1 v2(259.25,32.9) ; v2(257.66,39.2) 257.95,39.49 RE507.2 ; RE324.2 265.6,26.96 262.69,26.96 262.55,26.82 261.83,26.82 260.91,25.9 v2(260.91,25.81) ; RC69.2 151.08,60.64 153.22,58.5 154.86,58.5 157.55,55.82 157.55,54.07 v2(157.89,53.73)
  IN1 w0.254: v2(135.08,72.53) 135.07,72.53 135.07,72.52 135.02,72.52 134.62,72.13 134.62,71.08 134.62,71.08 134.62,66.69 136.52,64.8 v2(137.53,64.8)
  IN1 w0.508: v2(302.36,23.52) 302.07,23.52 300.05,21.5 300.05,17.96 299.06,16.97 299.06,15.94 v2(299.82,15.18)
  IN2 w0.508: v2(182.47,56.25) 184.17,54.54 185.06,54.54 200,39.59 201.29,39.59 204.62,36.27 207.11,36.27 208.58,34.79 218.21,34.79 220.49,32.52 228.18,32.52 229.49,31.21 233.35,31.21 233.97,30.58 237.77,30.58 238.49,29.87 245.25,29.87 245.41,30.04 247.34,30.04 247.56,29.82 248.2,29.82 248.66,30.27 v2(248.66,30.43) ; v2(257.34,28.65) 257.13,28.86 254.36,28.86 v2(254.14,28.64) 254.12,28.61 254.12,28.03 256.34,25.81 v2(260.91,25.81) 261.42,25.29 265.26,25.29 265.84,24.71 268.58,24.71 268.95,24.34 279.15,24.34 280.8,25.99 287.04,25.99 288.92,24.11 289.21,24.11 289.72,23.6 289.72,21.88 293.06,18.53 294.4,18.53 297.75,15.18 v2(299.82,15.18) 304.84,10.16 308.07,10.16 v2(308.23,10)
  BOTTOM w0.178: v2(137.53,64.8) UC1.BB14
  BOTTOM w0.254: v2(135.08,72.53) 135.07,72.53 135.07,72.55 135.11,72.59 135.11,72.8 UC1.AK19
  BOTTOM w0.508: v2(182.47,56.25) 182.47,56.2 178.1,51.84 164.06,51.84 163.36,52.53 160.21,52.53 159.45,53.29 159.45,54.33 159.31,54.48 158.6,54.48 157.89,53.76 v2(157.89,53.73) 157.02,53.73 155.59,55.16 149.09,55.16 148.39,54.45 144.05,54.45 142.01,56.49 142.01,57.37 v2(142.06,57.42) ; v2(257.66,39.2) 257.35,38.89 257.35,37.61 257.86,37.1 257.86,35.52 258.86,34.53 258.86,33.63 259.25,33.24 v2(259.25,32.9) 258.16,32.9 257.26,32 257.26,28.73 v2(257.34,28.65)
+RTC_CELL_VBAT: length 4.8
  TOP w0.254: CE11.1 v3(259.95,35.71) 259.95,36.45 261.08,37.59 UE1.A2
+SDC_IN: length 22.8
  TOP w0.508: PR1202.1 44.19,78.76 PQ1203.3 44.19,77.45 v2(44.27,77.38) ; v2(47.32,87.14) 45.93,87.14 v2(45.34,87.72)
  IN2 w0.457: v2(45.34,87.72) 45.57,87.5 45.57,85.87 45.24,85.54 45.24,77.56 44.99,77.31
  BOTTOM w0.254: PR10.1 43.64,89.68 PQ5.3 43.93,88.06 44.85,87.14 PR11.1 45.09,87.47 v2(45.34,87.72)
  BOTTOM w0.508: PR943.1 55.82,90.12 54.39,90.12 54.36,90.15
  vias: v1(54.84,94.75) v2(54,94.05) v2(54,93.47) v2(54,92.88) v2(54,92.3) v2(54,91.71) v2(54.49,94.34) v2(54.49,93.76) v2(54.49,93.17) v2(54.49,92.59) v2(54.49,92)
+SDREG2: length 1.2
  TOP w0.102: v3(301.63,55.53) 301.29,55.19 301.29,54.48
+SIM_PWR: length 64.7
  IN1 w0.508: v2(305.76,41.49) 305.76,42.92 v2(303.68,45)
  IN2 w0.508: v2(271.37,71.55) 272.61,71.55 277.63,66.54 281.21,66.54 288.81,58.94 289.12,58.94 289.84,58.22 289.84,56.48 293.17,53.15 293.17,51.51 294.68,50 294.68,48.81 295.7,47.8 296.94,47.8 297.78,46.96 301.43,46.96 302.01,46.38 v2(302.01,45.18)
  IN3 w0.508: v2(302.01,45.18) 303.51,45.18 v2(303.68,45) 303.68,45.01 305.36,46.69 307.83,46.69 v2(310.19,44.33)
  BOTTOM w0.254: JNGFF2.28 270.7,72.22 v2(271.37,71.55)
  BOTTOM w0.381: RZ335.1 v2(305.76,41.49)
  BOTTOM w0.508: v2(310.19,44.33) 310.5,44.02 JSIM1.C1 ; CZ37.1 304.19,45.69 303.68,45.18 v2(303.68,45) 303.9,44.79 CZ41.1
+TBT_SVR_IND: length 2.9
  BOTTOM w0.102: LT1.1 v3(22.5,81.5)
  vias: v2(21.29,79.17) v2(21.31,78.58) v2(21.31,77.97)
+TBTA_LDO_BMC: length 3.4
  TOP w0.203: CT71.1 29.54,65.94 29.17,65.94 28.92,65.69 28.92,64.65 28.76,64.49 UT5.E1
+TBTA_VBUS: length 1
  BOTTOM w0.102: PL1201.1 17.69,94.37
  BOTTOM w0.381: CT100.1 v2(9.36,93.29)
  vias: v1(16,96.5) v2(8.1,85.59) v2(8.1,85) v2(8.74,91.09) v2(8.74,88.58) v2(9.25,83.79) v2(9.32,91.09) v2(9.35,88.58) v2(9.35,83.15) v2(9.81,83.66) v2(10.09,84.19) v2(10.06,83.08) v2(10.39,83.66) v2(10.72,83.1) v2(10.97,83.79) v2(11.28,83.28) v2(11.28,82.7) v2(13.83,94.06) v2(14.05,94.61) v2(14.39,94.05) v2(14.45,95.05) v2(14.68,94.53) v2(15.03,95.13) v2(14.98,94.05) v2(15.31,94.56) v2(15.4,95.54) v2(15.86,95.87)
+TBTA_VBUS_1: length 82.2
  TOP w0.508: 32.11,58.85 32.11,57.07 31.57,56.53 31.57,49.17 33.85,46.89 33.85,44.14 32.54,42.83 v1(31.75,42.83) 30.48,41.56 30.48,40.76 29.59,39.87 29.59,36.91 29.58,36.9 29.58,36.41 29.59,36.4 29.59,24.43 32.35,21.67 40.81,21.67 v2(41.43,21.05) ; v2(39.81,62.58) 40.69,62.58 42.45,64.33 42.45,68.42 v2(42.19,68.67)
  IN1 w0.508: v2(39.81,62.58) 38.6,62.58 38.16,63.01 36.34,63.01 34.93,64.42 34.93,64.83 34.15,65.61 33.28,65.61 32.39,64.72 32.39,60.23 v2(31.36,59.2)
  IN2 w0.508: v2(31.36,59.2) 30.34,59.2 29.97,58.83 27.94,58.83 27.45,58.34 v2(26.48,58.34)
  BOTTOM w0.508: v2(42.19,68.67) 41.78,69.09 PC1216.1 41,69.45 PR1239.1 ; v2(41.43,21.05) 40.92,21.56 UT8.1
  vias: v2(16.32,57.12) v2(16.89,57.12) v2(17.08,57.75) v2(17.53,57.11) v2(17.72,57.75) v2(18.16,57.11) v2(19.43,97.33) v2(19.94,99.29) v2(19.99,97.33) v2(20.59,99.29) v2(21.17,99.28) v2(21.77,99.28) v2(22.38,99.29) v2(23.02,99.29) v2(23.6,99.29) v2(24.2,99.28) v2(25.19,57.8) v2(25.24,57.23) v2(25.74,57.79) v2(25.81,57.23) v2(25.99,56.69) v2(26.27,57.56) v2(28.32,110.46) v2(28.32,109.7) v2(28.32,109.06) v2(28.32,108.3) v2(29.15,110.52) v2(29.15,109.82) v2(29.15,109.12) v2(31.85,110.84) v2(32.21,111.32) v2(32.36,110.56) v2(44.37,114.69) v2(44.81,115.16) v2(44.94,114.55) v2(45.16,115.61) v2(45.45,115.03) v2(45.49,116.12) v2(45.67,116.68) v2(45.8,115.61) v2(46.08,116.27)
+USB_EX2_PWR: length 0.8
  TOP w0.102: v2(21.02,26.89) v1(21.02,27.65)
  vias: v2(20.45,26.64) v2(20.45,25.88) v2(21.02,26.26) v2(21.02,25.62)
+USB_EX3_PWR:
  vias: v1(24.83,45.43) v2(20.89,45.24) v2(20.89,44.61) v2(21.59,45.24) v2(22.23,45.24)
+UZ12_TPM: length 3.4
  BOTTOM w0.254: UZ12.8 165.65,86.05 165.57,85.97 CZ50.1 165.52,85.35 CZ75.1 165.53,85.18 RZ89.2
+VCHGR:
  vias: v1(204.54,37.81)
+VHDMI_VCC: length 4.3
  BOTTOM w0.102: v1(16.7,75.34) 16.7,73.84 17.43,73.12 UV2.3
  BOTTOM w0.254: RV23.2 15.34,70.16 v2(14.95,69.77)
  vias: v2(15.12,72.1) v2(15.06,71.49)
+VR_CAP: length 34.1
  TOP w0.102: v2(259.03,41.31) 259.03,41.89 v3(258.97,41.95)
  TOP w0.254: CE31.1 270.16,35.08 v2(270.03,35.2) 268.82,36.41 UE1.J1 ; UE1.C10 264.02,44.04 v2(263.65,44.41)
  IN2 w0.508: v2(263.65,44.41) 263.57,44.41 262.32,43.16 262.32,42.82 260.47,40.97 259.37,40.97 v2(259.03,41.31)
  IN3 w0.508: v2(255.69,35.6) 256.07,35.22 258.76,35.22 259.43,34.54 262.16,34.54 262.69,35.07 266.42,35.07 267.25,35.9 269.55,35.9 270.03,35.42 v2(270.03,35.2)
  BOTTOM w0.508: v2(259.03,41.31) 258.12,41.31 257.47,40.66 257.32,40.66 257.32,40.66 255.5,38.84 255.5,35.8 v2(255.69,35.6)
+Z4012: length 2.2
  TOP w0.127: PR2.2 v3(310.78,13.15)
  TOP w0.508: PR2.2 309.82,12.2 PD3.2
AC1_DISC#: length 54.8
  TOP w0.102: v2(39.32,79.6) 39.42,79.6 41.02,81.2 41.8,81.2 42.04,81.44 42.04,85.88 41.57,86.35 40.23,86.35 39.35,87.24 PR1244.1 ; v2(29.19,70.58) 28.74,71.03 PR939.1
  TOP w0.112: RT72.1 26.81,53.85 v2(26.85,53.82)
  IN1 w0.102: v2(29.19,70.58) 28.81,70.2 28.81,65.25 30.84,63.21 30.84,59.59 30.35,59.1 29.01,57.76 29.01,55.94 29.56,55.39 29.56,54.29 29.35,54.08 28.69,54.08 28.29,53.68 26.99,53.68 v2(26.85,53.82)
  IN2 w0.102: v2(39.32,79.6) 39.7,79.22 39.7,78.67 39.43,78.39 39.19,78.39 38.57,77.77 38.57,74.63 34.95,71.01 34.24,71.01 32.64,69.41 30.41,69.41 29.24,70.58 v2(29.19,70.58)
  BOTTOM w0.102: v3(26.6,54.34) 26.85,54.08 v2(26.85,53.82)
AC1_DISC#_R: length 2.5
  TOP w0.076: 27.33,57.65 27.76,58.08 UT5.G11
  TOP w0.112: RT72.2 26.81,57.13 27.33,57.65
AC_DIS: length 270.6
  TOP w0.102: RE83.1 267.9,49.16 267.9,47.65 v2(267.34,47.08) 267.7,46.72 267.7,46.25 268.02,45.93 UE1.H12
  IN2 w0.102: v2(56.54,107.97) 56.72,108.15 58.4,108.15 61.36,111.12 67.18,111.12 67.39,111.32 76.6,111.32 78.1,109.82 92.47,109.82 92.59,109.95 102.14,109.95 102.72,109.38 105.86,109.38 106.11,109.63 120.21,109.63 123.32,112.74 150.75,112.74 158.44,105.06 159.09,105.06 159.98,104.17 164.38,104.17 165.58,102.96 165.58,102.23 173.8,94.02 173.8,92.34 175.3,90.83 175.3,87.45 174.98,87.12 174.98,84.45 175.57,83.86 175.57,82.63 176.09,82.1 176.09,81.3 176.96,80.44 176.96,79.62 177.93,78.66 179.37,78.66 183.07,74.96 183.07,73.91 188.66,68.33 188.66,67.38 191.47,64.56 192.2,64.56 209.08,47.68 231.8,47.68 232.77,46.7 237.51,46.7 238.08,47.27 246.19,47.27 252.53,53.61 258.14,53.61 259.1,52.65 263.05,52.65 264.63,51.07 264.63,50.68 265.99,49.32 265.99,47.88 266.78,47.08 v2(267.34,47.08)
  BOTTOM w0.102: PR927.1 60.97,102.96 PQ909.2 ; PR927.1 v3(62.23,103.28) ; PR927.1 61.29,103.63 57.99,106.93 57.58,106.93 v2(56.54,107.97)
AC_DISC#: length 334.1
  TOP w0.102: v2(33.88,97.33) 34.36,96.86 34.36,94.66 PR1231.1 34.63,94.38 36.13,94.38 36.41,94.11 36.41,93.84 36.63,93.61 37.04,93.61 37.61,93.05 PR1245.1 38.42,93.05 PQ1210.6 38.74,92.72 PC1217.1 37.77,91.73 38.2,91.29 38.7,91.29 38.72,91.31 39.05,91.31 39.99,92.25 41.1,92.25 41.3,92.04 42.14,92.04 42.5,92.4 42.5,93.46 PQ1211.6 42.61,93.48 43.16,92.93 44.03,92.93 ; v2(43.23,106.34) 42.55,106.34 42.03,106.86 42.03,108.08 38.41,111.7 36.35,111.7 35.68,111.03 PR25.2 ; v2(264.92,48.23) 265.05,48.1 265.05,47.49 265.62,46.92 UE1.E13 ; PQ1211.3 43.91,92.8 44.03,92.93 ; PR1223.2 43.24,80.38 43.86,79.76 v2(43.96,79.76) ; 44.03,92.93 44.28,92.93 v2(44.58,93.24)
  IN2 w0.102: v2(33.88,97.33) 33.88,99.99 37.85,103.96 37.85,104.82 40.27,107.24 41.75,107.24 42.65,106.34 v2(43.23,106.34) 43.44,106.14 44,106.14 45.32,107.46 50.95,107.46 51.44,106.98 57.51,106.98 60.92,110.38 77.25,110.38 78.01,109.62 92.76,109.62 92.85,109.71 101.59,109.71 102.17,109.12 109.67,109.12 109.92,109.38 120.24,109.38 123.29,112.43 150.78,112.43 158.69,104.51 159.35,104.51 160.38,103.48 160.38,100.14 160.79,99.73 165.17,99.73 167.18,97.72 169.81,97.72 173.59,93.93 173.59,92.26 175.1,90.75 175.1,87.53 174.78,87.21 174.78,84.13 174.95,83.96 174.95,81.3 177.79,78.45 179.29,78.45 182.87,74.87 182.87,73.82 188.45,68.24 188.45,67.29 196.22,59.53 196.95,59.53 209.07,47.4 231.79,47.4 232.73,46.46 237.55,46.46 238.14,47.05 246.3,47.05 251.69,52.43 255.4,52.43 256.38,53.41 258.05,53.41 259.02,52.45 262.96,52.45 264.37,51.03 264.37,50.65 264.92,50.1 v2(264.92,48.23) ; v2(44.58,93.24) 43.36,92.02 43.36,87.76 43.51,87.61 43.51,84.83 44.25,84.1 44.25,80.06 v2(43.96,79.76)
AC_PRESENT: length 187.7
  TOP w0.102: RC243.1 171.46,54.76 v1(170.66,53.96) 170.43,53.72 166.02,53.72 165.83,53.92 163.67,53.92 163.17,54.41 159.36,54.41 v2(158.66,53.72)
  TOP w0.107: v2(270.02,42.79) 269.62,42.39
  IN2 w0.102: v2(270.02,42.79) 269.63,42.39 269.63,40.64 268.78,39.79 268.78,39.28 268.7,39.2 268.24,39.2 267.97,38.94 267.97,38.43 266.98,37.44 260.77,37.44 259.53,38.67 257.47,38.67 255.97,40.17 253.7,40.17 250.58,43.29 237.59,43.29 237.18,43.7 232.45,43.7 231.82,44.33 230.01,44.33 229.17,45.16 227.59,45.16 226.76,44.33 222.74,44.33 221.62,45.45 208.84,45.45 208.14,45.45 198.27,55.32 197.76,55.32 193.42,59.66 193.42,59.78 191.51,61.69 v2(190.93,61.69)
  BOTTOM w0.076: 141.29,57.86 139.65,59.5 139.65,61.39 136.54,64.5 136.54,66.44 136.65,66.55 136.65,66.83 UC1.AY15
  BOTTOM w0.102: v2(190.93,61.69) 190.44,62.18 180.95,62.18 180.08,61.31 180.08,60.26 183.25,57.09 183.25,56.09 178.59,51.43 163.89,51.43 163.2,52.12 159.57,52.12 159.01,52.69 159.01,53.38 v2(158.66,53.72) 158.13,53.18 156.99,53.18 155.63,54.54 149.05,54.54 148.56,54.05 143.63,54.05 141.48,56.19 141.48,57.67 141.29,57.86
ACAV_IN: length 391
  TOP w0.102: v2(31.88,70.99) 31.98,70.88 32.95,70.88 PR953.1 PR946.2 ; RE530.2 258.3,85.87 QE13.4 258.71,84.66 258.71,82.98 258.32,82.58 257.52,82.58 256.85,81.91 v3(256.85,79.04) 256.85,73.35 257.86,72.34 257.86,67.11 255.51,64.75 251.39,64.75 249.56,62.91 249.56,58.36 245.82,54.63 v2(245.3,54.63)
  TOP w0.107: UE1.C7 263.67,41.23 v2(263.58,41.23)
  IN2 w0.102: v2(263.58,41.23) 263.22,40.88 263.22,40.06 262.93,39.76 260,39.76 258.15,41.62 253.8,41.62 251.14,44.28 238.16,44.28 237.57,44.87 233,44.87 231.44,46.44 208.55,46.44 198.17,56.81 197.66,56.81 197.05,57.42 197.05,57.54 187.64,66.96 187.64,67.9 180.91,74.63 180.81,74.63 178.19,77.25 176.22,77.25 173.93,79.55 173.93,81.06 172.74,82.24 172.74,86.69 172.13,87.31 172.13,90.44 172.62,90.93 172.62,93.75 170.23,96.15 167.6,96.15 165.64,98.11 163.92,98.11 163.1,98.92 160.43,98.92 159.54,99.81 159.54,101.74 159.02,102.25 158.32,102.25 157.18,103.4 157.18,104.81 154.59,107.39 153.16,107.39 148.81,111.75 123.55,111.75 119.25,107.45 105.91,107.45 105.44,107.92 101.73,107.92 101.33,108.32 97.47,108.32 97.11,107.96 93.5,107.96 92.55,108.91 77.86,108.91 77,109.77 62.94,109.77 59.36,106.19 59.36,105.62 58.73,105 58.21,105 57.63,105.57 57.63,105.95 57.02,106.57 55.63,106.57 55.37,106.32 55.37,105.81 55.15,105.58 54.71,105.58 54.01,106.29 51.13,106.29 50.16,107.26 45.41,107.26 44.09,105.94 42.77,105.94 41.66,107.04 40.35,107.04 38.05,104.74 38.05,103.87 34.8,100.62 34.8,95.3 34.34,94.84 34.34,92.99 34.83,92.49 34.83,91.26 35.63,90.46 35.63,85.52 39.02,82.14 39.02,81.94 39.65,81.31 39.65,80.39 39.45,80.18 38.97,80.18 38.66,79.88 38.66,78.46 37.57,77.38 37.57,75.66 36.58,74.67 36.58,74.21 34.44,72.08 33.86,72.08 32.77,70.99 v2(31.88,70.99)
  BOTTOM w0.102: v2(245.3,54.63) 245.69,54.63 248.07,52.25 253.79,52.25 254.47,51.57 254.47,51.57 255.46,50.58 258.78,50.58 260.41,48.95 260.41,42.42 261.21,41.61 262.92,41.61 262.94,41.59 263.22,41.59 v2(263.58,41.23)
ACAV_IN1: length 67.3
  TOP w0.102: v2(30.96,70.76) 30.2,70.76 29.81,71.15 PR942.1
  IN1 w0.102: v2(50.35,81.11) 49.96,81.5 49.96,84.54 50.24,84.82 50.24,87.68 53.01,90.46 53.81,90.46 55.85,92.49 55.85,94.59 v2(55.42,95.03)
  IN3 w0.102: v2(50.35,81.11) 49.4,81.11 45.49,77.21 45.49,76.56 42.95,74.02 42.95,71.37 38.83,67.24 33.83,67.24 33.65,67.43 30.53,67.43 30.46,67.49 28.74,67.49 26.94,69.29 26.94,69.98 27.25,70.3 28.12,70.3 28.81,71 29.62,71 29.86,70.76 v2(30.96,70.76)
  BOTTOM w0.102: PQ909.1 60.33,99.8 59.78,99.24 PR918.1 PR925.1 59.34,98.65 58.7,98.65 v3(58.5,98.44) 58.14,98.08 56.7,98.08 56.22,97.61 55.74,97.61 55.54,97.41 55.54,96.37 55.08,95.9 55.08,95.48 55.42,95.15 v2(55.42,95.03) PR928.1
ACAV_IN_NB: length 421.6
  TOP w0.102: PR21.1 28.7,110.98 28.7,107.03 29.75,105.99 29.75,105.82 v2(32.16,103.4) ; PR1258.1 PR1241.1 45.96,88.26 45.68,88.54 45,88.54 42.99,86.53 42.79,86.53 42.25,85.98 42.25,81.35 41.89,80.99 41.1,80.99 40.72,80.61 40.72,78.79 39.74,77.8 v2(39.44,77.8) ; PU1201.1 38.74,68.93 38.43,68.62 37.46,68.62 37.28,68.44 35.94,68.44 PR1206.2 35.3,67.8 PC1207.1 34.43,68.18 34.58,68.33 35.08,68.33 36.16,69.41 v2(36.63,69.41) ; PR941.1 27.74,73.73 v2(27.79,73.68)
  TOP w0.107: v2(273.7,41.37) 273.7,41.37 273.7,40.87 273.59,40.76 272.05,40.76 UE1.N6
  IN2 w0.102: v2(273.7,41.37) 274.51,41.37 274.75,41.61 274.75,42.45 274.45,42.75 274.13,42.75 273.86,43.02 273.86,43.29 273.64,43.52 273.64,48.47 271.97,50.14 271.97,52.53 268.13,56.36 264.73,56.36 262.72,58.37 261.11,58.37 258.91,56.17 256.2,56.17 256.04,56 249.79,56 243.38,49.6 210.18,49.6 191.06,68.72 190.53,68.72 188.6,70.64 188.6,71.81 186.11,74.3 185.4,74.3 176.43,83.27 176.43,87.34 177.14,88.05 177.14,89.55 177.27,89.67 177.27,90.89 175.17,92.98 175.17,94.91 171.51,98.57 171.51,99.61 168.51,102.61 168.23,102.61 163,107.84 159.21,107.84 159.02,108.03 158.36,108.03 151.61,114.78 122.66,114.78 120.84,112.96 117.61,112.96 117.46,113.11 117.46,113.68 117.01,114.13 109.12,114.13 107.66,112.66 103.4,112.66 102.14,113.93 90.2,113.93 89.13,112.86 78.29,112.86 77.47,113.68 72.07,113.68 70.56,115.18 61.62,115.18 58.88,112.45 58.88,110.96 58.03,110.1 40.63,110.1 36.91,106.38 35.32,106.38 34.42,105.48 34.42,103.44 33.84,102.86 32.7,102.86 v2(32.16,103.4) 31.11,103.4 27.31,99.6 27.31,96.33 25.71,94.74 25.71,94.23 25.33,93.84 20.36,93.84 18.66,92.14 18.66,86.99 17.89,86.22 17.89,81.57 16.38,80.06 16.38,79.83 16.08,79.52 16.08,79.03 16.19,78.91 16.19,76.15 17.4,74.94 17.4,72.93 20.22,70.11 22.43,70.11 23.78,71.47 26.52,71.47 27.79,72.74 v2(27.79,73.68) 28.35,73.12 28.35,69.63 29.24,68.74 32.72,68.74 32.98,68.47 35.47,68.47 36.39,69.39 36.6,69.39 v2(36.63,69.41) 37.55,70.33 37.55,70.79 38.25,71.5 38.25,73.18 38.97,73.9 38.97,77.34 v2(39.44,77.8)
  BOTTOM w0.102: v3(36.3,68.69) 36.3,69.08 v2(36.63,69.41) 36.63,69.9 PR1203.2
ACIN_ISL88738: length 4.8
  BOTTOM w0.203: PC1286.1 57.21,92.63 v3(58.19,91.64) 58.33,91.51 59.04,91.51 59.13,91.42 PU901.19
  BOTTOM w0.254: PC1286.1 PR945.1 PR944.2
ACOK_ISL88738: length 3
  BOTTOM w0.203: PU901.24 59.18,93.42 58.22,94.38 57.47,94.38 57.45,94.4 PR928.2
ADP_ISL88738: length 2.9
  BOTTOM w0.203: PR943.2 57.98,89.88 v3(58.49,89.88) 60.09,89.88 PU901.16
ALW_PWRGD_3V_5V: length 251.9
  TOP w0.102: v2(228.03,29.88) 228.18,29.88 228.39,30.09 v1(230.82,30.09) 234.39,30.09 235.76,28.72 238.1,28.72 238.75,28.08 238.75,24.4 v2(239.04,24.1)
  IN2 w0.102: v2(242.78,27.63) 240.13,24.99 239.93,24.99 v2(239.04,24.1) ; v2(228.03,29.88) 228.03,30.02 227.01,31.03 227.01,31.11 226.89,31.24 221.87,31.24 219.18,28.54 201.92,28.54 201.45,28.08 199.29,28.08 198.95,28.42 197.4,28.42 197.1,28.71 172.63,28.71 171.48,27.56 163.98,27.56 163.48,27.07 160.66,27.07 160.27,27.46 157.34,27.46 156.16,26.28 155.73,26.28 155.35,25.89 137.17,25.89 136.42,26.65 134.88,26.65 134.13,25.89 115.19,25.89 113.92,24.63 82.63,24.63 81.46,25.81 46.86,25.81 43.09,22.03 32.54,22.03 29.47,25.1 29.47,38.02 32.5,41.04 v2(32.5,41.38)
  BOTTOM w0.102: PR119.2 238.48,24.67 v2(239.04,24.1) ; v2(32.5,41.38) 32.4,41.48 PR120.2 ; v2(242.78,27.63) 242.78,27.69 242.23,28.24 242.23,31.41 242.93,32.12 UZ6.2
ALWON: length 295.9
  TOP w0.102: UE1.A5 262.2,39.99 261.89,39.68 261.19,39.68 260.53,40.34 v3(260.21,40.34) 259.5,40.34 259.08,39.92 258.68,39.92 v2(258.33,40.27)
  IN2 w0.102: v2(258.63,23.28) 257.25,21.89 250.74,21.89 250.16,22.47 245.67,22.47 245.28,22.08 244.14,22.08 243.18,23.04 240.21,23.04 239.85,23.4 236.3,23.4 235.32,24.39 235.32,25.1 231.42,29 223.34,29 220.78,26.43 215.04,26.43 214.06,27.41 209.87,27.41 209.62,27.16 208.89,27.16 208.12,27.93 202.17,27.93 201.71,27.47 199.04,27.47 198.7,27.81 197.14,27.81 196.85,28.1 185.6,28.1 183.15,25.66 167.53,25.66 166.98,26.21 165.01,26.21 164.77,26.46 159.81,26.46 158.44,25.08 115.9,25.08 113.71,22.89 83.28,22.89 81.02,25.14 47.16,25.14 42.23,20.21 33.5,20.21 28.35,25.36 28.35,42.69 29.59,43.93 v2(29.59,46.19)
  BOTTOM w0.102: v2(258.33,40.27) 258.12,40.05 257.57,40.05 256.59,39.07 256.59,37.36 256.19,36.96 256.19,35.01 255.91,34.73 255.18,34.73 254.38,33.92 254.38,30.23 256.04,28.57 256.04,26.94 258.63,24.34 v2(258.63,23.28) ; v2(29.59,46.19) 29.59,44.82 PD100.2 31.12,44.79 PR114.1
AR_DET#: length 24.5
  TOP w0.102: v2(162.46,82.2) v1(162.46,83.66) 163.07,84.27 163.07,85.49 RC401.1 RC400.1
  IN3 w0.076: 146.43,81.82 146.28,81.67 v2(146.23,81.67)
  IN3 w0.102: v2(162.46,82.2) 162.03,81.76 152.92,81.76 152.28,82.39 147.01,82.39 146.43,81.82
  BOTTOM w0.076: UC1.P4 143.56,81.22 143.79,81.45 146.01,81.45 v2(146.23,81.67)
AR_DP1_CTRL_CLK: length 23.7
  TOP w0.076: UT1.Y2 32.86,81.64 32.86,81.08 33.23,80.71 33.23,80.31 33.24,80.3 33.24,80.28
  TOP w0.102: RT125.1 RT13.1 v2(34.9,78.29)
  TOP w0.112: 33.24,80.28 33.24,80.09 33.65,79.69 34,79.69 34.58,79.11 34.58,78.61 v2(34.9,78.29)
  IN1 w0.102: v2(24.38,70.32) 25.3,70.32 26.93,71.95 27.59,71.95 28.83,73.19 28.83,75.21 30.33,76.71 32.73,76.71 33.89,77.87 34.19,77.87 34.61,78.29 v2(34.9,78.29)
  BOTTOM w0.102: v2(24.38,70.32) v3(23.56,70.32) 22.17,70.32 22.05,70.2 QV3.1
AR_DP1_CTRL_DATA: length 24.5
  TOP w0.076: 33,80.28 33,80.3 33.02,80.31 33.02,80.63 32.67,80.99 32.67,81.37 UT1.Y1
  TOP w0.102: RT124.1 RT12.1 v2(34.01,78.29)
  TOP w0.112: 33,80.28 33,80 33.55,79.45 33.9,79.45 34.34,79.01 34.34,78.61 v2(34.01,78.29)
  IN1 w0.102: v2(34.01,78.29) 32.64,76.92 30.25,76.92 28.63,75.3 28.63,73.27 27.51,72.15 26.85,72.15 25.59,70.9 v2(24.39,70.9)
  BOTTOM w0.102: QV3.4 20.75,72.48 20.93,72.66 22.33,72.66 v3(23.19,71.8) 24.05,70.94 24.35,70.94 v2(24.39,70.9)
AR_DP1_HPD: length 18.3
  TOP w0.076: UT1.G1 26.63,81.15 26.5,81.02 26.5,79.91 26.47,79.88 26.47,79.65
  TOP w0.102: QV5.3 17.58,74.9 RV20.1 18.97,74.9 v2(19.79,74.08)
  TOP w0.112: v2(27.78,75.52) 27.78,75.53 27,76.31 27,78.68 26.47,79.2 26.47,79.65
  IN2 w0.102: v2(19.79,74.08) 22.94,74.08 23.63,74.77 27.03,74.77 v2(27.78,75.52)
  BOTTOM w0.102: v2(27.78,75.52) v3(27.17,75.52)
AR_DP1_N0: length 29
  TOP w0.076: UT1.R1 30.31,81.27 30.24,81.2 30.24,80.53 30.26,80.5 30.26,80.31 30.24,80.3 30.24,80.28
  TOP w0.112: v2(30.9,78.75) 30.9,78.83 30.76,78.98 30.53,78.98 30.24,79.26 30.24,80.28
  IN3 w0.135: v2(30.9,78.75) 30.9,78.8 31.03,78.92 31.16,78.92 31.34,78.74 31.34,78.42 30.56,77.64 30.56,77.05 27.87,74.36 27.39,74.36 26.06,73.03 26.06,72.91 24.99,71.84 24.31,71.84 23.58,71.11 23.58,65.19 23.97,64.8 23.97,63.69 22.27,61.99 21.41,61.99 21.3,62.1 20.99,62.1 20.85,62.24 20.85,62.42 20.97,62.54 v2(21.15,62.54)
  BOTTOM w0.112: v2(21.15,62.54) 21.15,62.44 20.93,62.22 20.75,62.22 CT201.2 20.48,62.31 20.17,62.31 CV32.1
AR_DP1_N1: length 31
  TOP w0.076: UT1.N1 29.23,81.42 29.18,81.37 29.18,81.25 29.42,81.01 29.42,80.36 29.46,80.32 29.46,80.29 29.48,80.28
  TOP w0.112: 29.48,80.28 29.55,80.2 29.55,79.27 29.32,79.04 29.12,79.04 28.99,79.17 28.99,79.35 29.12,79.48 v2(29.18,79.48)
  IN3 w0.135: v2(21.12,66.31) 20.98,66.17 20.61,66.17 20.14,65.7 20.14,63.76 20.61,63.28 21.98,63.28 22.9,64.2 22.9,71.43 27.41,75.94 28.45,75.94 29.74,77.23 29.74,78 29.86,78.11 29.86,79 29.56,79.3 29.35,79.3 v2(29.18,79.48)
  BOTTOM w0.112: v2(21.12,66.31) 21.12,66.16 21.04,66.08 20.71,66.08 CT202.2 20.47,66.11 20.13,66.11 CV34.1
AR_DP1_N2: length 25.4
  TOP w0.076: UT1.L1 28.47,81.11 28.53,81.06 28.53,80.31 28.54,80.3 28.54,80.28
  TOP w0.112: v2(27.92,78.68) 27.92,78.78 28.19,79.05 28.34,79.05 28.64,79.34 28.64,79.99 28.54,80.08 28.54,80.28
  IN3 w0.135: v2(27.92,78.68) 27.91,78.68 27.91,78.86 28.04,78.99 28.23,78.99 28.37,78.85 28.37,78.52 27.85,78 27.57,78 27.44,78.13 27.44,78.41 27.34,78.52 27.15,78.52 27.03,78.39 27.03,78.13 26.48,77.58 25.03,77.58 23.37,75.91 23.37,73.62 21.69,71.94 21.69,65.37 21.56,65.25 21.56,65.05 21.69,64.92 21.69,64.7 21.48,64.49 21.32,64.49 v2(21.18,64.63)
  BOTTOM w0.112: CV36.1 19.86,64.54 20.12,64.29 20.43,64.29 CT203.2 20.59,64.45 21,64.45 v2(21.18,64.63)
AR_DP1_N3: length 21.5
  TOP w0.076: UT1.J1 27.55,81.05 27.72,80.89 27.72,80.28
  TOP w0.112: v2(27.04,79.56) 27.04,79.66 27.17,79.79 27.55,79.79 27.72,79.96 27.72,80.28
  IN3 w0.135: v2(21.21,68.1) 21.04,68.1 20.88,67.94 20.7,67.94 20.39,68.25 20.39,71.91 20.99,72.52 20.99,76.01 24.84,79.86 26.44,79.86 26.56,79.73 26.56,79.28 26.71,79.13 26.89,79.13 27.04,79.28 v2(27.04,79.56)
  BOTTOM w0.112: CV38.2 20.21,67.95 20.54,67.95 CT204.2 21.19,68.12 v2(21.21,68.1)
AR_DP1_P0: length 29
  TOP w0.076: 30.51,80.28 30.51,80.3 30.49,80.31 30.49,80.59 30.46,80.62 30.46,81.1 30.54,81.18 30.54,81.65 UT1.R2
  TOP w0.112: 30.51,80.28 30.51,79.34 30.62,79.23 30.77,79.23 v2(30.9,79.36)
  IN3 w0.135: v2(30.9,79.36) 31.06,79.21 31.28,79.21 31.63,78.86 31.63,78.31 30.84,77.52 30.84,76.94 27.99,74.08 27.51,74.08 26.34,72.92 26.34,72.79 25.11,71.55 24.42,71.55 23.86,70.99 23.86,65.31 24.26,64.92 24.26,63.57 22.39,61.71 v2(21.13,61.71)
  BOTTOM w0.112: CV31.1 20.14,62 20.39,62 CT201.1 20.71,61.95 20.89,61.95 v2(21.13,61.71)
AR_DP1_P1: length 31
  TOP w0.076: 29.66,80.46 29.62,80.51 29.62,81.65 UT1.N2
  TOP w0.112: v2(29.18,78.66) 29.31,78.8 29.42,78.8 29.79,79.17 29.79,80.3 29.66,80.43 29.66,80.46
  IN3 w0.102: v2(29.18,78.66) 29.13,78.71 29.13,78.89
  IN3 w0.135: 29.13,78.89 29.26,79.02 29.44,79.02 29.57,78.88 29.57,78.23 29.46,78.11 29.46,77.35 29.24,77.13 29.06,77.13 28.91,77.28 28.72,77.28 28.55,77.11 28.55,76.92 28.7,76.77 28.7,76.59 28.33,76.22 27.29,76.22 22.61,71.55 22.61,64.32 21.86,63.57 20.73,63.57 20.42,63.87 20.42,64.78 20.49,64.84 20.76,64.84 20.89,64.97 20.89,65.15 20.76,65.28 20.52,65.28 20.42,65.38 20.42,65.59 20.73,65.89 20.92,65.89 21.04,65.76 21.04,65.63 v2(21.13,65.55)
  BOTTOM w0.112: v2(21.13,65.55) 21.13,65.69 21,65.81 20.76,65.81 CT202.1 20.41,65.79 20.13,65.79 19.86,65.53 CV33.1
AR_DP1_P2: length 25.2
  TOP w0.076: UT1.L2 28.47,81.8 28.24,81.57 28.24,81.02 28.3,80.97 28.3,80.31 28.28,80.3 28.28,80.28
  TOP w0.112: v2(27.92,79.41) 28.04,79.29 28.25,79.29 28.37,79.41 28.37,79.88 28.28,79.97 28.28,80.28
  IN3 w0.135: v2(21.19,64.07) 21.33,64.21 21.6,64.21 21.97,64.58 21.97,71.82 23.65,73.5 23.65,75.79 25.15,77.29 26.59,77.29 27.02,77.72 27.97,77.72 28.65,78.4 28.65,78.97 28.34,79.28 28.05,79.28 v2(27.92,79.41)
  BOTTOM w0.112: CV35.1 20.07,63.94 20.48,63.94 CT203.1 20.8,64.07 v2(21.19,64.07)
