# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D23: length 82.5
  IN3 w0.076: 132.39,54.89 131.94,54.89 131.15,55.68 130.12,55.68 128.98,56.83 128.98,63.15 124.67,67.45 124.67,69 124.49,69.19 124.49,69.7 124.15,70.04 v2(124.11,70.04)
  IN3 w0.117: v2(174.2,34.21) 174.33,34.34 174.33,35.18 173.48,36.03 173.48,37.07 173.2,37.35 173.2,38.03 172.98,38.25 172.9,38.25 172.77,38.37 172.77,41.79 172.93,41.95 172.93,42.11 172.66,42.38 172.5,42.38 172.28,42.16 172.12,42.16 171.95,42.33 171.95,42.5 172.17,42.71 172.17,42.87 172.01,43.03 171.84,43.03 171.62,42.8 171.45,42.8 170.9,43.36 170.9,44.14 170.4,44.64 170.23,44.64 170,44.42 169.84,44.42 169.67,44.58 169.67,44.75 169.9,44.97 169.9,45.14 166.89,48.15 166.89,48.9 166.19,49.6 165.44,49.6 164.31,50.73 163.96,50.73 163.85,50.84 163.85,50.98 163.73,51.1 163.5,51.1 163.38,50.98 163.38,50.84 163.26,50.73 162.5,50.73 161.45,51.77 153.13,51.77 152.36,52.54 149.74,52.54 148.48,53.81 145.89,53.81 145.71,53.99 143.03,53.99 142.73,54.29 138.58,54.29 137.98,54.89 132.39,54.89
  BOTTOM w0.076: UC1.AR37 v2(124.11,70.04)
  BOTTOM w0.112: JDIMM2.183 172.92,33.92 173.04,33.8 173.25,33.8 173.36,33.92 173.36,34.32 173.47,34.43 173.67,34.43 173.82,34.28 173.82,33.96 173.93,33.85 174.09,33.85 174.2,33.96 v2(174.2,34.21)
DDR_B_D24: length 83.9
  IN3 w0.076: v2(125.94,69.4) 125.58,69.05 125.58,68.56 125.73,68.42 125.73,67.89 128.05,65.57 128.05,65.25 128.98,64.32 129.59,64.32 130.1,63.81 130.1,57.06 130.7,56.46 131.46,56.46 132.44,55.48 139.8,55.48
  IN3 w0.117: 139.8,55.48 143.22,55.48 143.52,55.18 146.2,55.18 146.39,55 148.97,55 150.24,53.73 152.85,53.73 153.62,52.96 163.76,52.96 165.93,50.79 166.68,50.79 168.1,49.37 168.1,48.62 173.59,43.13 174.32,42.4 174.32,40.06 174.44,39.95 174.59,39.95 174.72,39.82 174.72,39.64 174.59,39.51 174.45,39.51 174.33,39.39 174.33,39.18 174.45,39.06 174.61,39.06 174.73,38.94 174.73,38.73 174.66,38.67 174.66,36.52 175.52,35.67 175.52,32.8 175,32.27 175,31.61 175.11,31.49 175.45,31.49 175.57,31.61 175.57,32.09 175.95,32.48 v2(175.95,32.69)
  BOTTOM w0.076: v2(125.94,69.4) 126.12,69.54 UC1.AT33
  BOTTOM w0.112: JDIMM2.191 174.92,35.1 175.26,34.77 175.26,33.38 v2(175.95,32.69)
DDR_B_D25: length 83.5
  IN3 w0.076: v2(125.94,68.77) 125.94,68.08 128.22,65.81 128.22,65.32 129.03,64.51 129.64,64.51 130.26,63.88 130.26,57.13 130.76,56.63 131.53,56.63 132.51,55.65 139.26,55.65 139.43,55.82 139.8,55.82
  IN3 w0.117: v2(175.95,34.21) 175.95,35.7 175.51,36.15 175.51,36.64 175.37,36.77 175.13,36.77 175,36.9 175,37.62 175.13,37.75 175.33,37.75 175.45,37.88 175.45,38.3 175.34,38.42 175.18,38.42 175.06,38.53 175.06,38.77 175.18,38.88 175.39,38.88 175.51,39 175.51,39.23 175.39,39.35 175.18,39.35 175.06,39.47 175.06,39.7 175.18,39.82 175.39,39.82 175.51,39.94 175.51,40.15 175.38,40.28 174.77,40.28 174.65,40.4 174.65,40.64 174.77,40.76 175.39,40.76 175.51,40.87 175.51,41.09 175.39,41.21 174.76,41.21 174.65,41.32 174.65,41.57 174.76,41.68 174.92,41.68 175.03,41.79 175.03,42.16 168.43,48.76 168.43,49.51 166.64,51.3 166.45,51.3 166.27,51.12 166.08,51.12 165.95,51.25 165.95,51.44 166.14,51.62 166.14,51.8 166,51.94 165.82,51.94 165.63,51.75 165.45,51.75 165.29,51.9 165.29,52.08 165.48,52.27 165.48,52.46 165.35,52.59 165.17,52.59 164.96,52.38 164.81,52.38 163.9,53.29 153.81,53.29 153.04,54.06 150.38,54.06 149.11,55.33 146.54,55.33 146.35,55.51 143.66,55.51 143.36,55.82 139.8,55.82
  BOTTOM w0.076: v2(125.94,68.77) 126.12,68.9 UC1.AU33
  BOTTOM w0.112: JDIMM2.195 175.92,35.14 176.04,35.03 176.44,35.03 176.54,34.93 176.54,33.96 176.43,33.85 176.07,33.85 175.95,33.96 v2(175.95,34.21)
DDR_B_D26: length 83.1
  IN3 w0.076: v2(127.77,68.77) 128.21,68.33 128.21,67.43 130.27,65.37 130.27,65.05 130.94,64.37 131.1,64.22 131.4,64.22 132.55,63.07 132.55,56.69 132.92,56.33 137.44,56.33 138.65,57.54 139.8,57.54
  IN3 w0.117: v2(178.6,32.69) 178.11,32.69 177.7,33.1 177.7,33.86 178.18,34.34 178.18,35.31 177.64,35.85 177.64,36.28 177.37,36.56 177.37,37.64 177.11,37.9 177.11,42.35 171.71,47.75 171.71,47.88 171.89,48.06 171.89,48.24 171.77,48.37 171.58,48.37 171.43,48.22 171.25,48.22 171.12,48.35 171.12,48.53 171.27,48.68 171.27,48.87 171.12,49.02 170.93,49.02 170.78,48.87 170.6,48.87 170.06,49.41 170.06,50.16 165.54,54.68 164.88,54.68 164.62,54.94 163.51,54.94 163.06,55.39 154.83,55.39 154.56,55.66 151.04,55.66 149.27,57.43 144.5,57.43 143.94,58 143.38,58 143.23,57.85 141.9,57.85 141.59,57.54 139.8,57.54
  BOTTOM w0.076: UC1.AU30 v2(127.77,68.77)
  BOTTOM w0.112: v2(178.6,32.69) 177.92,33.36 JDIMM2.203
DDR_B_D27: length 83.2
  IN3 w0.076: v2(127.77,69.4) 127.77,69.29 128.38,68.69 128.38,67.5 130.43,65.44 130.43,65.12 131.17,64.38 131.47,64.38 132.72,63.14 132.72,56.76 132.98,56.5 137.34,56.5 138.74,57.9 139.8,57.9
  IN3 w0.117: v2(178.6,34.21) 178.65,34.27 178.65,34.6 178.51,34.75 178.51,35.07 178.65,35.22 178.65,35.98 178.54,36.1 178.08,36.1 177.98,36.2 177.98,36.42 177.7,36.7 177.7,37 178,37.3 178,37.6 177.92,37.67 177.81,37.67 177.44,38.04 177.44,42.49 176.06,43.87 175.39,44.54 175.39,44.99 175.26,45.12 175.01,45.12 174.88,45.24 174.88,45.43 174.94,45.48 174.94,45.67 174.79,45.82 174.6,45.82 174.45,45.67 174.26,45.67 174.13,45.8 174.13,45.98 174.29,46.14 174.29,46.32 174.15,46.45 173.97,46.45 173.82,46.3 173.63,46.3 173.5,46.43 173.5,46.62 173.65,46.77 173.65,46.95 173.52,47.09 173.34,47.09 173.18,46.93 173,46.93 172.87,47.06 172.87,47.25 173.02,47.4 173.02,47.59 172.87,47.74 172.68,47.74 172.53,47.59 172.35,47.59 172.21,47.72 172.21,47.9 172.37,48.06 172.37,48.32 165.68,55.01 165.02,55.01 164.75,55.28 163.65,55.28 163.2,55.72 155.07,55.72 154.79,56 151.18,56 149.41,57.77 144.64,57.77 144.08,58.33 143.24,58.33 143.09,58.19 141.69,58.19 141.4,57.9 139.8,57.9
  BOTTOM w0.076: UC1.AT30 v2(127.77,69.4)
  BOTTOM w0.112: v2(178.6,34.21) 178.6,34.09 178.72,33.96 178.9,33.96 179.14,34.19 179.14,34.58 179.01,34.7 179.01,34.96 178.92,35.04 JDIMM2.207
DDR_B_D28: length 84.6
  IN3 w0.076: 139.8,56.15 139.45,56.15 139.13,55.84 132.55,55.84 131.6,56.79 131.28,56.79 130.43,57.65 130.43,63.95 129.71,64.67 129.11,64.67 128.77,65.01 128.77,65.48 126.35,67.9 126.35,69.62 v2(125.94,70.04)
  IN3 w0.117: v2(175.95,31.17) 175.95,30.95 176.48,30.43 176.65,30.43 176.82,30.6 176.82,30.76 176.34,31.24 176.34,35.78 175.84,36.29 175.84,41.82 168.76,48.9 168.76,49.65 165.32,53.09 164.64,53.09 164.05,53.68 162.98,53.68 162.54,54.12 154.26,54.12 153.98,54.4 150.51,54.4 149.24,55.66 146.75,55.66 146.53,55.88 143.77,55.88 143.49,56.15 139.8,56.15
  BOTTOM w0.076: v2(125.94,70.04) 126.12,70.18 UC1.AR33
  BOTTOM w0.112: v2(175.95,31.17) 175.1,30.31 175.1,29.32 174.68,28.9 JDIMM2.190
DDR_B_D29: length 85.2
  IN3 w0.076: 139.8,55.15 138.32,55.15 138.2,55.26 132.43,55.26 131.39,56.3 130.63,56.3 129.93,56.99 129.93,63.74 129.6,64.07 128.52,64.07 125.56,67.03 125.56,68.35 125.36,68.55 125.36,69.17 125.47,69.27 125.47,70.2 v2(125.94,70.67)
  IN3 w0.117: 139.8,55.15 143.08,55.15 143.38,54.85 146.07,54.85 146.25,54.67 148.83,54.67 150.1,53.4 152.72,53.4 153.49,52.63 163.62,52.63 165.8,50.45 166.54,50.45 167.77,49.23 167.77,48.48 173.34,42.91 173.95,42.3 173.95,39 174.33,38.62 174.33,36.38 175.19,35.53 175.19,32.93 175.18,32.92 174.63,32.37 174.63,29.16 174.74,29.04 175.84,29.04 175.95,29.16 v2(175.95,29.64)
  BOTTOM w0.076: v2(125.94,70.67) 126.12,70.82 UC1.AP33
  BOTTOM w0.112: JDIMM2.194 175.68,28.77 175.95,29.05 v2(175.95,29.64)
DDR_B_D30: length 84.2
  IN3 w0.076: v2(127.77,70.67) 128.14,70.3 128.14,69.16 128.54,68.76 128.54,67.57 130.6,65.51 130.6,65.2 131.25,64.55 132.07,64.55 132.42,64.2 132.94,64.2 133.86,63.28 133.86,61.94 134.41,61.39 135.41,61.39 138.56,58.23 139.8,58.23
  IN3 w0.117: v2(178.6,31.17) 178.81,31.17 178.99,31.35 178.99,36.22 178.77,36.44 178.39,36.44 178.28,36.55 178.28,36.75 178.41,36.89 178.75,36.89 178.88,37.02 178.88,37.88 178.76,38 177.94,38 177.83,38.12 177.83,38.38 177.94,38.5 178.73,38.5 178.84,38.61 178.84,38.83 178.73,38.94 177.89,38.94 177.78,39.06 177.78,42.63 176.49,43.91 176.49,44.67 165.82,55.34 165.16,55.34 164.89,55.61 163.78,55.61 163.34,56.05 155.25,56.05 154.97,56.33 151.31,56.33 149.54,58.1 144.78,58.1 144.21,58.67 143.1,58.67 142.96,58.52 141.55,58.52 141.26,58.23 139.8,58.23
  BOTTOM w0.076: UC1.AR30 v2(127.77,70.67)
  BOTTOM w0.112: JDIMM2.208 179.18,29.24 179.17,29.24 179.17,30.59 v2(178.6,31.17)
DDR_B_D31: length 85
  IN3 w0.076: 139.8,58.58 138.46,58.58 135.48,61.55 134.48,61.55 134.03,62.01 134.03,63.35 133.01,64.36 132.49,64.36 132.14,64.71 131.32,64.71 130.76,65.27 130.76,65.58 128.71,67.63 128.71,68.83 128.31,69.22 128.31,70.76 v2(127.77,71.31)
  IN3 w0.117: v2(178.6,29.64) 178.6,29.44 178.48,29.33 178.05,29.33 177.94,29.22 177.94,28.95 178.06,28.84 179.21,28.84 179.33,28.95 179.33,36.35 179.22,36.47 179.22,39.04 178.13,40.13 178.13,42.74 176.82,44.05 176.82,44.81 165.96,55.68 165.3,55.68 165.03,55.94 163.92,55.94 163.48,56.38 155.42,56.38 155.14,56.66 151.45,56.66 149.68,58.43 144.92,58.43 144.35,59 142.96,59 142.82,58.85 141.41,58.85 141.13,58.58 139.8,58.58
  BOTTOM w0.076: UC1.AP30 v2(127.77,71.31)
  BOTTOM w0.112: JDIMM2.204 178.18,29.22 v2(178.6,29.64)
DDR_B_D32: length 47
  IN1 w0.076: 131.21,53.63 131.21,54.75 129.87,56.1 129.87,57.33 v2(129.51,57.68)
  IN1 w0.119: 131.21,53.63 131.21,45.21 133.27,43.15 133.27,42.89 132.84,42.46 132.84,42.3 136.46,38.69 136.46,37.34 136.79,37.01 136.79,35.17 137.39,34.57 137.66,34.3 137.66,30.24 137.51,30.09 137.11,30.09 136.99,29.97 136.99,29.73 137.11,29.61 137.55,29.61 137.67,29.49 137.67,29.25 137.55,29.13 136.76,29.13 v2(136.6,29.29)
  BOTTOM w0.076: UC1.AY31 128.35,67.08 128.08,66.82 128.08,66.53 127.92,66.12 127.92,65.76 128.06,65.62 128.06,64.73 128.4,64.39 128.4,58.79 v2(129.51,57.68)
  BOTTOM w0.112: JDIMM2.50 137.67,28.89 137.28,29.29 v2(136.6,29.29)
DDR_B_D33: length 46.7
  IN1 w0.076: 130.2,53.69 130.2,54.76 128.81,56.15 128.81,62.69 v2(129.51,63.39)
  IN1 w0.119: 130.2,53.69 130.2,43.52 135.44,38.29 135.44,36.94 135.79,36.59 135.79,34.76 136.08,34.46 136.08,33.75 135.68,33.35 135.68,31.28 135.8,31.16 136.09,31.16 136.21,31.28 136.21,33.26 136.5,33.55 136.5,33.72 v2(136.57,33.79)
  BOTTOM w0.076: v2(129.51,63.39) 129.54,63.42 129.54,65.31 129.24,65.6 129.24,66.13 129.26,66.16 129.29,66.24 129.29,66.36 129.22,66.58 129.22,66.72 129.28,66.88 129.28,67.06 129.26,67.11 129.26,67.68 129,67.94 UC1.AW31
  BOTTOM w0.112: v2(136.57,33.79) 136.57,33.9 136.42,34.04 JDIMM2.45
DDR_B_D34: length 45.6
  IN1 w0.076: 132.48,53.63 132.48,54.62 130.58,56.52 130.58,61.68 v2(129.51,62.74)
  IN1 w0.119: 132.48,53.63 132.48,45.73 134.54,43.68 134.54,42.41 138.06,38.88 138.06,35.7 138.93,34.83 138.93,33.4 139.58,32.76 139.58,31.06 139.53,31.01 139.53,30.45 139.65,30.34 139.81,30.34 139.93,30.22 139.93,29.98 139.81,29.86 139.66,29.86 139.54,29.74 139.54,29.41 139.66,29.29 v2(140.32,29.29)
  BOTTOM w0.076: v2(129.51,62.74) 129.51,62.74 129.88,63.11 129.88,63.63 129.7,63.81 129.7,65.38 129.41,65.67 129.41,66.09 129.46,66.21 129.46,66.35 129.4,66.58 129.4,66.71 129.47,66.93 129.47,67.19 UC1.AY29
  BOTTOM w0.112: JDIMM2.58 139.67,28.9 140.07,29.29 v2(140.32,29.29)
DDR_B_D35: length 46.4
  IN1 w0.076: 132.82,53.63 132.82,54.6 130.74,56.68 130.74,59.12 v2(131.11,59.49)
  IN1 w0.119: v2(140.32,30.81) 140.22,30.71 140.05,30.71 139.93,30.83 139.93,33.34 139.81,33.46 139.42,33.46 139.3,33.58 139.3,33.85 139.42,33.97 139.71,33.97 139.83,34.09 139.83,34.33 139.71,34.45 139.39,34.45 139.27,34.56 139.27,34.97 138.4,35.84 138.4,39.02 134.87,42.55 134.87,43.81 132.82,45.87 132.82,53.63
  BOTTOM w0.076: UC1.AW29 129.57,67.72 129.88,67.41 129.88,66.86 130.11,66.64 130.11,65.69 130.2,65.6 130.2,64.03 130.4,63.83 130.4,60.2 v2(131.11,59.49)
  BOTTOM w0.112: JDIMM2.62 140.67,28.63 140.83,28.78 140.83,30.3 v2(140.32,30.81)
DDR_B_D36: length 45.3
  IN1 w0.076: v2(129.51,59.49) 128.98,58.96 128.98,56.22 130.54,54.66 130.54,53.68
  IN1 w0.119: 130.54,53.68 130.54,44.93 131,44.46 131,44.29 130.54,43.83 130.54,43.66 130.71,43.49 130.88,43.49 131.34,43.96 131.51,43.96 131.68,43.79 131.68,43.62 131.21,43.16 131.21,42.99 131.39,42.81 131.56,42.81 132.03,43.27 132.2,43.27 132.37,43.1 132.37,42.93 131.9,42.47 131.9,42.3 135.77,38.43 135.77,37.08 136.12,36.73 136.12,34.9 136.99,34.02 136.99,32.73 v2(136.6,32.34)
  BOTTOM w0.076: UC1.BB31 128.35,65.81 128.39,65.76 128.39,64.87 128.73,64.53 128.73,60.27 v2(129.51,59.49)
  BOTTOM w0.112: v2(136.6,32.34) 137.42,33.16 JDIMM2.49
DDR_B_D37: length 45.1
  IN1 w0.076: 130.88,53.63 130.88,54.65 129.14,56.39 129.14,58.47 v2(129.51,58.84)
  IN1 w0.119: 130.88,53.63 130.88,45.07 132.82,43.13 132.82,42.91 132.38,42.47 132.38,42.3 136.12,38.55 136.12,37.2 136.46,36.87 136.46,35.03 137.33,34.16 137.33,30.57 137.18,30.42 136.72,30.42 136.6,30.54 v2(136.6,30.81)
  BOTTOM w0.076: UC1.BA31 128.35,66.49 128.21,66.35 128.2,66.34 128.2,66.34 128.08,66.09 128.08,65.83 128.23,65.68 128.23,64.8 128.57,64.46 128.57,59.78 v2(129.51,58.84)
  BOTTOM w0.112: JDIMM2.46 136.67,28.64 136.1,29.22 136.1,30.31 v2(136.6,30.81)
DDR_B_D38: length 45.5
  IN1 w0.076: v2(131.11,58.12) 131.85,57.38 131.85,56.17 133.49,54.53 133.49,53.63
  IN1 w0.119: 133.49,53.63 133.49,46.15 135.54,44.09 135.54,42.83 139.07,39.3 139.07,38.27 139.19,38.15 139.96,38.15 140.08,38.03 140.08,37.77 139.95,37.65 139.19,37.65 139.07,37.53 139.07,37.25 139.19,37.13 140.39,37.13 140.61,36.92 140.61,35.98 140.71,35.88 140.71,32.73 v2(140.32,32.34)
  BOTTOM w0.076: v2(131.11,58.12) 130.24,59 130.24,63.76 130.03,63.96 130.03,65.51 129.94,65.6 129.94,66.14 129.67,66.41 UC1.BA29
  BOTTOM w0.112: JDIMM2.63 140.93,32.95 v2(140.32,32.34)
DDR_B_D39: length 44.1
  IN1 w0.076: 133.15,53.63 133.15,54.57 131.51,56.21 131.51,57.19 131.24,57.46 v2(131.11,57.46)
  IN1 w0.119: v2(140.32,33.78) 140.32,34.78 140.2,34.9 139.72,34.9 139.6,35.02 139.6,35.22 139.74,35.36 140.24,35.36 140.37,35.49 140.37,35.74 140.25,35.86 138.85,35.86 138.73,35.98 138.73,36.2 138.85,36.32 140.15,36.32 140.27,36.44 140.27,36.68 140.15,36.8 138.85,36.8 138.73,36.92 138.73,39.16 135.21,42.69 135.21,43.95 133.15,46.01 133.15,53.63
  BOTTOM w0.076: v2(131.11,57.46) 130.07,58.51 130.07,63.69 129.87,63.89 129.87,65.44 129.67,65.64 UC1.BB29
  BOTTOM w0.112: v2(140.32,33.78) 140.32,33.86 140.48,34.02 140.48,34.82 139.93,35.37 JDIMM2.59
DDR_B_D40: length 47.4
  IN1 w0.076: v2(131.11,61.44) 132.44,60.12 132.44,56.58 134.47,54.54 134.47,53.75 134.35,53.63
  IN1 w0.119: v2(142.43,30.81) 142.34,30.72 141.33,30.72 141.21,30.84 141.21,31.09 141.33,31.21 141.87,31.21 141.99,31.33 141.99,31.57 141.87,31.69 141.48,31.69 141.36,31.81 141.36,32.17 141.57,32.37 141.57,36.23 141.47,36.33 141.47,38.07 141.35,38.19 141.08,38.19 140.96,38.31 140.96,38.63 136.4,43.18 136.4,44.45 134.35,46.51 134.35,53.63
  BOTTOM w0.076: v2(131.11,61.44) 131.65,61.97 131.65,63.78 130.86,64.57 130.86,65.72 130.97,65.83 130.97,66.09 130.93,66.18 130.93,66.19 130.93,66.44 130.97,66.53 130.97,66.74 130.94,66.82 130.9,66.92 130.9,67.19 UC1.AY27
  BOTTOM w0.112: JDIMM2.66 141.67,30.06 v2(142.43,30.81)
DDR_B_D41: length 48.1
  IN1 w0.076: v2(131.11,60.14) 132.18,59.07 132.18,56.53 134.24,54.47 134.24,53.89 134.01,53.66 134.01,53.63
  IN1 w0.119: v2(142.43,29.29) 142.28,29.14 140.89,29.14 140.76,29.27 140.76,29.5 140.88,29.62 141.29,29.62 141.41,29.74 141.41,29.98 141.29,30.09 140.9,30.09 140.79,30.21 140.79,32.06 141.23,32.51 141.23,36.09 141.13,36.19 141.13,37.66 140.56,38.23 140.56,38.55 136.07,43.04 136.07,44.31 134.01,46.37 134.01,53.63
  BOTTOM w0.076: UC1.AW27 130.8,67.75 130.48,67.42 130.48,66.88 130.27,66.67 130.27,65.76 130.36,65.67 130.36,64.35 130.69,64.03 130.69,60.57 v2(131.11,60.14)
  BOTTOM w0.112: JDIMM2.70 142.67,29.05 v2(142.43,29.29)
DDR_B_D42: length 47.9
  IN1 w0.076: v2(133.07,58.96) 132.66,58.55 132.66,56.59 134.68,54.57 134.68,53.63
  IN1 w0.119: 134.68,53.63 134.68,46.64 136.74,44.59 136.74,43.32 141.8,38.26 141.8,36.79 142.02,36.57 142.3,36.57 142.41,36.45 142.41,36.21 142.3,36.09 142.02,36.09 141.9,35.97 141.9,35.75 142.02,35.63 142.3,35.63 142.41,35.51 142.41,35.28 142.3,35.16 142.02,35.16 141.9,35.04 141.9,34.8 142.02,34.68 142.28,34.68 142.41,34.55 142.41,34.32 142.3,34.2 142.02,34.2 141.9,34.08 141.9,33.42 142.02,33.3 142.31,33.3 142.43,33.18 142.43,32.94 142.31,32.82 142.02,32.82 141.9,32.7 141.9,32.16 142.02,32.04 142.31,32.04 142.43,32.16 v2(142.43,32.34)
  BOTTOM w0.076: v2(133.07,58.96) 133.54,59.43 133.54,63.51 132.47,64.58 132.47,66.11 132.35,66.36 132.3,66.47 132.3,66.81 132.03,67.08 UC1.AY25
  BOTTOM w0.112: v2(142.43,32.34) 141.62,33.15 141.62,34.64 141.93,34.95 JDIMM2.67
DDR_B_D43: length 48.7
  IN1 w0.076: v2(133.07,58.4) 133.45,58.03 133.45,56.11 135.02,54.55 135.02,53.63
  IN1 w0.119: v2(142.47,33.8) 142.47,33.9 142.75,34.18 142.75,36.6 142.14,37.21 142.14,38.4 139.75,40.78 139.75,40.95 140.2,41.39 140.2,41.56 140.03,41.73 139.86,41.73 139.42,41.29 139.25,41.29 139.09,41.45 139.09,41.61 139.53,42.06 139.53,42.23 139.36,42.4 139.2,42.4 138.75,41.95 138.58,41.95 138.41,42.12 138.41,42.29 138.88,42.75 138.88,42.92 138.71,43.09 138.54,43.09 138.08,42.63 137.91,42.63 137.74,42.8 137.74,42.97 138.2,43.43 138.2,43.6 138.03,43.77 137.86,43.77 137.4,43.3 137.23,43.3 137.07,43.46 137.07,43.68 137.52,44.12 137.52,44.29 135.02,46.78 135.02,53.63
  BOTTOM w0.076: UC1.AW25 131.39,67.94 131.17,67.71 131.17,67.22 131.1,67.12 131.1,66.87 131.14,66.74 131.14,66.51 131.14,66.5 131.13,66.5 131.13,66.5 131.1,66.41 131.1,66.21 131.13,66.12 131.13,66.12 131.13,65.76 131.06,65.68 131.06,64.6 131.85,63.81 131.85,59.63 v2(133.07,58.4)
  BOTTOM w0.112: JDIMM2.71 142.93,34.36 142.47,33.9 v2(142.47,33.8)
DDR_B_D44: length 46.5
  IN1 w0.076: v2(131.11,62.09) 131.94,62.92 133.22,62.92 135.02,61.13 135.02,56.06 136.64,54.44 136.7,54.44
  IN1 w0.119: v2(145.41,32.29) 145.04,33.15 145.04,38.25 142.14,41.14 142.14,42.41 137.48,47.07 137.48,53.77 136.81,54.44 136.7,54.44
  BOTTOM w0.076: UC1.BB27 130.69,65.98 130.69,64.5 131.48,63.71 131.48,62.46 v2(131.11,62.09)
  BOTTOM w0.112: v2(145.41,32.29) 145.41,32.34 144.93,32.83 JDIMM2.79
DDR_B_D45: length 46.8
  IN1 w0.076: 136.7,54.93 136.48,54.93 135.18,56.24 135.18,61.19 133.29,63.09 131.42,63.09 v2(131.11,63.39)
  IN1 w0.119: v2(145.45,33.82) 145.81,34.19 145.81,38.07 144.67,39.22 144.67,39.39 144.97,39.69 144.97,39.85 144.8,40.02 144.63,40.02 144.33,39.73 144.16,39.73 143.99,39.89 143.99,40.06 144.32,40.39 144.32,40.56 144.15,40.73 143.98,40.73 143.66,40.4 143.49,40.4 143.32,40.57 143.32,40.74 143.63,41.05 143.63,41.22 143.46,41.38 143.29,41.38 142.98,41.08 142.81,41.08 142.64,41.25 142.64,41.41 143.04,41.81 143.04,41.98 137.81,47.21 137.81,53.91 136.78,54.93 136.7,54.93
  BOTTOM w0.076: UC1.BA27 130.7,66.41 130.44,66.15 130.44,65.83 130.53,65.74 130.53,64.43 131.11,63.84 v2(131.11,63.39)
  BOTTOM w0.112: v2(145.45,33.82) 145.46,33.84 145.46,33.91 145.93,34.38 145.93,36.1
DDR_B_D46: length 46.4
  IN1 w0.076: v2(133.07,62.56) 133.18,62.56 134.85,60.9 134.85,55.83 136.57,54.11
  IN1 w0.119: 136.57,54.11 136.62,54.06 136.62,48.39 136.74,48.27 136.92,48.27 137.04,48.15 137.04,47.91 136.92,47.79 136.74,47.79 136.62,47.67 136.62,47.45 141.8,42.27 141.8,41 144.7,38.11 144.7,31.66 144.82,31.54 144.9,31.54 145.02,31.42 145.02,31.18 144.9,31.06 144.77,31.06 144.66,30.94 144.66,30.57 144.78,30.45 145.04,30.45 v2(145.41,30.82)
  BOTTOM w0.076: UC1.BA25 132.03,66.49 132.18,66.34 132.31,66.07 132.31,64.51 132.6,64.22 132.6,63.03 v2(133.07,62.56)
  BOTTOM w0.112: v2(145.41,30.82) 144.99,30.39 144.99,28.94 145.17,28.76 JDIMM2.80
DDR_B_D47: length 45.2
  IN1 w0.076: 136.29,53.83 136.29,54.04 133.95,56.38 133.95,61.13 v2(133.07,62.01)
  IN1 w0.119: 136.29,53.83 136.29,47.31 141.47,42.13 141.47,40.86 144.32,38.01 144.32,29.3 144.48,29.14 145.25,29.14 v2(145.41,29.29)
  BOTTOM w0.076: UC1.BB25 132.03,65.76 132.14,65.65 132.14,64.44 132.44,64.15 132.44,62.27 132.57,62.14 132.94,62.14 v2(133.07,62.01)
  BOTTOM w0.112: v2(145.41,29.29) 145.91,29.29 146.17,29.03 JDIMM2.84
DDR_B_D48: length 81.7
  IN3 w0.076: v2(129.6,68.75) 129.6,67.84 130.16,67.28 130.51,67.28 131.82,65.97 131.88,65.91 132.76,65.91 133.46,65.22 133.46,64.85 134.69,63.62 134.69,62.57 135.03,62.22 136.96,62.22 137.29,61.89
  IN3 w0.117: 137.29,61.89 140.75,61.89 141.64,61 143,61 143.48,60.52 144.98,60.52 145.54,59.96 150.31,59.96 152.08,58.18 156.1,58.18 156.38,57.91 164.11,57.91 164.55,57.46 166.94,57.46 174.22,50.18 174.22,49.56 179.65,44.13 179.65,40.76 181.19,39.22 181.19,29.45 180.9,29.17 180.31,29.17 180.2,29.28 180.2,29.52 180.32,29.64 v2(180.63,29.64)
  BOTTOM w0.076: UC1.AU27 v2(129.6,68.75)
  BOTTOM w0.112: v2(180.63,29.64) 181.18,29.1 JDIMM2.216
DDR_B_D49: length 81.9
  IN3 w0.076: 138.17,59.98 137.82,59.98 135.74,62.06 134.96,62.06 134.52,62.5 134.52,63.55 133.29,64.78 133.29,65.15 132.69,65.75 131.81,65.75 131.75,65.81 130.44,67.11 130.09,67.11 129.24,67.97 129.24,68.98 129.6,69.33 v2(129.6,69.4)
  IN3 w0.117: v2(180.63,34.21) 180.85,34.44 180.85,34.75 180.64,34.97 180.64,35.17 180.85,35.39 180.85,39.09 179.32,40.62 179.32,43.99 173.7,49.61 173.7,49.73 173.86,49.89 173.86,50.07 173.73,50.2 173.54,50.2 173.42,50.08 173.23,50.08 173.1,50.21 173.1,50.4 173.23,50.52 173.23,50.7 173.07,50.85 172.89,50.85 172.77,50.73 172.58,50.73 172.45,50.86 172.45,51.05 172.57,51.17 172.57,51.36 172.44,51.49 172.26,51.49 172.13,51.36 171.95,51.36 171.82,51.5 171.82,51.68 171.94,51.8 171.94,51.99 171.79,52.14 171.6,52.14 171.48,52.02 171.3,52.02 171.16,52.15 171.16,52.33 171.29,52.46 171.29,52.64 171.16,52.77 170.97,52.77 170.85,52.65 170.66,52.65 170.53,52.78 170.53,52.97 170.65,53.09 170.65,53.27 170.52,53.41 170.34,53.41 170.22,53.28 170.03,53.28 169.9,53.41 169.9,53.6 170.02,53.72 170.02,53.91 169.87,54.06 169.69,54.06 169.56,53.93 169.38,53.93 169.25,54.07 169.25,54.25 169.38,54.39 169.38,54.55 166.8,57.13 164.41,57.13 163.97,57.57 156.14,57.57 155.86,57.85 151.95,57.85 150.17,59.63 145.4,59.63 144.84,60.19 143.34,60.19 142.86,60.67 141.49,60.67 140.69,61.46 139.7,61.46 139.33,61.09 139.33,60.18 139.13,59.98 138.17,59.98
  BOTTOM w0.076: UC1.AT27 v2(129.6,69.4)
  BOTTOM w0.112: v2(180.63,34.21) 180.92,34.51 JDIMM2.215
DDR_B_D50: length 81.3
  IN3 w0.076: 136.67,63.49 135.75,63.49 134.12,65.12 134.12,65.49 133.04,66.57 132.2,66.57 131.16,67.62 131.16,68.68 130.51,69.33 v2(130.51,69.4)
  IN3 w0.117: v2(183.68,31.17) 183.28,31.57 183.28,34.09 182.79,34.58 182.79,39.89 181.27,41.41 181.27,44.8 175.83,50.23 175.83,50.84 167.61,59.06 165.3,59.06 164.07,60.29 159.51,60.29 159,59.78 152.75,59.78 150.96,61.57 146.38,61.57 145.43,62.52 145.42,62.52 145.4,62.53 143.74,62.53 143.66,62.6 143.02,62.6 142.13,63.49 136.67,63.49
  BOTTOM w0.076: UC1.AT25 v2(130.51,69.4)
  BOTTOM w0.112: JDIMM2.224 183.18,30.66 v2(183.68,31.17)
DDR_B_D51: length 80.5
  IN3 w0.076: 135.89,63.16 135.77,63.28 135.73,63.28 133.95,65.05 133.95,65.42 132.97,66.41 132.14,66.41 130.99,67.55 130.99,68.29 v2(130.51,68.77)
  IN3 w0.117: v2(183.67,29.72) 182.94,30.45 182.94,33.96 182.45,34.44 182.45,39.75 180.93,41.27 180.93,44.66 175.5,50.09 175.5,50.7 167.47,58.73 165.16,58.73 163.93,59.96 159.65,59.96 159.14,59.45 152.61,59.45 150.82,61.24 146.23,61.24 145.26,62.2 143.6,62.2 143.53,62.27 142.88,62.27 141.99,63.16 135.89,63.16
  BOTTOM w0.076: UC1.AU25 v2(130.51,68.77)
  BOTTOM w0.112: JDIMM2.228 184.17,27.9 184.17,29.22 v2(183.67,29.72)
DDR_B_D52: length 83
  IN3 w0.076: 138.72,59.43 138.13,59.43 135.68,61.88 134.91,61.88 134.36,62.43 134.36,63.48 133.15,64.69 132.63,64.69 130.37,66.95 130.02,66.95 129.07,67.9 129.07,69.04 129.23,69.2 129.23,70.31 v2(129.6,70.67)
  IN3 w0.117: v2(180.63,32.69) 180.27,32.69 180.19,32.78 180.19,35.47 180.3,35.58 180.4,35.58 180.52,35.7 180.52,35.93 180.4,36.05 180.3,36.05 180.19,36.17 180.19,36.7 180.07,36.82 180.07,39.4 178.99,40.48 178.99,43.85 168.73,54.11 168.73,54.19 168.91,54.37 168.91,54.55 168.78,54.68 168.59,54.68 168.47,54.56 168.28,54.56 168.15,54.69 168.15,54.87 168.28,55 168.28,55.18 168.15,55.32 167.96,55.32 167.84,55.19 167.65,55.19 167.52,55.32 167.52,55.51 167.65,55.63 167.65,55.82 167.51,55.95 167.33,55.95 167.2,55.82 167.02,55.82 166.87,55.97 166.87,56.16 166.97,56.27 166.97,56.43 166.61,56.8 164.28,56.8 163.83,57.24 155.9,57.24 155.62,57.52 151.81,57.52 150.03,59.29 145.27,59.29 144.71,59.85 142.95,59.85 142.59,60.21 141.55,60.21 140.78,59.43 138.72,59.43
  BOTTOM w0.076: UC1.AP27 v2(129.6,70.67)
  BOTTOM w0.112: v2(180.63,32.69) 179.92,33.39 JDIMM2.211
DDR_B_D53: length 83.5
  IN3 w0.076: 138.19,59.1 135.57,61.72 134.55,61.72 134.19,62.07 134.19,63.41 133.08,64.53 132.56,64.53 132.21,64.88 131.38,64.88 130.93,65.34 130.93,66.16 130.3,66.78 129.95,66.78 128.91,67.83 128.91,69.11 129.06,69.26 129.06,70.78 129.59,71.31
  IN3 w0.112: v2(129.6,71.31) 129.59,71.31 ; 138.19,59.1 139.8,59.1
  IN3 w0.117: 139.8,59.1 140.92,59.1 141.19,59.38 142.6,59.38 142.75,59.52 144.57,59.52 145.13,58.96 149.89,58.96 151.67,57.19 155.45,57.19 155.72,56.91 163.7,56.91 164.14,56.47 165.91,56.47 177.57,44.8 177.57,44.51 177.45,44.38 177.45,44.16 177.6,44.01 177.79,44.01 177.93,44.15 178.11,44.15 178.25,44.02 178.25,43.84 178.09,43.68 178.09,43.53 178.66,42.96 178.66,40.34 179.74,39.26 179.74,36.68 179.85,36.56 179.85,31.62 180.31,31.17 v2(180.63,31.17)
  BOTTOM w0.076: UC1.AN27 v2(129.6,71.31)
  BOTTOM w0.112: v2(180.63,31.17) 180.18,30.71 JDIMM2.212
DDR_B_D54: length 83.5
  IN3 w0.076: 135.28,64.49 134.45,65.32 134.45,65.63 133.17,66.9 132.35,66.9 131.49,67.77 131.49,68.82 131.05,69.26 131.05,70.77 v2(130.51,71.31) ; 142.98,64.07 142.43,64.63 142.13,64.63 141.85,64.35 140.64,64.35 140.33,64.04 138.32,64.04 138.06,64.3
  IN3 w0.117: v2(183.68,32.69) 184.07,33.08 184.07,36.25 183.9,36.42 183.9,38.21 184.07,38.38 184.07,39.73 181.93,41.86 181.93,45.07 176.5,50.51 176.5,51.12 167.07,60.54 164.76,60.54 164.15,61.15 159.42,61.15 158.72,60.45 153.02,60.45 151.24,62.23 147.57,62.23 146.53,63.27 143.79,63.27 142.98,64.07 ; 135.28,64.49 135.47,64.3 138.06,64.3
  BOTTOM w0.076: UC1.AN25 v2(130.51,71.31)
  BOTTOM w0.112: JDIMM2.229 184.43,35.04 184.65,34.81 184.65,33.66 v2(183.68,32.69)
DDR_B_D55: length 81.8
  IN3 w0.076: 135.68,63.82 134.28,65.22 134.28,65.56 133.11,66.74 132.27,66.74 131.32,67.69 131.32,68.75 130.88,69.2 130.88,70.31 v2(130.51,70.67)
  IN3 w0.112: 141.54,64.17 140.9,64.17 140.57,63.84
  IN3 w0.117: 135.68,63.82 140.55,63.82 140.57,63.84 ; v2(183.68,34.21) 183.72,34.26 183.72,35.14 183.6,35.26 183.36,35.26 183.23,35.39 183.23,35.57 183.37,35.71 183.6,35.71 183.73,35.84 183.73,36.02 183.6,36.15 183.27,36.15 183.14,36.29 183.14,36.47 183.27,36.6 183.44,36.6 183.56,36.73 183.56,37.82 183.44,37.94 183.27,37.94 183.14,38.07 183.14,38.26 183.27,38.39 183.6,38.39 183.73,38.52 183.73,38.71 183.6,38.84 183.27,38.84 183.14,38.97 183.14,39.18 183.27,39.31 183.56,39.31 183.69,39.44 183.69,39.63 183.56,39.76 183.25,39.76 183.14,39.87 183.14,40.01 181.6,41.55 181.6,44.93 176.16,50.37 176.16,50.98 167.75,59.4 165.44,59.4 164.01,60.82 159.56,60.82 158.86,60.12 152.88,60.12 151.1,61.9 147.43,61.9 146.39,62.94 143.27,62.94 142.04,64.17 141.54,64.17
  BOTTOM w0.076: UC1.AP25 v2(130.51,70.67)
  BOTTOM w0.112: JDIMM2.225 183.43,34.98 183.68,34.73 v2(183.68,34.21)
DDR_B_D56: length 87.7
  IN3 w0.076: v2(132.34,69.4) 132.34,69.28 131.98,68.92 131.98,67.97 132.56,67.4 133.38,67.4 134.54,66.24 135.26,66.24 135.41,66.09
  IN3 w0.112: 136.46,65.9 136.73,65.9 136.94,66.11 138.99,66.11 139.1,66.22 143.16,66.22 144.25,65.13 144.25,65.13
  IN3 w0.117: v2(186.56,32.69) 186.09,32.23 185.89,32.23 185.76,32.1 185.76,30.06 185.65,29.94 185.47,29.94 185.36,30.05 185.36,40.11 183.12,42.36 183.12,45.57 177.68,51 177.68,51.61 166.95,62.34 158.65,62.34 157.94,61.64 153.51,61.64 151.73,63.42 148.11,63.42 147.03,64.51 144.88,64.51 144.25,65.13 ; 136.46,65.9 136.14,65.9 135.95,66.09 135.41,66.09
  BOTTOM w0.076: UC1.AT22 v2(132.34,69.4)
  BOTTOM w0.112: JDIMM2.233 185.43,33.82 v2(186.56,32.69)
DDR_B_D57: length 87.3
  IN3 w0.076: 135.07,66.42 134.59,66.42 133.14,67.88 133.14,67.9 132.81,68.23 132.29,68.23 132.2,68.32 132.2,68.61 v2(132.34,68.75) ; 135.94,66.42 136.07,66.29 138.91,66.29 139.06,66.44 143.42,66.44 144.25,65.6
  IN3 w0.117: 135.94,66.42 135.07,66.42 ; v2(186.56,34.21) 186.39,34.38 186.19,34.38 186.06,34.26 186.06,32.66 185.95,32.56 185.83,32.56 185.74,32.65 185.74,34.75 185.95,34.96 185.95,35.46 185.74,35.67 185.74,36.04 185.95,36.25 185.95,36.54 185.7,36.8 185.7,38.28 185.71,38.29 185.71,40.24 183.45,42.49 183.45,45.7 183.18,45.97 183.18,46.14 183.32,46.28 183.32,46.45 183.16,46.61 182.99,46.61 182.85,46.47 182.69,46.47 182.52,46.64 182.52,46.8 182.66,46.94 182.66,47.11 182.5,47.27 182.33,47.27 182.19,47.13 182.02,47.13 181.82,47.34 181.82,47.49 181.95,47.63 181.95,47.81 181.83,47.93 181.65,47.93 181.53,47.81 181.34,47.81 181.21,47.95 181.21,48.13 181.33,48.25 181.33,48.44 181.22,48.55 181.03,48.55 180.91,48.43 180.73,48.43 180.59,48.57 180.59,48.75 180.71,48.87 180.71,49.06 180.59,49.18 180.4,49.18 180.28,49.06 180.1,49.06 179.97,49.19 179.97,49.38 180.09,49.5 180.09,49.68 179.96,49.81 179.78,49.81 179.65,49.69 179.47,49.69 179.35,49.81 179.35,49.99 179.47,50.11 179.47,50.3 179.32,50.45 179.13,50.45 179.01,50.33 178.83,50.33 178.7,50.46 178.7,50.64 178.81,50.76 178.81,50.96 178.65,51.12 178.47,51.12 178.35,50.99 178.16,50.99 178.04,51.11 178.04,51.28 178.12,51.35 178.12,51.64 167.09,62.67 159.87,62.67 159.76,62.79 159.76,63.19 159.62,63.33 159.4,63.33 159.29,63.21 159.29,62.79 159.17,62.67 158.51,62.67 157.81,61.97 153.65,61.97 151.87,63.76 148.25,63.76 147.17,64.84 145.02,64.84 144.25,65.6
  BOTTOM w0.076: UC1.AU22 v2(132.34,68.75)
  BOTTOM w0.112: JDIMM2.237 186.43,34.35 v2(186.56,34.21)
DDR_B_D58: length 86.6
  IN3 w0.076: 134.44,67.92 135.64,67.92 136.61,66.95 138.59,66.95 138.82,67.18 144.25,67.18 ; v2(133.25,68.75) 133.49,68.75 134.33,67.92 134.35,67.92
  IN3 w0.117: v2(189.1,32.69) 189.1,32.52 188.72,32.15 188.38,32.15 188.27,32.27 188.27,33.18 187.74,33.71 187.74,34.89 187.22,35.41 187.22,36.94 187.81,37.54 187.81,38.38 186.98,39.22 186.98,41.2 186.85,41.32 186.43,41.32 186.31,41.44 186.31,41.67 186.43,41.79 186.85,41.79 186.98,41.92 186.98,42.42 185.73,43.67 185.56,43.67 185.06,43.17 184.9,43.17 184.73,43.33 184.73,43.51 185.23,44 185.23,44.17 184.73,44.67 184.73,46.96 167.7,64 166.23,64 165.62,64.6 158.64,64.6 157.28,63.24 154.18,63.24 152.33,65.09 148.71,65.09 147.69,66.11 145.54,66.11 144.47,67.18 144.25,67.18 ; 134.35,67.92 134.44,67.92
  BOTTOM w0.076: UC1.AU21 v2(133.25,68.75)
  BOTTOM w0.112: JDIMM2.245 188.43,33.36 v2(189.1,32.69)
DDR_B_D59: length 86.8
  IN3 w0.076: 136.74,67.13 135.78,68.08 134.8,68.08 134.38,68.5 134.03,68.5 133.72,68.81 133.72,68.82 133.25,69.29 v2(133.25,69.4)
  IN3 w0.112: 144.25,67.71 143.9,67.71 143.58,67.38 138.76,67.38 138.51,67.13 136.74,67.13
  IN3 w0.117: v2(189.1,34.21) 188.68,33.8 188.19,33.8 188.07,33.91 188.07,35.19 188.39,35.5 188.55,35.5 188.87,35.18 189.04,35.18 189.2,35.35 189.2,35.51 188.88,35.84 188.88,36 189.11,36.23 189.11,36.39 188.95,36.55 188.79,36.55 187.89,35.64 187.73,35.64 187.55,35.81 187.55,35.97 187.78,36.2 187.78,36.37 187.58,36.57 187.58,36.73 187.74,36.9 187.91,36.9 188.11,36.7 188.27,36.7 188.47,36.89 188.47,37.06 188.2,37.32 188.2,38.46 187.32,39.34 187.32,42.98 185.88,44.43 185.71,44.43 185.65,44.38 185.49,44.38 185.32,44.54 185.32,44.71 185.38,44.76 185.38,44.93 185.22,45.09 185.22,46.94 167.83,64.33 166.36,64.33 165.76,64.93 158.5,64.93 157.14,63.57 154.32,63.57 152.02,65.87 148.54,65.87 147.97,66.44 147.17,66.44 145.9,67.71 144.25,67.71
  BOTTOM w0.076: UC1.AT21 v2(133.25,69.4)
  BOTTOM w0.112: JDIMM2.249 189.43,34.54 v2(189.1,34.21)
DDR_B_D60: length 89.1
  IN3 w0.076: v2(132.34,71.31) 131.79,70.76 131.79,69.24 131.65,69.1 131.65,67.83 132.42,67.07 133.24,67.07 134.61,65.7 134.61,65.41 135.01,65.01 ; 137.23,65.16 137.88,65.16 138.03,65.01
  IN3 w0.112: 138.37,64.67 140.36,64.67 141.45,65.75 143.06,65.75 144.05,64.76 144.05,64.39
  IN3 w0.117: 135.01,65.01 136.94,65.01 137.09,65.16 137.23,65.16 ; v2(186.56,29.64) 186.56,28.92 186.18,28.54 184.82,28.54 184.7,28.67 184.7,39.84 182.45,42.08 182.45,45.29 177.02,50.73 177.02,51.33 166.68,61.68 159.21,61.68 158.5,60.97 153.24,60.97 151.45,62.76 147.83,62.76 146.75,63.84 144.6,63.84 144.05,64.39 ; 138.03,65.01 138.37,64.67
  BOTTOM w0.076: v2(132.34,71.31) UC1.AN22
  BOTTOM w0.112: v2(186.56,29.64) 186.17,29.26 186.17,27.9 JDIMM2.236
DDR_B_D61: length 88.8
  IN3 w0.076: v2(132.34,70.67) 131.96,70.29 131.96,69.16 131.82,69.02 131.82,67.9 132.49,67.23 133.31,67.23 134.67,65.88 135.2,65.88 135.32,65.76
  IN3 w0.112: 144.25,64.66 144.25,64.85 143.15,65.95 139.11,65.95 139,65.84 137.16,65.84
  IN3 w0.117: v2(186.56,31.17) 186.28,31.17 186.17,31.05 186.17,29.74 185.99,29.56 185.22,29.56 185.03,29.75 185.03,39.98 182.79,42.22 182.79,45.43 177.35,50.86 177.35,51.47 166.82,62.01 159.07,62.01 158.37,61.3 153.38,61.3 151.59,63.09 147.97,63.09 146.89,64.17 144.74,64.17 144.25,64.66 ; 135.32,65.76 135.81,65.76 136.09,65.48 136.8,65.48 137.16,65.84
  BOTTOM w0.076: UC1.AP22 v2(132.34,70.67)
  BOTTOM w0.112: JDIMM2.232 185.18,29.79 v2(186.56,31.17)
DDR_B_D62: length 88.1
  IN3 w0.076: 136.76,68.36 136.42,68.36 136.37,68.41 134.93,68.41 134.65,68.7 134.65,70.19 v2(134.17,70.67)
  IN3 w0.112: 136.76,68.36 141.31,68.36 141.44,68.23 142.03,68.23 142.2,68.41 144.24,68.41 144.25,68.4
  IN3 w0.117: v2(189.12,30) 189.88,30.76 189.88,36.7 190.78,37.6 190.78,39.06 188.98,40.86 188.98,42.27 185.98,45.27 185.98,47.12 168.11,64.99 167.01,64.99 165.84,66.16 163.64,66.16 163.19,66.6 160.57,66.6 157.32,69.86 154.06,69.86 152.01,67.81 152.01,67.55 151.48,67.02 149.07,67.02 148.52,67.56 148.52,68 148.02,68.51 147.35,68.51 147.25,68.4 144.26,68.4 144.25,68.4
  BOTTOM w0.076: 134.1,70.74 v2(134.17,70.67) ; 134.08,70.76 133.79,71.05 UC1.AP21
  BOTTOM w0.112: JDIMM2.246 188.68,29.55 v2(189.12,30) ; 134.08,70.76 134.1,70.74
DDR_B_D63: length 89.3
  IN3 w0.076: v2(133.25,71.31) 133.62,70.94 133.62,69.45 134.41,68.66 134.45,68.66 134.87,68.25 136.13,68.25 136.24,68.13 136.63,68.13
  IN3 w0.112: 144.25,68.04 144.09,68.21 142.29,68.21 142.12,68.03 141.32,68.03 141.22,68.13 136.63,68.13
  IN3 w0.117: v2(189.1,31.17) 189.54,31.61 189.54,36.47 188.54,37.47 188.54,38.6 187.66,39.48 187.66,40.88 187.77,41 187.91,41 188.03,41.12 188.03,41.35 187.91,41.47 187.77,41.47 187.66,41.58 187.66,43.12 185.65,45.13 185.65,46.98 167.97,64.66 166.5,64.66 165.9,65.26 160.47,65.26 158.98,66.75 158.98,67.72 157.18,69.53 154.32,69.53 152.34,67.56 152.34,66.97 151.58,66.2 148.68,66.2 148.11,66.77 147.3,66.77 146.04,68.04 144.25,68.04
  BOTTOM w0.076: UC1.AN21 v2(133.25,71.31)
  BOTTOM w0.112: v2(189.1,31.17) 189.68,30.59 JDIMM2.250
DDR_B_DQS0: length 44.9
  IN1 w0.076: 124.11,53.63 124.11,53.64 124.14,53.67 124.14,56.29 124.53,56.68 124.53,60.79 124.45,60.86 124.15,60.86 v2(124.08,60.79)
  IN1 w0.124: v2(128.07,31.96) 127.91,32.11 127.57,32.11 127.32,32.36 127.32,33.6 127.62,33.9 127.62,34.08 127.16,34.55 127.16,34.9 127.34,35.08 127.34,35.3 127.05,35.6 126.87,35.6 126.67,35.39 126.31,35.39 125.91,35.79 125.91,36.14 126.12,36.35 126.12,36.53 124.11,38.53 124.11,53.63
  BOTTOM w0.076: UC1.AY38 123.93,67.42 123.63,67.12 123.63,66.52 123.58,66.41 123.58,66.2 123.63,66.09 123.63,65.68 123.51,65.56 123.51,65.09 123.68,64.93 123.68,63.89 123.68,63.89 123.51,63.73 123.51,61.18 123.72,60.98 123.89,60.98 v2(124.08,60.79)
  BOTTOM w0.112: v2(128.07,31.96) 128.24,32.13 128.39,32.13 128.72,32.46 128.72,34.36 128.3,34.77 128.3,34.98 128.42,35.1 JDIMM2.13
DDR_B_DQS1: length 45.5
  IN1 w0.076: 128.14,53.63 128.14,53.64 128.11,53.67 128.11,55.24 127.05,56.31 127.05,59.95 127.19,60.09 127.63,60.09 127.74,59.98 127.74,59.87 127.66,59.79 v2(127.63,59.79)
  IN1 w0.124: v2(133.24,32.21) 133.14,32.1 132.96,32.1 132.85,32.21 132.85,33.03 132.75,33.13 132.75,36.49 132.41,36.82 132.41,37.9 130.95,39.36 130.95,39.86 128.14,42.68 128.14,53.63
  BOTTOM w0.076: v2(127.63,59.79) 127.63,60.02 127.56,60.09 127.01,60.09 126.81,60.3 126.81,64.82 126.62,65.01 126.62,66.13 126.67,66.24 126.67,66.26 126.67,66.37 126.62,66.5 126.62,66.77 126.65,66.85 126.65,67.07 126.62,67.13 126.57,67.21 126.53,67.23 126.45,67.23 126.38,67.17 126.38,66.96 UC1.BA34
  BOTTOM w0.112: JDIMM2.34 133.67,28.75 133.54,28.89 133.54,29.31 134.11,29.88 134.11,31.76 133.88,31.99 133.4,31.99 133.24,32.15 v2(133.24,32.21)
DDR_B_DQS2: length 81.4
  IN3 w0.076: v2(123.25,70.03) 122.96,69.74 122.88,69.74 122.71,69.57 122.71,68.45 125.8,65.36 125.8,64.53 128.28,62.04 128.28,56.53 129.83,54.98 130.36,54.98 130.83,54.51 130.83,54.44 130.85,54.43
  IN3 w0.124: v2(172.27,33.07) 172.26,33.05 172.26,32.9 172.38,32.77 172.62,32.77 172.74,32.9 172.74,34.78 172.6,34.92 172.3,34.92 172.07,35.15 172.07,36.49 171.3,37.26 171.3,40.97 166.74,45.52 166.74,45.75 166.74,46.31 163.73,49.32 161.88,49.32 160.84,50.37 152.55,50.37 151.78,51.14 149.16,51.14 147.89,52.4 144.31,52.4 144.13,52.59 142.45,52.59 142.14,52.89 137.79,52.89 137.54,53.14 137.54,53.34 137.31,53.58 136.82,53.58 136.48,53.92 136.16,53.92 135.82,53.58 135.2,53.58 134.85,53.92 134.22,53.92 133.87,53.58 133.26,53.58 132.92,53.92 132.54,53.92 132.2,53.58 131.7,53.58 130.85,54.43
  BOTTOM w0.076: UC1.AR38 123.65,70.35 v2(123.25,70.03)
  BOTTOM w0.112: JDIMM2.179 171.92,35.34 171.78,35.2 171.78,32.93 172.02,32.7 172.24,32.7 172.35,32.81 172.35,32.99 v2(172.27,33.07)
DDR_B_DQS3: length 84
  IN3 w0.076: v2(126.85,70.04) 127.1,70.04 127.21,69.93 127.21,68.63 127.15,68.58 127.15,67.47 128.97,65.65 129.16,65.65 129.6,65.21 129.6,65.11 130.92,63.79 131.26,63.79 132.22,62.83 132.22,56.56 132.78,56 138.8,56 139.4,56.6 139.61,56.6 139.7,56.69 139.71,56.69 139.8,56.69
  IN3 w0.124: 139.8,56.69 148.97,56.69 150.73,54.92 154.23,54.92 154.51,54.65 162.76,54.65 163.08,54.33 163.2,54.2 164.31,54.2 164.58,53.94 165.23,53.94 169.29,49.87 169.29,49.12 176.37,42.05 176.37,36.51 176.9,35.97 176.9,35.54 177.44,35.01 177.44,34.65 176.87,34.08 176.87,31.46 177.45,30.88 v2(177.45,30.79)
  BOTTOM w0.076: UC1.AR32 126.95,70.04 v2(126.85,70.04)
  BOTTOM w0.112: JDIMM2.200 177.18,28.9 177.01,29.06 177.01,29.67 176.86,29.83 176.86,30.9 176.97,31 177.23,31 v2(177.45,30.79)
DDR_B_DQS4: length 46
  IN1 w0.076: v2(129.51,60.79) 129.72,61 129.88,61 130.24,60.65 130.24,56.16 131.76,54.64 131.76,53.67 131.74,53.64 131.74,53.63
  IN1 w0.124: 131.74,53.63 131.74,45.42 133.8,43.37 133.8,42.1 137.32,38.58 137.32,35.39 138.19,34.52 138.19,32.35 138.44,32.1 138.92,32.1 139.05,31.97 v2(139.05,31.96)
  BOTTOM w0.076: UC1.AY30 128.71,67.35 128.62,67.21 128.58,67.1 128.58,66.82 128.61,66.74 128.61,66.53 128.56,66.42 128.56,66.2 128.61,66.09 128.61,65.48 128.58,65.45 128.58,64.91 128.95,64.54 128.95,61.2 129.16,60.99 129.31,60.99 v2(129.51,60.79)
  BOTTOM w0.112: v2(139.05,31.96) 139.05,32.06 139.18,32.19 139.42,32.19 139.68,32.44 139.68,33.78 138.78,34.67 138.78,34.95 138.93,35.1 JDIMM2.55
DDR_B_DQS5: length 47.6
  IN1 w0.076: v2(133.07,60.2) 133.31,60.44 133.54,60.44 133.62,60.36 133.62,56.21 135.57,54.26 135.57,53.67 135.55,53.64 135.55,53.63
  IN1 w0.124: v2(143.75,31.19) 143.48,31.46 143.19,31.46 142.96,31.7 142.96,33.57 143.28,33.89 143.28,37.36 142.93,37.71 142.93,38.35 140.73,40.56 140.73,41.82 135.55,47 135.55,53.63
  BOTTOM w0.076: v2(133.07,60.2) 132.77,60.5 132.24,60.5 132.06,60.68 132.06,63.92 131.8,64.18 131.8,65.51 131.8,65.52 131.6,65.73 131.6,66.12 131.65,66.26 131.65,66.37 131.6,66.5 131.6,66.77 131.63,66.85 131.63,67.07 131.61,67.13 131.56,67.21 131.51,67.23 131.43,67.23 131.36,67.17 131.36,66.96 UC1.BA26
  BOTTOM w0.112: JDIMM2.76 144.17,28.67 144.03,28.81 144.03,29.17 143.26,29.94 143.26,31.4 143.39,31.53 143.62,31.53 143.75,31.4 v2(143.75,31.19)
DDR_B_DQS6: length 81.8
  IN3 w0.076: 137.29,62.42 137.2,62.42 137.14,62.48 136.24,62.48 136.15,62.39 135.15,62.39 134.85,62.69 134.85,63.69 133.62,64.92 133.62,65.29 132.83,66.08 131.94,66.08 130.6,67.43 130.6,67.93 129.95,68.58 129.95,69.9 129.81,70.04 v2(129.6,70.04)
  IN3 w0.124: 137.29,62.42 141.01,62.42 141.9,61.53 143.22,61.53 143.7,61.05 145.2,61.05 145.33,60.92 145.34,60.92 145.76,60.49 150.52,60.49 152.3,58.71 164.05,58.71 164.77,57.99 167.16,57.99 174.76,50.4 174.76,49.79 180.19,44.35 180.19,40.96 181.71,39.44 181.71,32.78 181.96,32.53 182.18,32.53 v2(182.41,32.31)
  BOTTOM w0.076: UC1.AR27 v2(129.6,70.04)
  BOTTOM w0.112: JDIMM2.221 182.42,36.1 182.42,35.21 182.28,35.07 182.28,34.86 182.97,34.17 182.97,34.17 183.06,34.08 183.06,32.84 182.75,32.53 182.58,32.53 182.41,32.36 v2(182.41,32.31)
DDR_B_DQS7: length 87.6
  IN3 w0.076: v2(133.25,70.67) 133.25,70.54 133.14,70.43 132.88,70.43 132.7,70.25 132.7,68.57 134.16,67.11 134.16,67.08 134.27,66.97 134.32,66.97 134.34,66.95 134.35,66.95
  IN3 w0.112: 144.25,66.35 143.9,66.7 138.89,66.7 138.75,66.57 136.22,66.57 135.84,66.95 135.41,66.95
  IN3 w0.124: 134.35,66.95 135.41,66.95 ; 144.25,66.35 145.24,65.37 147.38,65.37 148.4,64.35 152.02,64.35 153.87,62.5 157.59,62.5 158.95,63.86 161.87,63.86 162,63.73 162,63.45 162.25,63.2 162.8,63.2 163.05,63.45 163.05,63.73 163.17,63.86 163.54,63.86 163.67,63.73 163.67,63.45 163.92,63.2 164.47,63.2 164.72,63.45 164.72,63.73 164.84,63.86 165.28,63.86 165.88,63.25 167.39,63.25 183.99,46.65 183.99,42.71 186.24,40.47 186.24,38.6 186.48,38.36 186.48,35.1 187,34.58 187,31.46 187.44,31.02 187.59,31.02 v2(187.83,30.79)
  BOTTOM w0.076: UC1.AR21 133.52,70.4 v2(133.25,70.67)
  BOTTOM w0.112: JDIMM2.242 187.68,28.75 187.53,28.9 187.53,29.37 187.41,29.49 187.41,30.85 187.52,30.97 187.65,30.97 v2(187.83,30.79)
DDR_B_DQS#0: length 44.7
  IN1 w0.076: v2(124.08,61.44) 124.02,61.38 124.02,61.25 124.12,61.14 124.21,61.14 124.27,61.09 124.46,61.09 124.69,60.86 124.69,56.61 124.3,56.22 124.3,53.67 124.33,53.64 124.33,53.63
  IN1 w0.124: 124.33,53.63 124.33,38.62 126.33,36.61 126.33,36.26 126.13,36.06 126.13,35.88 126.4,35.61 126.58,35.61 126.78,35.81 127.14,35.81 127.56,35.39 127.56,35 127.37,34.81 127.37,34.64 127.84,34.17 127.84,33.81 127.54,33.51 127.54,32.45 127.66,32.33 127.93,32.33 128.08,32.48 128.08,32.7 v2(128.07,32.72)
  BOTTOM w0.076: v2(124.08,61.44) 124.08,61.24 123.98,61.15 123.79,61.15 123.68,61.25 123.68,63.66 123.84,63.83 123.84,64.99 123.68,65.16 123.68,65.49 123.8,65.61 123.8,66.12 123.75,66.23 123.75,66.4 123.8,66.51 123.8,66.91 123.85,66.96 UC1.BA38
  BOTTOM w0.112: v2(128.07,32.72) 128.01,32.66 128.01,32.49 128.15,32.34 128.31,32.34 128.51,32.54 128.51,34.27 128.1,34.68 128.1,34.93 127.93,35.1 JDIMM2.11
DDR_B_DQS#1: length 45.5
  IN1 w0.076: v2(127.63,60.44) 127.44,60.25 127.12,60.25 126.88,60.02 126.88,56.24 127.95,55.17 127.95,53.67 127.92,53.64 127.92,53.63
  IN1 w0.124: v2(133.24,31.45) 132.64,32.06 132.64,32.94 132.54,33.04 132.54,36.4 132.2,36.74 132.2,37.81 130.74,39.27 130.74,39.77 127.92,42.59 127.92,53.63
  BOTTOM w0.076: v2(127.63,60.44) 127.45,60.26 127.08,60.26 126.98,60.37 126.98,64.89 126.78,65.09 126.78,66.09 126.83,66.2 126.83,66.42 126.78,66.53 126.78,66.74 126.82,66.82 126.82,67.1 126.77,67.21 126.69,67.35 126.56,67.4 126.5,67.4 126.48,67.42 UC1.AY34
  BOTTOM w0.112: JDIMM2.32 133.17,28.67 133.32,28.81 133.32,28.82 133.34,28.84 133.34,29.4 133.9,29.97 133.9,31.67 133.79,31.78 133.36,31.78 133.24,31.67 v2(133.24,31.45)
DDR_B_DQS#2: length 81.4
  IN3 w0.076: 131.04,54.54 130.9,54.67 130.43,55.15 129.9,55.15 128.45,56.6 128.45,62.11 125.96,64.59 125.96,65.43 122.87,68.52 122.87,69.5 122.95,69.58 123.06,69.58 v2(123.25,69.39)
  IN3 w0.124: 131.04,54.54 131.79,53.79 132.11,53.79 132.45,54.13 133.01,54.13 133.35,53.79 133.79,53.79 134.13,54.13 134.94,54.13 135.29,53.79 135.73,53.79 136.07,54.13 136.57,54.13 136.91,53.79 137.4,53.79 137.76,53.43 137.76,53.23 137.88,53.1 142.23,53.1 142.53,52.8 144.22,52.8 144.4,52.62 147.98,52.62 149.25,51.35 151.87,51.35 152.64,50.58 160.92,50.58 161.97,49.53 163.82,49.53 166.96,46.4 166.96,45.75 166.96,45.61 171.51,41.05 171.51,37.35 172.28,36.58 172.28,35.23 172.38,35.13 172.69,35.13 172.95,34.86 172.95,32.81 172.7,32.56 172.43,32.56 172.27,32.4 v2(172.27,32.31)
  BOTTOM w0.076: UC1.AT38 123.65,69.7 v2(123.25,69.39)
  BOTTOM w0.112: v2(172.27,32.31) 172.09,32.49 171.93,32.49 171.58,32.84 171.58,35.17 171.43,35.33 JDIMM2.177
DDR_B_DQS#3: length 84.1
  IN3 w0.076: v2(127.77,70.04) 127.73,70.07 127.45,70.07 127.37,70 127.37,68.56 127.32,68.51 127.32,67.54 129.04,65.81 129.23,65.81 129.76,65.28 129.76,65.18 130.99,63.95 131.33,63.95 132.39,62.9 132.39,56.62 132.85,56.17 138.73,56.17 139.33,56.76 139.54,56.76 139.65,56.88 139.68,56.88 139.71,56.9 139.8,56.9
  IN3 w0.124: 139.8,56.9 149.06,56.9 150.82,55.14 154.32,55.14 154.6,54.86 162.85,54.86 163.29,54.42 164.4,54.42 164.66,54.15 165.32,54.15 169.51,49.96 169.51,49.21 176.58,42.13 176.58,36.6 177.12,36.06 177.12,35.63 177.65,35.1 177.65,34.56 177.08,33.99 177.08,31.55 177.23,31.4 177.3,31.4 v2(177.45,31.55)
  BOTTOM w0.076: UC1.AT32 127.6,70.04 v2(127.77,70.04)
  BOTTOM w0.112: JDIMM2.198 176.68,28.9 176.79,29.02 176.79,29.04 176.81,29.06 176.81,29.59 176.66,29.74 176.66,30.98 176.88,31.21 177.22,31.21 177.45,31.45 v2(177.45,31.55)
DDR_B_DQS#4: length 46
  IN1 w0.076: 131.95,53.63 131.95,53.64 131.93,53.67 131.93,54.71 130.41,56.23 130.41,60.72 129.95,61.17 129.66,61.17 129.51,61.31 v2(129.51,61.44)
  IN1 w0.124: 131.95,53.63 131.95,45.51 134.01,43.46 134.01,42.19 137.53,38.67 137.53,35.48 138.4,34.61 138.4,32.44 138.53,32.31 138.82,32.31 139.05,32.54 v2(139.05,32.72)
  BOTTOM w0.076: v2(129.51,61.44) 129.51,61.31 129.36,61.16 129.23,61.16 129.12,61.27 129.12,64.61 128.75,64.98 128.75,65.38 128.78,65.41 128.78,66.13 128.73,66.24 128.73,66.26 128.73,66.37 128.78,66.5 128.78,66.77 128.74,66.85 128.74,67.07 128.77,67.13 128.84,67.25 128.89,67.31 128.97,67.31 129.05,67.23 129.06,67.14 UC1.BA30
  BOTTOM w0.112: v2(139.05,32.72) 139.05,32.47 139.13,32.39 139.34,32.39 139.47,32.53 139.47,33.69 138.57,34.59 138.57,34.95 138.42,35.1 JDIMM2.53
DDR_B_DQS#5: length 47.5
  IN1 w0.076: 135.76,53.63 135.76,53.64 135.74,53.67 135.74,54.33 133.78,56.28 133.78,60.43 133.61,60.6 133.32,60.6 v2(133.07,60.85)
  IN1 w0.124: v2(143.75,31.96) 143.47,31.68 143.3,31.68 143.17,31.8 143.17,33.49 143.49,33.81 143.49,37.45 143.15,37.8 143.15,38.44 140.94,40.64 140.94,41.91 135.76,47.09 135.76,53.63
  BOTTOM w0.076: v2(133.07,60.85) 132.9,60.67 132.31,60.67 132.23,60.75 132.23,63.99 131.97,64.25 131.97,65.59 131.76,65.8 131.76,66.09 131.82,66.2 131.82,66.42 131.76,66.53 131.76,66.74 131.8,66.82 131.8,67.1 131.75,67.21 131.67,67.35 131.54,67.4 131.48,67.4 131.46,67.42 UC1.AY26
  BOTTOM w0.112: v2(143.75,31.96) 143.53,31.73 143.3,31.73 143.05,31.49 143.05,29.85 143.83,29.08 143.83,28.83 143.67,28.68 JDIMM2.74
DDR_B_DQS#6: length 81.8
  IN3 w0.076: 137.29,62.63 137.22,62.63 137.21,62.64 136.17,62.64 136.08,62.55 135.22,62.55 135.02,62.76 135.02,63.76 133.79,64.98 133.79,65.35 132.9,66.24 132.01,66.24 130.76,67.49 130.76,68 130.12,68.65 130.12,70.14 130.19,70.21 130.43,70.21 130.51,70.14 v2(130.51,70.04)
  IN3 w0.124: v2(182.41,33.07) 182.41,32.93 182.23,32.75 182.05,32.75 181.93,32.87 181.93,39.53 180.41,41.05 180.41,44.44 174.97,49.88 174.97,50.49 167.25,58.2 164.86,58.2 164.14,58.92 152.39,58.92 150.61,60.71 145.85,60.71 145.3,61.26 143.79,61.26 143.31,61.74 141.98,61.74 141.1,62.63 137.29,62.63
  BOTTOM w0.076: UC1.AR25 v2(130.51,70.04)
  BOTTOM w0.112: JDIMM2.219 181.92,35.25 182.08,35.1 182.08,34.77 182.76,34.09 182.76,34.09 182.85,33.99 182.85,32.93 182.67,32.74 182.51,32.74 182.41,32.84 v2(182.41,33.07)
DDR_B_DQS#7: length 87.7
  IN3 w0.076: v2(133.25,70.04) 133.25,70.19 133.18,70.26 132.95,70.26 132.87,70.19 132.87,68.63 134.34,67.16 134.35,67.16
  IN3 w0.112: 135.4,67.16 135.42,67.16 135.43,67.16 135.49,67.16 135.5,67.15 135.92,67.15 136.3,66.77 138.67,66.77 138.8,66.9 143.98,66.9
  IN3 w0.124: 135.4,67.16 135.36,67.16 135.35,67.17 135.32,67.17 135.31,67.16 134.35,67.16 ; 143.98,66.9 144,66.9 145.33,65.58 147.47,65.58 148.49,64.56 152.11,64.56 153.96,62.71 157.5,62.71 158.86,64.07 161.96,64.07 162.21,63.82 162.21,63.54 162.33,63.41 162.71,63.41 162.83,63.54 162.83,63.82 163.08,64.07 163.63,64.07 163.88,63.82 163.88,63.54 164.01,63.41 164.38,63.41 164.5,63.54 164.5,63.82 164.75,64.07 165.37,64.07 165.97,63.47 167.48,63.47 184.2,46.74 184.2,42.8 186.45,40.56 186.45,38.69 186.69,38.45 186.69,35.19 187.21,34.67 187.21,31.55 187.53,31.23 187.7,31.23 187.83,31.36 v2(187.83,31.55)
  BOTTOM w0.076: v2(133.25,70.04) 132.89,70.4 UC1.AR22
  BOTTOM w0.112: v2(187.83,31.55) 187.83,31.33 187.67,31.17 187.44,31.17 187.2,30.93 187.2,29.41 187.32,29.29 187.32,28.9 187.18,28.76 JDIMM2.240
DDR_B_MA0: length 84.6
  IN3 w0.076: 119.61,54.43 119.61,55.1 119.06,55.64 119.06,62.13 v2(119.69,62.75)
  IN3 w0.183: 119.61,54.43 119.61,50.11 125.73,43.98 145.06,43.98 145.87,43.17 148.49,43.17 149.38,42.28 155.44,42.28 157.85,39.86 159.13,39.86 162.43,36.56 162.43,32.8 161.89,32.26 161.89,28.15 161.71,27.97 161.18,27.97 161,28.15 161,30.01 v2(161.45,30.46)
  BOTTOM w0.076: UC1.BA46 119.74,66.42 120,66.15 120,64.98 119.91,64.88 119.91,62.97 v2(119.69,62.75)
  BOTTOM w0.183: JDIMM2.144 161.17,28.74 161.36,28.93 161.67,28.93 161.86,28.74 161.86,27.91 162.04,27.72 162.43,27.72 162.61,27.91 162.61,29.68 162.43,29.87 161.88,29.87 161.45,30.29 v2(161.45,30.46)
DDR_B_MA1: length 85.7
  IN3 w0.076: v2(117.38,59.16) 117.38,59.27 117.29,59.35 116.98,59.35 116.82,59.19 116.82,55.03 116.43,54.63 116.43,54.43
  IN3 w0.183: 116.43,54.43 116.43,48.78 121.96,43.25 121.96,42.99 121.08,42.1 121.08,41.85 121.32,41.6 121.58,41.6 122.42,42.43 122.77,42.43 122.98,42.23 122.98,41.97 122.09,41.09 122.09,40.83 122.32,40.6 122.64,40.6 123.49,41.46 123.75,41.46 124.03,41.17 124.03,41 123.65,40.61 123.65,40.36 123.86,40.14 124.12,40.14 124.78,40.8 143.74,40.8 144.55,39.99 147.06,39.99 147.96,39.09 154.12,39.09 158.26,34.95 158.26,33.68 158.45,33.49 v2(158.69,33.49)
  BOTTOM w0.076: v2(117.38,59.16) 117.38,59.01 117.73,58.65 119.02,58.65 119.09,58.73 119.09,58.91 119.02,58.99 117.81,58.99 117.73,59.07 117.73,59.25 117.81,59.32 119.02,59.32 119.09,59.4 119.09,59.56 119.02,59.63 118.5,59.63 118.41,59.72 118.41,59.85 118.5,59.94 119.02,59.94 119.09,60.02 119.09,63.17 119.57,63.66 119.57,65.04 119.67,65.14 119.67,65.63 119.47,65.83 119.47,66.09 119.53,66.21 119.53,66.35 119.46,66.58 119.46,66.71 119.54,66.93 119.64,67.03 UC1.AY46
  BOTTOM w0.183: JDIMM2.133 158.42,35.16 158.11,34.84 158.11,33.72 158.34,33.49 v2(158.69,33.49)
