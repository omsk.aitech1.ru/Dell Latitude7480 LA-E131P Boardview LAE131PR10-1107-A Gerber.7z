# Allegro board LAE131PR10-1107-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA2: length 85.2
  IN3 w0.076: v2(117.38,59.71) 116.9,59.71 116.63,59.45 116.63,55.31 115.96,54.64 115.96,54.43
  IN3 w0.183: 115.96,54.43 115.96,48.59 121.31,43.25 121.31,42.99 120.54,42.22 120.54,41.73 122.67,39.6 125.28,39.6 126.02,40.34 143.55,40.34 144.36,39.53 146.87,39.53 147.77,38.63 153.92,38.63 157.79,34.76 157.79,33.36 157.81,33.34 157.81,29.5 158,29.32 158.39,29.32 158.57,29.13 158.57,28.04 158.75,27.86 159.05,27.86 159.26,28.07 159.26,29.79 158.69,30.36 v2(158.69,30.44)
  BOTTOM w0.076: UC1.AY47 119.34,67.31 119.34,66.88 119.29,66.72 119.29,66.58 119.35,66.36 119.35,66.24 119.32,66.16 119.31,66.13 119.31,65.76 119.51,65.56 119.51,65.22 119.41,65.12 119.41,63.88 118.87,63.35 118.87,60.55 118.04,59.71 v2(117.38,59.71)
  BOTTOM w0.183: JDIMM2.132 158.17,30.27 158.35,30.44 v2(158.69,30.44)
DDR_B_MA3: length 84.9
  IN3 w0.076: 116.89,54.43 116.89,54.49 116.98,54.59 116.98,57.73 117.06,57.8 v2(117.32,57.8)
  IN3 w0.183: v2(158.69,31.96) 158.95,31.96 159.13,32.14 159.13,34.73 159.06,34.8 159.06,34.8 154.31,39.55 148.15,39.55 147.25,40.45 144.74,40.45 143.93,41.26 124.6,41.26 116.89,48.97 116.89,54.43
  BOTTOM w0.076: UC1.BB46 119.84,65.88 119.84,65.06 119.74,64.96 119.74,63.5 119.26,63.02 119.26,58.56 119.18,58.49 119.06,58.49 118.97,58.4 118.97,56.96 118.88,56.88 118.74,56.88 118.66,56.95 118.66,58.41 118.58,58.49 118.43,58.49 118.35,58.41 118.35,57.08 118.23,56.96 118.13,56.96 118.02,57.06 118.02,58.41 117.95,58.48 117.8,58.48 117.72,58.41 117.72,57.41 117.64,57.33 117.5,57.33 117.32,57.51 v2(117.32,57.8)
  BOTTOM w0.183: v2(158.69,31.96) 158.69,31.9 158.5,31.72 158.29,31.72 158.11,31.54 158.11,31.21 157.93,31.03 157.62,31.03 157.44,31.21 157.44,32.15 157.62,32.33 158.02,32.33 158.2,32.52 158.2,32.88 157.82,33.26 157.82,35.07 157.93,35.17 JDIMM2.131
DDR_B_MA4: length 84.2
  IN3 w0.076: 115.5,54.43 115.5,54.49 116.47,55.46 116.47,59.58 116.82,59.93 116.82,60.46 v2(117.3,60.94)
  IN3 w0.183: 115.5,54.43 115.5,48.4 120.56,43.34 120.56,42.89 119.77,42.1 119.77,41.85 122.48,39.13 125.47,39.13 126.21,39.87 143.36,39.87 144.17,39.06 146.64,39.06 147.95,37.76 154.14,37.76 157.33,34.57 157.33,33.14 157.34,33.13 157.34,29.11 157.16,28.93 156.62,28.93 156.44,29.11 156.44,29.87 156.86,30.29 v2(156.86,30.46)
  BOTTOM w0.076: UC1.BA47 118.85,66.74 118.85,66.51 118.85,66.5 118.84,66.5 118.84,66.5 118.81,66.41 118.81,66.21 118.84,66.12 118.84,65.72 118.72,65.6 118.72,64.97 118.8,64.9 119.12,64.9 119.19,64.82 119.19,64.67 119.12,64.59 118.8,64.59 118.72,64.52 118.72,64.36 118.8,64.29 119.12,64.29 119.19,64.21 119.19,64.06 119.12,63.98 118.8,63.98 118.72,63.91 118.72,63.52 118.71,63.51 118.71,61.06 118.59,60.94 v2(117.3,60.94)
  BOTTOM w0.183: JDIMM2.128 157.17,29.24 157.69,29.75 157.69,30.31 157.32,30.68 157.08,30.68 v2(156.86,30.46)
DDR_B_MA5: length 86.7
  IN3 w0.076: 114.11,54.43 114.11,54.53 115.89,56.31 115.89,62.42 116.32,62.85 116.48,62.85 116.68,63.06 v2(117.38,63.06)
  IN3 w0.183: 114.11,54.43 114.11,47.82 117.33,44.61 117.33,43.93 116.71,43.31 116.71,42.95 121.91,37.75 126.42,37.75 126.6,37.93 126.6,37.94 126.78,38.12 127.08,38.12 127.08,38.13 127.43,38.13 127.44,38.12 128.04,38.12 128.22,37.94 128.22,37.93 128.41,37.75 128.77,37.75 128.96,37.93 128.96,38.3 129.14,38.49 130.12,38.49 130.3,38.3 130.3,37.94 130.5,37.75 131.01,37.75 131.19,37.93 131.19,38.3 131.38,38.49 131.93,38.49 132.08,38.33 132.08,37.89 132.23,37.75 132.69,37.75 132.87,37.93 132.87,38.29 133.07,38.49 133.59,38.49 133.8,38.28 133.8,37.98 133.85,37.93 133.85,37.88 133.98,37.75 134.38,37.75 134.56,37.93 134.56,38.28 134.77,38.49 135.44,38.49 135.63,38.3 135.63,37.93 135.81,37.75 136.14,37.75 136.36,37.96 136.36,38.3 136.54,38.49 137.12,38.49 137.3,38.3 137.3,37.93 137.49,37.75 137.85,37.75 138.04,37.93 138.04,38.3 138.22,38.49 138.59,38.49 138.78,38.3 138.78,37.93 138.96,37.75 139.32,37.75 139.51,37.93 139.51,38.3 139.69,38.49 140.74,38.49 140.92,38.3 140.92,37.94 141.12,37.75 141.47,37.75 141.66,37.93 141.66,38.3 141.84,38.49 142.79,38.49 143.07,38.21 143.07,37.81 143.13,37.75 143.14,37.75 143.62,37.27 144.11,37.27 144.21,37.37 145.02,37.37 145.25,37.14 146.07,37.14 146.84,36.37 153.57,36.37 155.5,34.43 155.5,32.15 v2(155.05,31.7)
  BOTTOM w0.076: v2(117.38,63.06) 117.94,63.62 117.94,63.98 118.12,64.17 118.12,67 UC1.AY48
  BOTTOM w0.183: JDIMM2.126 156.67,28.87 156.34,29.2 156.34,30.42 v2(155.05,31.7)
DDR_B_MA6: length 84
  IN3 w0.076: 115.04,54.43 115.04,54.45 116.3,55.7 116.3,61.87 116.37,61.95 117.3,61.95 117.38,61.87 v2(117.38,61.76)
  IN3 w0.183: v2(156.86,33.51) 156.64,33.51 156.43,33.72 156.43,34.82 153.95,37.3 147.22,37.3 145.91,38.6 143.98,38.6 143.17,39.41 126.4,39.41 125.66,38.67 122.29,38.67 119,41.96 119,42.22 119.88,43.1 119.88,43.36 119.62,43.62 119.37,43.62 118.48,42.74 118.22,42.74 117.96,43 117.96,43.26 118.85,44.14 118.85,44.4 115.04,48.21 115.04,54.43
  BOTTOM w0.076: UC1.BA48 118.44,66.67 118.57,66.67 118.64,66.59 118.64,66.18 118.68,66.09 118.68,65.79 118.56,65.66 118.56,63.59 118.54,63.58 118.54,63.29 118.47,63.22 118.01,63.22 117.93,63.14 117.93,62.95 118,62.87 118.46,62.87 118.54,62.78 118.54,62.64 118.46,62.55 117.82,62.55 117.73,62.47 117.73,62.3 117.83,62.2 118.47,62.2 118.54,62.13 118.54,61.98 118.45,61.89 117.85,61.89 117.78,61.81 117.78,61.64 117.85,61.56 118.47,61.56 118.54,61.49 118.54,61.29 118.46,61.2 117.59,61.2 117.38,61.42 v2(117.38,61.76)
  BOTTOM w0.183: JDIMM2.127 156.93,35.28 157.5,34.71 157.5,33.68 157.22,33.4 156.96,33.4 v2(156.86,33.51)
DDR_B_MA7: length 87.4
  IN3 w0.076: v2(117.71,70.67) 117.4,70.67 117.33,70.6 117.33,69.02 117.18,68.88 117.18,68.85 116.97,68.64 116.97,66.76 116.07,65.86 116.07,64.09 114.96,62.98 114.96,56.22 113.91,55.17 113.74,55.17 113.41,54.84
  IN3 w0.183: v2(155.05,30.18) 154.78,30.18 154.59,30 154.59,27.84 154.41,27.66 154.07,27.66 153.89,27.84 153.89,30.5 154.6,31.21 154.6,33.03 154.18,33.44 154.18,34.45 153.18,35.45 146.45,35.45 145.77,36.13 143.45,36.13 142.76,36.82 121.52,36.82 115.43,42.91 115.43,43.38 116.17,44.12 116.17,44.46 113.19,47.44 113.19,54.62 113.41,54.84
  BOTTOM w0.076: UC1.AP48 v2(117.71,70.67)
  BOTTOM w0.183: JDIMM2.122 155.67,29.56 v2(155.05,30.18)
DDR_B_MA8: length 82.7
  IN3 w0.076: 114.58,54.43 114.58,54.52 114.93,54.88 115.04,54.88 116.05,55.89 116.05,62.35 116.39,62.68 116.54,62.68 116.72,62.86 117.07,62.86 117.25,62.68 117.35,62.68 117.42,62.61 117.42,62.45 v2(117.38,62.41)
  IN3 w0.183: 114.58,54.43 114.58,48.02 118.08,44.51 118.08,44.03 117.45,43.4 117.45,42.86 122.1,38.21 125.85,38.21 126.59,38.95 142.98,38.95 143.79,38.14 145.72,38.14 147.03,36.83 153.76,36.83 155.97,34.63 155.97,33.41 156.15,33.23 156.27,33.23 156.44,33.06 156.44,32.77 156.27,32.6 156.1,32.6 155.97,32.47 155.97,31.65 155.49,31.17 155.49,30.34 155.68,30.15 155.99,30.15 156.21,30.37 156.21,31.17 156.86,31.82 v2(156.86,31.98)
  BOTTOM w0.076: v2(117.38,62.41) 117.38,62.57 117.47,62.67 117.59,62.67 117.67,62.74 117.67,62.84 117.73,62.91 117.73,63.18 118.12,63.57 118.12,63.94 118.2,64.01 118.31,64.01 118.39,64.09 118.39,65.97 UC1.BB48
  BOTTOM w0.183: JDIMM2.125 156.42,35.13 156.33,35.03 156.33,32.51 v2(156.86,31.98)
DDR_B_MA9: length 81.6
  IN3 w0.076: 113.65,54.43 115.72,56.5 115.72,62.48 116.25,63.01 116.41,63.01 116.81,63.41 117.55,63.41 117.64,63.51 117.64,66.7 118.49,67.56 118.49,68.34 118.14,68.7 118.14,71.25 118.06,71.33 v2(117.74,71.33)
  IN3 w0.183: v2(155.05,33.23) 154.64,33.64 154.64,34.64 153.38,35.91 146.65,35.91 145.96,36.59 144.99,36.59 144.7,36.88 144.42,36.88 144.13,36.59 143.64,36.59 142.95,37.29 121.71,37.29 115.98,43.02 115.98,43.28 116.87,44.16 116.87,44.42 113.65,47.63 113.65,54.43
  BOTTOM w0.076: v2(117.74,71.33) 117.47,71.05 UC1.AP50
  BOTTOM w0.183: v2(155.05,33.23) 155.23,33.05 155.68,33.05 155.86,33.24 155.86,34.73 155.42,35.16 JDIMM2.121
DDR_B_MA10: length 85.7
  IN3 w0.076: v2(120.04,60.52) 119.28,59.76 119.28,56.07 120.07,55.28 120.07,54.43
  IN3 w0.183: v2(163.41,30.46) 163.16,30.46 162.98,30.28 162.98,29.16 163.2,28.94 164.29,28.94 164.47,28.76 164.47,28.5 164.29,28.31 163.33,28.31 162.93,27.91 162.57,27.91 162.35,28.14 162.35,30.69 162.53,30.87 162.72,30.87 162.9,31.05 162.9,31.42 162.72,31.6 162.53,31.6 162.35,31.78 162.35,32.07 162.89,32.61 162.89,36.75 159.32,40.33 158.04,40.33 155.63,42.74 149.58,42.74 148.68,43.64 146.06,43.64 145.25,44.45 125.93,44.45 120.07,50.3 120.07,54.43
  BOTTOM w0.076: v2(120.04,60.52) 119.64,60.93 119.64,61.99 120.07,62.42 120.07,64.81 120.17,64.9 120.17,66.63 119.93,66.86 119.93,67.36 119.83,67.56 119.64,67.75 UC1.AW46
  BOTTOM w0.183: JDIMM2.146 163.68,29.12 163.97,29.42 163.97,29.81 163.41,30.38 v2(163.41,30.46)
DDR_B_MA11: length 88.6
  IN3 w0.076: v2(117.69,71.96) 117.28,71.96 117.16,71.84 117.16,69.1 116.75,68.68 116.75,67.03 116.56,66.85 115.99,66.85 115.79,66.64 115.79,64.04 114.79,63.05 114.79,56.29 114.13,55.63 113.54,55.63 113.41,55.5
  IN3 w0.183: v2(153.3,31.86) 153.3,31.67 153.5,31.46 153.95,31.46 154.13,31.65 154.13,32.84 153.72,33.25 153.72,34.26 152.99,34.98 146.26,34.98 145.58,35.67 143.26,35.67 142.96,35.97 142.57,36.36 121.33,36.36 114.67,43.02 114.67,43.28 115.55,44.15 115.55,44.41 115.29,44.67 115.03,44.67 114.16,43.79 113.9,43.79 113.65,44.04 113.65,44.3 114.45,45.11 114.45,45.53 112.73,47.25 112.73,54.81 113.41,55.5
  BOTTOM w0.076: UC1.AN48 118.14,71.68 117.8,71.68 117.69,71.78 v2(117.69,71.96)
  BOTTOM w0.183: JDIMM2.120 155.17,29.26 154.63,29.8 154.63,31.03 154.45,31.21 153.78,31.21 153.3,31.69 v2(153.3,31.86)
DDR_B_MA12: length 87.6
  IN3 w0.076: v2(116.78,71.34) 116.59,71.34 116.43,71.18 116.43,67.16 116.35,67.09 115.83,67.09 115.62,66.88 115.62,64.26 114.55,63.19 114.55,56.54 114.12,56.11 113.41,56.11
  IN3 w0.183: 113.41,56.11 113.37,56.11 112.26,55 112.26,47.06 112.83,46.49 112.83,46.14 112.25,45.56 112.25,45.31 112.5,45.05 112.76,45.05 113.36,45.65 113.65,45.65 113.84,45.47 113.84,45.15 112.99,44.3 112.99,44.04 121.14,35.9 142.38,35.9 143.07,35.21 145.39,35.21 146.07,34.52 152.58,34.52 152.71,34.4 152.71,33.66 152.99,33.38 v2(153.25,33.38)
  BOTTOM w0.076: UC1.AN50 117.14,71.7 v2(116.78,71.34)
  BOTTOM w0.183: v2(153.25,33.38) 153.4,33.23 153.74,33.23 153.92,33.05 153.92,31.89 154.14,31.67 154.45,31.67 154.63,31.86 154.63,33.68 154.45,33.87 153.9,33.87 153.68,34.09 153.68,34.42 153.86,34.6 154.74,34.6 154.93,34.78 JDIMM2.119
DDR_B_MA13: length 82.4
  IN3 w0.076: 123.3,54.43 123.3,55.93 122.52,56.72 122.52,57.51 121.11,58.92 121.11,60.55 121.74,61.18 v2(121.74,61.25)
  IN3 w0.183: 123.3,54.43 123.3,53.02 128.64,47.68 146.59,47.68 147.4,46.87 150.02,46.87 150.91,45.97 158.73,45.97 159.65,45.06 160.25,45.06 166.52,38.79 166.52,36.21 166.6,36.13 166.6,33.87 166.33,33.6 166.33,30.21 167.85,28.69 168.2,28.69 168.91,29.4 168.91,30.03 v2(169.25,30.37)
  BOTTOM w0.076: UC1.BA43 121.66,66.73 121.66,66.49 121.67,66.46 121.71,66.37 121.71,66.26 121.66,66.12 121.66,65.87 121.66,65.86 121.66,65.74 121.8,65.6 121.8,65.11 121.53,64.84 121.53,64.78 121.1,64.34 121.1,62.88 121.21,62.77 121.21,62.18 121.74,61.65 v2(121.74,61.25)
  BOTTOM w0.183: JDIMM2.158 166.68,28.87 167.05,29.24 167.36,29.24 168.49,30.37 v2(169.25,30.37)
DDR_B_MA14: length 86
  IN3 w0.076: v2(120.16,57.2) 120.16,57.41 120.24,57.48 121.41,57.48 121.73,57.16 121.73,54.7 121.46,54.43
  IN3 w0.183: 121.46,54.43 121.46,50.87 123.32,49.01 123.6,49.01 124.03,49.43 124.28,49.43 124.53,49.18 124.53,48.92 124.1,48.49 124.1,48.23 124.36,47.97 124.62,47.97 125.05,48.4 125.31,48.4 125.57,48.15 125.57,47.89 125.14,47.46 125.14,47.2 125.4,46.94 125.65,46.94 126.09,47.37 126.34,47.37 126.57,47.14 126.57,46.88 126.14,46.45 126.14,46.2 126.38,45.95 126.64,45.95 127.07,46.38 127.33,46.38 127.88,45.83 145.83,45.83 146.64,45.02 149.25,45.02 150.15,44.13 156.2,44.13 158.62,41.71 159.9,41.71 161.28,40.33 162.37,40.33 164.28,38.42 164.28,35.65 164.75,35.18 164.75,33.24 v2(165.25,32.74)
  BOTTOM w0.076: v2(120.16,57.2) 121.23,58.26 121.23,60.67 120.83,61.06 120.83,62.57 120.73,62.67 120.73,64.47 120.83,64.57 120.83,65.62 121.03,65.82 121.03,66.09 120.98,66.21 120.98,66.35 121.04,66.58 121.04,66.71 120.97,66.93 120.97,66.94 120.86,67.04 UC1.AY44
  BOTTOM w0.183: JDIMM2.151 164.92,35.23 165.23,34.93 165.23,34.86 165.94,34.16 165.94,32.76 166.84,31.86 166.84,31.6 166.61,31.37 166.32,31.37 165.67,32.02 165.67,32.32 v2(165.25,32.74)
DDR_B_MA15: length 86.5
  IN3 w0.076: v2(121.62,59.36) 122.81,58.17 122.81,56.83 123.77,55.87 123.77,54.95 124.29,54.43
  IN3 w0.183: v2(167.51,30.47) 167.06,30.93 167.06,36.32 166.98,36.4 166.98,38.98 160.44,45.52 159.84,45.52 158.92,46.43 151.11,46.43 150.21,47.33 147.59,47.33 146.78,48.14 132.18,48.14 131.83,48.48 131.83,49.64 131.71,49.77 131.32,49.77 131.13,49.59 131.13,48.32 130.95,48.14 130.58,48.14 130.4,48.32 130.4,49.59 130.2,49.79 129.81,49.79 129.68,49.66 129.68,48.32 129.5,48.14 129.19,48.14 128.95,48.38 128.95,49.73 128.82,49.85 128.34,49.85 128.22,49.73 128.22,49.53 127.99,49.3 127.67,49.3 127.47,49.5 127.47,50.12 124.99,52.61 124.99,52.9 125.31,53.22 125.31,53.41 124.99,53.72 124.81,53.72 124.27,53.18 123.97,53.18 123.77,53.39 123.77,53.72 124.29,54.25 124.29,54.43 124.29,54.43
  BOTTOM w0.076: UC1.AY43 121.24,67.32 121.24,67.22 121.16,67.06 121.16,66.88 121.21,66.72 121.21,66.58 121.15,66.36 121.15,66.24 121.2,66.13 121.2,65.75 121.01,65.57 121.01,64.49 120.9,64.37 120.9,62.81 121.02,62.69 121.02,61.15 121.47,60.7 121.47,59.44 121.55,59.36 v2(121.62,59.36)
  BOTTOM w0.183: JDIMM2.156 166.18,29.02 166.57,29.41 166.57,30.34 166.69,30.47 v2(167.51,30.47)
DDR_B_MA16: length 84.8
  IN3 w0.076: 122.84,54.43 122.84,55.75 122.29,56.3 122.29,57.51 120.94,58.85 120.94,61.47 120.52,61.9 v2(120.05,61.9)
  IN3 w0.183: 122.84,54.43 122.84,52.83 128.45,47.22 146.4,47.22 147.21,46.41 149.83,46.41 150.72,45.51 156.78,45.51 157.33,44.95 157.57,44.95 158.13,45.51 158.53,45.51 158.71,45.33 158.71,45.07 158.11,44.46 158.11,44.18 158.33,43.95 158.62,43.95 159.25,44.59 159.6,44.59 159.84,44.36 159.84,44.16 159.25,43.57 159.25,43.34 159.5,43.09 159.72,43.09 160.48,43.85 160.8,43.85 160.98,43.67 160.98,43.35 160.73,43.1 160.73,42.84 160.92,42.65 161.18,42.65 161.45,42.92 161.73,42.92 161.92,42.74 161.92,42.47 161.64,42.2 161.64,41.92 161.85,41.71 162.18,41.71 162.47,42 162.65,42 165.66,38.99 165.66,36.22 165.73,36.16 165.73,36.16 166.13,35.75 166.13,34.06 165.67,33.6 165.67,31.64 v2(165.25,31.22)
  BOTTOM w0.076: v2(120.05,61.9) 120.16,61.9 120.24,61.97 120.24,64.72 120.33,64.81 120.33,66.63 120.57,66.86 120.57,67.54 120.65,67.61 120.94,67.61 121.02,67.68 121.02,67.78 UC1.AW44
  BOTTOM w0.183: v2(165.25,31.22) 165.86,30.61 165.86,29.6 165.55,29.28 165.4,29.28 165.18,29.05 JDIMM2.152
DDR_B_ODT0: length 82.9
  IN3 w0.076: v2(121.45,64.18) 121.59,64.18 122.43,63.34 122.43,61.67 123.57,60.53 123.57,56.78 125.92,54.43
  IN3 w0.183: 125.92,54.43 126.46,53.89 126.46,52.86 128.15,51.17 128.52,51.17 129.22,51.87 129.59,51.87 130.54,50.92 134.24,50.92 134.45,50.71 134.45,49.55 134.63,49.37 135.01,49.37 135.19,49.55 135.19,50.02 135.38,50.21 135.86,50.21 136.04,50.03 136.04,49.55 136.22,49.37 136.59,49.37 136.77,49.55 136.77,50.03 136.96,50.21 138.57,50.21 138.75,50.03 138.75,49.48 138.93,49.29 139.31,49.29 139.49,49.48 139.49,50.03 139.68,50.21 141.03,50.21 141.22,50.03 141.22,49.48 141.4,49.29 147.26,49.29 148.07,48.48 150.69,48.48 151.58,47.59 159.4,47.59 160.32,46.67 161.38,46.67 165.92,42.14 166.37,42.14 168.66,39.86 168.66,37.99 168.14,37.47 168.14,36.87 168.21,36.8 168.21,36.44 168.4,36.25 168.4,32.88 v2(167.51,31.99)
  BOTTOM w0.076: UC1.BA42 122.09,66.42 121.87,66.2 121.83,66.09 121.83,65.89 121.83,65.88 121.83,65.8 121.96,65.67 121.96,65.04 121.83,64.9 121.83,64.08 121.72,63.98 121.55,63.98 121.45,64.07 v2(121.45,64.18)
  BOTTOM w0.183: v2(167.51,31.99) 167.51,32.16 166.63,33.04 166.63,34.44 165.92,35.15 JDIMM2.155
DDR_B_ODT1: length 82.8
  IN3 w0.076: 127.76,54.43 127.36,54.82 127.32,54.82 126.11,56.03 125.54,56.03 124.92,56.65 124.92,63.33 121.31,66.94 v2(121.31,68.72)
  IN3 w0.183: 127.76,54.43 127.76,54.43 127.76,54.17 126.92,53.33 126.92,53.05 127.16,52.81 127.44,52.81 128.28,53.65 128.54,53.65 128.79,53.39 128.79,53.13 127.98,52.32 127.98,52.07 128.25,51.8 128.5,51.8 129.31,52.62 129.57,52.62 130.79,51.39 135.89,51.39 136.61,50.67 141.22,50.67 141.5,50.4 142.58,50.4 143.23,49.76 147.45,49.76 148.26,48.95 150.88,48.95 151.64,48.18 159.62,48.18 160.67,47.13 161.58,47.13 166.11,42.6 166.57,42.6 169.12,40.05 169.12,36.35 169.87,35.6 169.87,33.22 169.68,33.04 169.43,33.04 169.25,33.22 v2(169.25,33.42)
  BOTTOM w0.076: UC1.AW42 122.09,68.21 121.57,68.73 121.32,68.73 v2(121.31,68.72)
  BOTTOM w0.183: v2(169.25,33.42) 168.58,34.08 168.58,34.29 167.84,35.03 167.78,35.03 167.43,35.39 JDIMM2.161
DDR_B_PARITY: length 89.8
  IN3 w0.076: 119.15,54.43 119.15,55.14 118.9,55.39 118.9,64.43 119.22,64.75 120.46,64.75 120.85,65.14 120.85,69.07 120.97,69.2 120.97,70.88 120.89,70.96 120.53,70.96 120.45,70.88 v2(120.45,70.67)
  IN3 w0.183: 119.15,54.43 119.15,49.92 125.54,43.52 144.87,43.52 145.68,42.71 148.19,42.71 149.09,41.81 155.24,41.81 157.66,39.4 158.94,39.4 161.97,36.37 161.97,33.67 161.8,33.51 v2(161.45,33.51)
  BOTTOM w0.076: UC1.AP43 v2(120.45,70.67)
  BOTTOM w0.183: v2(161.45,33.51) 161.01,33.51 160.83,33.69 160.83,34.51 161.01,34.69 161.74,34.69 162.27,35.22 162.27,37.92 162.4,38.04 162.44,38.04 162.63,38.22 162.63,38.89 162.44,39.07 161.13,39.07 160.95,38.89 160.95,37.67 161.53,37.1 161.53,35.44 161.34,35.26 161.1,35.26 160.93,35.43 JDIMM2.143
DDR_DRAMRST#: length 70.5
  TOP w0.112: v2(146.27,29.69) 146.27,28.43 145.99,28.15 139.41,28.15 138.94,28.62 137.31,28.62 137.14,28.8 136.13,28.8 135.8,28.47 RD11.2 135.8,27.82 135.71,27.73 RD12.2 ; v2(144.15,63.66) 144.15,63.15 143.42,62.42 143.42,57.79 143.28,57.65 143.28,56.09 142.72,55.54 v3(142.72,54.79) 142.72,54.32 143.9,53.15 146.84,53.15 148.13,51.86 148.13,49.95 147.43,49.24 143.14,49.24 v2(142.66,49.73)
  IN1 w0.076: v2(144.15,63.66) 144.03,63.66 143.51,64.18 142.85,64.18 142.15,64.87 142.15,65.17 141.46,65.87 141.46,65.88 140.49,66.85 139.29,66.85 137.61,68.53 137.61,69.04 137.82,69.26 v2(137.82,69.4)
  IN1 w0.119: v2(142.66,49.73) 142.28,49.36 142.28,44.32 146.87,39.73 146.87,38.96 147.07,38.76 147.07,37.24 146.87,37.04 146.87,30.63 146.27,30.03 v2(146.27,29.69)
  BOTTOM w0.076: UC1.AT13 138.17,69.75 v2(137.82,69.4)
DDR_DRAMRST#_R: length 95.7
  TOP w0.112: v2(135.84,25.76) 134.8,26.8 RD12.1 134.8,27.68 134.85,27.73 CD61.1 ; v2(70.63,27.46) 69.91,27.46 CD29.1
  IN1 w0.119: v2(152.59,26.5) 150.89,24.8 136.8,24.8 v2(135.84,25.76) 134.87,24.79 129,24.79 128.16,25.63 121.29,25.63 118.62,22.95 81.16,22.95 79.63,24.48 78.23,24.48 77.93,24.18 73.84,24.18 73.27,23.6 v2(73.22,23.6) 73.22,25.12 71.16,27.18 70.9,27.18 v2(70.63,27.46)
  BOTTOM w0.112: JDIMM2.108 152.17,26.61 152.29,26.5 v2(152.59,26.5) ; v2(73.22,23.6) 73.07,23.75 JDIMM1.108
DDR_VTT_CTRL: length 30.2
  BOTTOM w0.076: UC1.AW67 106.91,67.93 106.81,68.03 106.13,68.03 106.07,68.1 104.8,68.1 104.5,67.8 103.78,67.8 103.39,67.41 103.39,66.84 103.25,66.7 103.25,66.4 101.07,64.22
  BOTTOM w0.102: 101.07,64.22 100.57,63.72 100.57,62.39 99,60.82 v3(96.84,60.82) 95.94,60.82 91.51,65.25 87.7,65.25 86.36,63.91 86.36,62.35 85.97,61.96 UD1.2
DDR_XDP_WAN_SMBCLK: length 348.2
  TOP w0.112: QC2.1 150.17,81.54 150.33,81.37 150.62,81.37 151.03,81.78 151.03,82.45 v2(150.54,82.94) ; v2(189,26.56) 188.72,26.84 RC319.1
  IN1 w0.119: v2(57.55,111.68) 57.75,111.87 57.75,112.34 58.15,112.75 70.5,112.75 72.1,111.14 94.8,111.14 95.49,111.82 106.31,111.82 108.59,114.11 121.48,114.11 124.86,110.73 126.96,110.73 127.98,111.74 139.68,111.74 144.9,106.52 144.9,103.94 148.22,100.62 148.22,97.82 148.65,97.39 148.81,97.39 150.76,95.43 150.76,94.23 150.94,94.05 150.94,92.06 150.26,91.38 150.26,85.75 150.07,85.56 150.07,83.41 v2(150.54,82.94) ; v2(114.19,27.88) 114.19,27.87 116.49,25.58 119.74,25.58 120.66,26.5 128.64,26.5 129.27,25.87 134.43,25.87 135.05,26.5 136.58,26.5 137.2,25.87 149.55,25.87 152.57,28.89 160.79,28.89 161.13,29.23 166.61,29.23 167.51,28.33 176.2,28.33 177.19,27.33 182.85,27.33 183.28,26.9 188.66,26.9 v2(189,26.56) 189.23,26.33 190.15,26.33 190.66,25.83 192.05,25.83 192.83,26.61 192.83,30.06 193.86,31.1 194.49,31.1 194.98,31.59 194.98,32.09 195.28,32.39 196.05,32.39 v2(196.19,32.53)
  IN3 w0.135: v2(150.54,82.94) 150.54,83.02 150.93,83.41 152.02,83.41 153.16,82.26 154.27,82.26 154.92,82.91 162.69,82.91 162.82,83.04 163.01,83.04 163.71,82.34 166.73,82.34 169.35,79.72 169.35,78.27 168.68,77.6 168.68,75.86 167.41,74.59 167.41,73.76 169.87,71.3 170.44,71.3 172.18,69.56 172.18,68.84 172.9,68.12 172.9,64.56 182.18,55.28 182.62,55.28 184.98,52.92 184.98,52.89 191.5,46.37 191.5,46.3 198.11,39.69 198.11,38.24 201.32,35.04 201.32,34.92 201.96,34.28 202.73,34.28 203.33,33.68 203.33,33.37 203.2,33.23 v2(203.19,33.23)
  BOTTOM w0.112: v2(57.55,111.68) 57.73,111.5 57.73,111 60.34,108.38 61.13,108.38 62.93,106.58 62.93,105.3 64.24,104 70.21,104 71.05,103.16 73.16,103.16 73.39,102.93 73.39,102.72 73.21,102.54 JXDP1.53 ; JDIMM2.253 190.43,32.86 190.91,32.38 191.58,32.38 192.3,33.09 194.29,33.09 195.03,32.36 196.02,32.36 v2(196.19,32.53) 196.35,32.37 196.88,32.37 197.23,32.72 203.11,32.72 203.34,32.96 203.34,33.07 203.26,33.16 203.26,33.17 v2(203.19,33.23) ; v2(114.19,27.88) 114.02,27.72 113.51,27.72 112.3,28.94 111.84,28.94 111.32,29.45 JDIMM1.253
DDR_XDP_WAN_SMBDAT: length 350.4
  TOP w0.112: v2(147.34,83.02) 147.52,82.84 QC2.4 ; RC318.1 188.04,26.44 v2(188.41,26.44)
  IN1 w0.119: v2(196.19,31.95) 195.99,32.14 195.38,32.14 195.23,31.99 195.23,31.49 194.59,30.85 193.96,30.85 193.08,29.96 193.08,26.51 192.15,25.58 190.56,25.58 190.05,26.08 188.77,26.08 v2(188.41,26.44) 188.2,26.65 183.18,26.65 182.75,27.09 177.09,27.09 176.1,28.09 167.41,28.09 166.51,28.99 161.23,28.99 160.89,28.65 152.67,28.65 149.65,25.62 137.1,25.62 136.48,26.25 135.16,26.25 134.53,25.62 129.17,25.62 128.54,26.25 120.77,26.25 119.84,25.33 116.38,25.33 114.26,27.46 114.19,27.39 v2(114.19,27.3) ; v2(58.14,111.68) 58,111.82 58,112.24 58.25,112.5 70.4,112.5 72,110.9 94.91,110.9 95.59,111.58 106.41,111.58 108.69,113.86 121.38,113.86 124.76,110.48 127.07,110.48 128.08,111.49 139.58,111.49 144.65,106.42 144.65,103.84 147.97,100.52 147.97,97.72 148.54,97.14 148.7,97.14 150.52,95.33 150.52,94.12 150.7,93.95 150.7,92.16 150.02,91.48 150.02,85.86 149.82,85.66 149.82,84.58 148.78,83.54 148.09,83.54 147.57,83.02 v2(147.34,83.02)
  IN3 w0.135: v2(147.34,83.02) 147.34,83.2 147.63,83.48 150.52,83.48 150.71,83.67 152.12,83.67 153.27,82.52 154.16,82.52 154.82,83.18 162.58,83.18 162.71,83.3 163.12,83.3 163.82,82.6 166.84,82.6 169.61,79.83 169.61,78.16 168.94,77.49 168.94,75.75 167.67,74.48 167.67,73.87 169.97,71.57 170.54,71.57 172.44,69.67 172.44,68.95 173.16,68.23 173.16,64.67 182.29,55.54 182.73,55.54 185.24,53.03 185.24,53 191.76,46.48 191.76,46.41 198.38,39.8 198.38,38.35 201.58,35.14 201.58,35.03 202.07,34.55 202.84,34.55 203.6,33.79 203.6,33.37 v2(203.76,33.2)
  BOTTOM w0.112: v2(58.14,111.68) 58.13,111.68 57.97,111.51 57.97,111.1 60.44,108.62 61.23,108.62 63.17,106.68 63.17,105.4 64.34,104.23 70.31,104.23 71.15,103.4 73.26,103.4 73.63,103.03 73.63,102.72 73.81,102.54 JXDP1.51 ; JDIMM2.254 190.68,32.03 190.79,32.14 191.68,32.14 192.4,32.86 194.19,32.86 194.93,32.12 196.02,32.12 v2(196.19,31.95) 196.38,32.13 196.98,32.13 197.33,32.48 203.2,32.48 203.58,32.86 203.58,33.03 v2(203.76,33.2) ; JDIMM1.254 111.57,28.46 111.8,28.68 112.24,28.68 113.43,27.5 113.98,27.5 v2(114.19,27.3)
DEBUG_TX: length 4.6
  BOTTOM w0.102: JDEG1.9 299.01,74.37 v3(298.74,74.64) 297.75,75.63 RE74.2 296.7,75.63 296.48,75.42 RE30.2
DIMM1_SA0: length 7.9
  TOP w0.102: 112.08,29.01 v2(112.08,26.4) ; 112.08,29.01 v1(112.08,30.26) 112.08,31.01 113.24,32.16 RD4.2 ; 112.08,29.01 RD5.1
  BOTTOM w0.102: v2(112.08,26.4) 112.07,26.39 JDIMM1.256
DIMM1_SA1: length 7
  TOP w0.102: RD6.2 RD7.1 112.92,30.38 112.65,30.12 v3(112.65,27.02) v2(112.65,26.4)
  BOTTOM w0.102: JDIMM1.260 113.07,25.98 v2(112.65,26.4)
DIMM1_SA2: length 4
  TOP w0.102: RD9.1 RD8.2 90.15,23.91 v2(90.32,23.74) 90.32,23.51 v3(90.61,23.22)
  BOTTOM w0.102: v2(90.32,23.74) 89.92,23.74 89.57,24.08 JDIMM1.166
DIMM2_SA0: length 6.7
  TOP w0.102: RD21.1 RD20.2 190.57,28.26 v3(191.28,28.98) 191.58,29.28 191.58,29.37 v2(192.45,30.24)
  BOTTOM w0.102: v2(192.45,30.24) 192.45,29.88 191.18,28.61 JDIMM2.256
DIMM2_SA1: length 7.5
  TOP w0.102: v3(196.02,30.82) 195.62,30.42 v2(195.62,30.42) 195.44,30.24 RD22.2 195.44,28.89 RD23.1
  BOTTOM w0.102: v2(195.62,30.42) 193.27,30.42 192.18,29.32 JDIMM2.260
DIMM2_SA2: length 4.7
  TOP w0.102: v3(171.52,25.13) 171.44,25.2 171.07,25.2 RD24.2 170.45,25.83 RD25.1 169.21,26.29 v2(169.11,26.29)
  BOTTOM w0.102: JDIMM2.166 168.68,26.98 169.15,26.51 169.15,26.33 v2(169.11,26.29)
DISP_ON: length 9.8
  TOP w0.102: RV2.1 v2(66.92,115.9) 66.95,115.87 67.41,115.87 v1(67.85,115.43) 68.66,114.62 68.66,113.53 68.28,113.15 68.28,111.32 DV2.1
  BOTTOM w0.102: v2(66.92,115.9) 66.8,115.9 66.7,116 JEDP1.17
DMIC0: length 452.4
  TOP w0.112: v2(293.96,35.43) 294.34,35.05 294.62,35.05 295.09,34.58 RA52.2 295.53,34.22 UA1.2 ; v2(59.23,116.42) 58.99,116.19 CA6.1
  IN1 w0.119: v2(18.62,99.27) 18.62,97.35 18.16,96.89 18.16,96.36 19.05,95.47 19.05,94.96 20.17,93.85 24.88,93.85 25.78,92.94 25.78,91.23 24.76,90.2 24.76,86.07 23.51,84.82 21.62,84.82 21.19,84.39 21.19,82.14 21.07,82.02 21.07,80.95 19.28,79.17 17.88,79.17 v2(17.28,78.56)
  IN3 w0.135: v2(18.62,99.27) 18.75,99.27 19.48,98.54 24.54,98.54 25.4,99.4 26.53,99.4 27.97,100.83 27.97,103.26 29.11,104.4 29.11,107.51 31.45,109.84 34.7,109.84 35.22,110.36 41.51,110.36 41.84,110.7 43.69,110.7 46.55,113.56 52.08,113.56 53.83,115.31 55.62,115.31 57.25,116.93 58.71,116.93 v2(59.23,116.42) ; v2(17.28,78.56) 16.69,77.97 16.69,60.96 17.63,60.01 17.63,59.26 18.63,58.26 18.63,52.43 21.15,49.92 21.56,49.92 23.44,48.04 23.44,45.49 19.99,42.04 19.99,32.31 22.74,29.56 22.74,25.14 24.06,23.82 24.06,21.24 25.88,19.43 26.28,19.43 27.36,18.34 27.36,17.25 28.32,16.29 41.17,16.29 46.52,21.64 58.6,21.64 60.84,23.89 61.9,23.89 61.97,23.92 62.27,23.98 62.33,24.04 66.5,24.04 69.5,21.04 121.27,21.04 124.02,23.78 126.88,23.78 129.1,21.56 152.16,21.56 153.96,23.36 159.01,23.36 160.61,24.95 161.58,25.28 165.38,25.28 165.76,24.9 173.59,24.9 173.98,25.28 178.57,25.28 178.98,25.69 192.45,25.69 193.65,24.5 211.05,24.5 214.49,27.95 221.72,27.95 222.24,28.47 231.13,28.47 232.61,26.99 232.61,22.92 233.64,21.89 235.34,21.89 236.3,20.94 279.64,20.94 280.56,21.85 280.58,21.99 280.58,22.74 282.83,24.99 285.2,24.99 287.06,26.84 287.06,28.6 287.79,29.33 291.36,29.33 293.96,31.93 v2(293.96,35.43)
  BOTTOM w0.112: JEDP1.2 59.2,116.45 v2(59.23,116.42)
DMIC_CLK0: length 452.2
  TOP w0.112: RA14.1 CA54.1 293.33,34.15 v2(293.42,34.23) ; v2(60.2,116.23) 60.73,116.76 61.68,116.76 62.11,116.34 CA5.1
  IN1 w0.119: v2(17.29,77.2) 16.77,77.71 16.77,80.28 17.88,81.39 19.39,81.39 20.69,82.69 20.69,84.59 21.42,85.32 23.3,85.32 24.26,86.27 24.26,90.41 25.28,91.44 25.28,92.22 24.17,93.34 18.87,93.34 18.16,94.05 18.16,95.65 17.66,96.15 17.66,97.11 18.05,97.49 v2(18.05,99.28)
  IN3 w0.135: v2(60.2,116.23) 60.2,115.95 59.64,115.4 56.44,115.4 55.83,114.79 54.05,114.79 51.57,112.31 46.03,112.31 43.91,110.19 42.06,110.19 41.72,109.85 35.44,109.85 34.87,109.28 32.3,109.28 31.96,108.94 31.49,108.94 29.63,107.07 29.63,104.19 28.49,103.05 28.49,100.62 26.75,98.88 25.61,98.88 24.75,98.02 19.12,98.02 18.19,98.94 18.19,99.13 v2(18.05,99.28) ; v2(17.29,77.2) 17.2,77.11 17.2,61.17 18.15,60.23 18.15,59.57 19.15,58.57 19.15,52.65 21.36,50.44 21.77,50.44 23.95,48.25 23.95,45.28 20.5,41.83 20.5,32.52 23.31,29.72 23.31,25.3 23.59,25.01 24.57,24.03 24.57,21.46 26.09,19.94 26.49,19.94 27.87,18.56 27.87,17.47 28.53,16.81 40.96,16.81 46.31,22.16 58.38,22.16 60.48,24.26 60.63,24.4 61.8,24.4 61.82,24.42 62.02,24.45 62.12,24.56 67.34,24.56 70.35,21.55 121.06,21.55 123.8,24.3 127.09,24.3 129.31,22.07 151.95,22.07 153.74,23.87 154.17,23.87 158.8,23.87 160.33,25.4 161.5,25.79 165.59,25.79 165.98,25.41 173.38,25.41 173.76,25.79 177.99,25.79 179.44,27.24 191.63,27.24 193.62,25.26 200.23,25.26 201.04,26.07 206.55,26.07 208.56,28.08 213.9,28.08 214.28,28.46 221.5,28.46 222.02,28.98 231.35,28.98 233.22,27.1 233.22,23.96 234.15,23.04 235.81,23.04 237.19,21.65 242.06,21.65 242.66,22.25 243.24,22.25 244.04,21.45 279.42,21.45 280.07,22.09 280.07,22.96 280.37,23.26 282.61,25.5 284.95,25.5 286.54,27.1 286.54,28.93 287.45,29.84 288.99,29.84 289.74,30.6 291.9,30.6 293.42,32.12 v2(293.42,34.23)
  BOTTOM w0.112: JEDP1.4 v2(60.2,116.23)
DMIC_CLK_CODEC: length 2.2
  TOP w0.112: RA14.2 296.1,33.62 v3(296.13,33.65) 296.3,33.82 UA1.3
DPSNK0_DDC_CLK: length 10.3
  TOP w0.102: RT126.1 37.7,78.68 RT341.2 ; RT126.1 RT14.1 ; RT126.1 37.06,80.18 v2(36.48,80.18) ; UT1.Y5 v2(32.51,83.55)
  IN2 w0.102: v2(32.51,83.55) 33.23,82.83 33.23,81.22 34.06,80.38 34.9,80.38 35.44,79.85 36.15,79.85 v2(36.48,80.18)
DPSNK0_DDC_DATA: length 12.4
  TOP w0.102: UT1.R4 v2(29.91,82.91)
  IN2 w0.102: v2(36.52,79.58) 35.42,79.58 34.82,80.18 33.66,80.18 32.01,81.83 30.41,81.83 29.91,82.33 v2(29.91,82.91)
  BOTTOM w0.102: v2(36.52,79.58) 36.51,79.58 36.51,79.01 v3(36.68,78.85) 37.25,78.85 37.43,78.67 RT342.2 37.7,78.68 RT127.1 RT15.1
DPSNK1_DDC_CLK: length 14.9
  TOP w0.076: UT1.Y8 32.58,84.79 31.49,84.79 31.21,85.07 v2(31.21,85.52)
  IN3 w0.102: v2(35.38,83.53) 35.38,83.86 32.61,86.64 32.08,86.64 31.47,87.24 31.09,87.24 30.69,86.84 30.69,86.05 v2(31.21,85.52)
  BOTTOM w0.102: RT336.1 38.35,82.14 RT128.1 36.98,82.14 36.68,82.44 36.68,83.43 v3(36.32,83.79) 35.64,83.79 v2(35.38,83.53)
DPSNK_RBIAS: length 2.6
  TOP w0.076: UT1.Y18 32.83,89.09 v2(32.52,89.41)
  BOTTOM w0.102: v2(32.52,89.41) 32.73,89.2 RT38.1 33.32,89.2 33.93,88.59 v3(34.34,88.59)
EC_FPM_EN: length 44.4
  TOP w0.102: 264.44,40.43 264.47,40.43 UE1.D6
  TOP w0.107: 264.44,40.43 v2(264.44,40.43)
  BOTTOM w0.102: v2(264.44,40.43) 264.01,40.85 261.33,40.85 259.43,38.94 258.51,38.94 257.76,38.19 257.76,37.78 258.47,37.07 258.47,35.6 259.59,34.47 259.59,33.47 259.65,33.41 259.65,32.73 259.38,32.45 258.61,32.45 258.09,31.93 258.09,31.1 258.61,30.57 258.61,29.41 259.43,28.59 259.43,28.08 260.52,26.99 260.52,26 260.02,25.49 259.07,25.49 258.84,25.27 v1(258.84,24.91) 258.84,24.83 259.09,24.59 262.07,24.59 263.77,22.89 265.81,22.89 266.1,23.17 271.8,23.17 273.15,24.52 JUSH1.5
EDP_AUXN: length 76.2
  TOP w0.104: v2(72.55,97) 72.79,96.75 73.18,96.75 73.28,96.85 73.28,97.59 73.59,97.89 73.59,102.45 75.06,103.92 v4(75.06,104.7) 75.06,106.13 75.06,106.13 75.06,106.61 75.06,106.61 75.06,107 73.51,108.55 73.51,110.45 CV1.1
  IN1 w0.076: v2(119.56,86.11) 119.56,85.95 119.4,85.79 119.26,85.79 119.19,85.86 119.19,92.5 119.24,92.54
  IN1 w0.119: v2(72.55,97) 73.33,97 73.87,96.46 75.21,96.46 77.04,94.62 83.66,94.62 84,94.97 91.48,94.97 92.23,95.72 97.43,95.72 97.87,95.28 104.36,95.28 104.64,95.56 108,95.56 108.7,96.26 109.59,96.26 109.81,96.05 110.48,96.05 111.18,95.34 111.83,95.34 112.34,94.83 114.94,94.83 115.26,95.16 118.55,95.16 119.24,94.47 119.24,92.54
  BOTTOM w0.076: v2(119.56,86.11) 119.56,86.11 UC1.E45
EDP_AUXN_C: length 6.2
  TOP w0.104: v2(72.35,114.88) 72.49,114.74 v4(72.49,114.22) 72.49,114.03 73.27,113.26 73.27,112.82 73.27,112.82 73.27,112.35 CV1.2
  BOTTOM w0.104: v2(72.35,114.88) 72.51,115.03 72.51,115.3 72.79,115.59 72.79,116.09 72.7,116.18 JEDP1.29
EDP_AUXP: length 76.2
  TOP w0.104: CV2.1 73.71,110.99 73.71,108.63 75.26,107.08 v4(75.26,106.37) 75.26,104.95 75.27,104.94 75.27,104.47 75.26,104.46 75.26,103.84 73.79,102.37 73.79,97.81 73.48,97.5 73.48,96.77 73.26,96.55 72.68,96.55 v2(72.55,96.41)
  IN1 w0.076: 119.02,92.6 119.02,85.78 119.18,85.62 119.42,85.62 v2(119.56,85.47)
  IN1 w0.119: v2(72.55,96.41) 72.55,96.45 72.88,96.78 73.24,96.78 73.78,96.24 75.12,96.24 76.95,94.41 83.75,94.41 84.09,94.75 91.57,94.75 92.32,95.5 97.34,95.5 97.78,95.06 104.45,95.06 104.73,95.34 108.1,95.34 108.8,96.04 109.5,96.04 109.72,95.83 110.39,95.83 111.09,95.13 111.73,95.13 112.25,94.61 115.03,94.61 115.35,94.94 118.46,94.94 119.02,94.37 119.02,92.6
  BOTTOM w0.076: v2(119.56,85.47) UC1.F45
EDP_AUXP_C: length 6.3
  TOP w0.104: v2(72.94,114.88) 72.7,114.64 72.7,114.11 73.47,113.34 v4(73.47,113.09) 73.47,112.3 CV2.2
  BOTTOM w0.104: JEDP1.30 73.2,116.21 73,116 73,115.51 72.71,115.22 72.71,115.1 v2(72.94,114.88)
EDP_BIA_PWM: length 106.2
  TOP w0.102: DV1.3 65.79,110.86 65.79,108.5 66.44,107.85 67.19,107.85 68.35,106.69 68.35,103.48 67.21,102.34 67.21,98.37 v2(67.13,98.29)
  IN1 w0.076: 121.6,87.8 121.6,85.33 121.77,85.16 121.77,84.61 122.28,84.1 127.64,84.1 128.15,83.59 128.15,83.59 128.59,83.15 128.59,79.8 129.03,79.36 130.05,79.36 130.06,79.35 131.78,79.35 132.76,80.34 133.89,80.34 134.39,79.83 134.68,79.83 134.94,79.57 135.56,79.57 136.27,78.87 137.96,78.87 139.23,80.14 v2(139.23,80.18)
  IN1 w0.102: v2(67.13,98.29) 68.21,97.21 71.69,97.21 72.16,97.68 73.4,97.68 73.64,97.45 91.23,97.45 91.51,97.73 106.24,97.73 106.46,97.73 107.02,98.29 111.71,98.29 112.02,97.98 112.04,97.98 112.93,97.08 114.62,97.08 115.14,97.61 118.83,97.61 121.6,94.83 121.6,87.8
  BOTTOM w0.076: v2(139.23,80.18) 139.53,80.48 UC1.R11
EDP_COMP: length 2.3
  TOP w0.254: v2(115.88,85.49) 115.75,85.49 115.43,85.17 115.43,84.6 115.33,84.51 RC2.1
  BOTTOM w0.254: UC1.E52 116.28,85.89 v2(115.88,85.49)
EDP_HPD: length 110.8
  TOP w0.102: RC1.1 140.5,81.24 v2(140.5,82.18) ; v2(68.41,98.29) 68.43,98.32 68.43,101.85 68.95,102.36 68.95,108.06 68.76,108.25 68.76,113.12 69.05,113.42 69.05,114.96 68.33,115.69 v2(68.33,115.87) 68.43,115.97 68.43,116.55 RV7.1
  IN1 w0.076: 128.48,84.57 129.07,83.98 130.83,83.98 132.28,82.53 132.28,80.95 132.55,80.68 133.94,80.68 134.12,80.86 134.12,81.33 134.27,81.48 135.45,81.48 136.34,82.37 138.03,82.37 138.22,82.56 140.13,82.56 v2(140.5,82.18)
  IN1 w0.102: v2(68.41,98.29) 69.16,98.29 69.6,97.85 71.37,97.85 71.81,98.29 73.66,98.29 74.09,97.85 91.06,97.85 91.21,98.01 91.34,98.13 106.26,98.13 106.82,98.69 112.09,98.69 112.55,98.23 114.72,98.23 114.89,98.06 118.94,98.06 122.01,95 122.01,89.18 124.88,86.3 125.95,86.3 126.98,85.27 126.99,85.27 127.2,85.06 127.99,85.06 128.48,84.57
  BOTTOM w0.076: UC1.L10 v2(140.5,82.18)
  BOTTOM w0.102: JEDP1.21 68.7,116.8 68.48,116.58 68.48,116.02 v2(68.33,115.87) ; v2(68.41,98.29) 68.41,98.1 v3(69.11,97.39)
EDP_TXN0: length 68
  TOP w0.104: CV4.1 74.88,108.96 74.88,108.55 75.97,107.46 75.97,103.58 74.82,102.42 74.82,101.05 74.82,101.05 74.82,100.56 74.82,100.56 74.82,98.13 75.36,97.58 75.36,94.19 v2(75.53,94.02)
  IN1 w0.119: v2(75.53,94.02) 75.17,94.38 75.17,94.56 75.3,94.68 75.66,94.68 76.69,93.65 84.01,93.65 84.36,94 91.84,94 92.62,94.78 97,94.78 97.45,94.33 104.79,94.33 105.09,94.62 108.31,94.62 110.51,94.62 110.85,94.29 111.15,94.29 111.17,94.28 111.19,94.28 111.58,93.89 114.42,93.89 115.57,92.74 116.49,92.74 117.3,91.93 117.62,91.93 117.94,91.62 v2(117.94,91.5)
  BOTTOM w0.076: UC1.C47 118.83,87.83 118.83,91.47 118.55,91.75 118.19,91.75 v2(117.94,91.5)
EDP_TXN0_C: length 7.9
  TOP w0.104: v2(74.18,114.88) 73.99,114.69 73.99,114.25 74.84,113.39 v4(74.84,112.51) 74.84,110.52 CV4.2
  BOTTOM w0.104: v2(74.18,114.88) 74.04,115.01 74.04,115.95 74.2,116.11 JEDP1.32
EDP_TXN1: length 75.1
  TOP w0.104: CV6.1 76.33,110.8 76.33,110.18 77,109.5 77,103.64 75.5,102.14 75.5,101.33 75.5,101.33 75.5,100.28 75.5,100.28 75.5,98.65 77.35,96.81 77.35,95.15 v2(77.39,95.1)
  IN1 w0.119: v2(77.39,95.1) 77.09,95.41 77.09,95.7 76.92,95.87 76.92,96.09 77.56,96.73 91.51,96.73 91.8,97.02 101.62,97.02 101.73,96.9 107.48,96.9 108.16,97.58 110.05,97.58 110.36,97.27 111.75,97.27 112.64,96.37 115.97,96.37 116.36,96.76 118.66,96.76 120.89,94.53 120.89,90.69 120.82,90.61 120.65,90.61 120.55,90.71 120.5,90.71 120.36,90.84 v2(120.36,91.12)
  BOTTOM w0.076: UC1.D46 119.29,87.16 119.29,87.33 119.57,87.61 119.87,87.61 119.96,87.88 119.96,88.07 119.92,88.16 119.92,88.41 119.96,88.51 119.96,88.77 119.74,88.98 119.74,90.61 119.97,90.84 120.21,90.84 120.36,90.99 v2(120.36,91.12)
EDP_TXN1_C: length 6.3
  TOP w0.104: v2(75.46,115.03) 75.27,114.84 75.27,113.96 v4(75.96,113.27) 76.22,113.01 76.22,112.33 CV6.2
  BOTTOM w0.104: JEDP1.34 75.2,116.71 75.05,116.56 75.05,115.83 75.25,115.63 75.25,115.24 v2(75.46,115.03)
EDP_TXN2: length 70
  TOP w0.104: v2(78.6,95.18) 78.48,95.31 78.45,95.31 78.35,95.42 78.35,96.82 76.19,98.98 76.19,99.99 76.19,100 76.19,101.62 76.19,101.62 76.19,101.78 78.36,103.95 78.36,107.35 78.39,107.38 78.39,107.95 78.36,107.98 78.36,110.52 CV8.1
  IN1 w0.119: v2(120.37,92.28) 120.37,92.49 119.67,93.19 119.67,94.74 118.75,95.66 112.34,95.66 111.45,96.55 110.06,96.55 109.75,96.86 108.45,96.86 107.74,96.14 101.45,96.14 101.3,96.3 92.1,96.3 91.72,95.92 83.31,95.92 82.6,95.22 79.32,95.22 78.95,95.59 78.56,95.59 78.44,95.47 78.44,95.35 v2(78.6,95.18)
  BOTTOM w0.076: UC1.A45 119.69,88.49 119.56,88.36 119.42,88.36 119.34,88.43 119.34,92.1 119.92,92.68 120.45,92.68 120.52,92.6 120.52,92.44 v2(120.37,92.28)
EDP_TXN2_C: length 7.2
  TOP w0.104: CV8.2 78.36,112.12 78.36,112.76 v4(78.03,113.1) 77.7,113.43 77.19,113.43 76.69,113.92 76.69,114.37 v2(76.85,114.52)
  BOTTOM w0.104: v2(76.85,114.52) 76.72,114.65 76.72,115.05 76.05,115.72 76.05,116.67 76.2,116.82 JEDP1.36
EDP_TXN3: length 66
  TOP w0.104: CV10.1 80.65,111.85 80.33,111.54 80.33,110.78 80.71,110.4 80.71,105.1 76.87,101.26 76.87,99.26 79.03,97.1 79.03,97.05 79.04,97.05 79.04,95.87 79.38,95.53 79.38,94.81 80.52,93.67 80.52,93.25 v2(80.77,93)
  IN1 w0.119: v2(117.95,90.38) 117.58,90.01 117.35,90.01 116.79,90.57 116.79,91.87 116.31,92.35 115.2,92.35 114.16,93.39 111.37,93.39 110.98,93.78 110.96,93.78 110.95,93.79 110.64,93.79 110.43,94 108.41,94 108.32,93.91 105.64,93.91 105.53,93.8 105.23,93.5 84.98,93.5 84.79,93.5 84.44,93.15 81.59,93.15 80.97,92.53 80.8,92.53 80.61,92.71 80.61,92.83 v2(80.77,93)
  BOTTOM w0.076: v2(117.95,90.38) 117.95,90.26 118.09,90.12 118.33,90.12 118.53,89.92 118.53,89.04 118.29,88.8 118.29,88.58 118.38,88.49 118.44,88.49 UC1.A47
EDP_TXN3_C: length 7.7
  TOP w0.104: CV10.2 80.35,113.11 80.35,113.6 79.88,114.07 79.72,114.07 79.69,114.1 79.12,114.1 79.09,114.07 78.17,114.07 77.93,114.32 77.93,114.67 v2(78.15,114.89)
  BOTTOM w0.104: v2(78.15,114.89) 77.98,115.05 77.98,115.35 77.64,115.69 77.15,115.69 77.05,115.79 77.05,116.61 77.2,116.76 JEDP1.38
EDP_TXP0: length 68
  TOP w0.104: CV3.1 74.68,108.88 74.68,108.47 75.77,107.37 75.77,103.67 74.61,102.51 74.61,100.97 74.62,100.96 74.62,100.65 74.61,100.65 74.61,98.05 75.16,97.5 75.16,94.23 v2(74.95,94.02)
  IN1 w0.119: v2(74.95,94.02) 74.95,94.65 75.21,94.9 75.75,94.9 76.78,93.87 83.92,93.87 84.27,94.22 91.75,94.22 92.52,95 97.09,95 97.54,94.55 104.7,94.55 105,94.84 108.22,94.84 110.61,94.84 110.94,94.51 111.25,94.51 111.26,94.5 111.28,94.5 111.67,94.11 114.51,94.11 115.66,92.96 116.58,92.96 117.39,92.15 v2(117.94,92.15)
  BOTTOM w0.076: v2(117.94,92.15) 118.17,91.92 118.62,91.92 119,91.54 119,87.76 UC1.C46
EDP_TXP0_C: length 8
  TOP w0.104: v2(73.59,114.88) 73.79,114.69 73.79,114.16 74.64,113.31 74.64,112.76 74.61,112.73 74.61,112.3 74.64,112.27 74.64,110.52 CV3.2
  BOTTOM w0.104: v2(73.59,114.88) 73.84,115.13 73.84,115.97 73.7,116.11 JEDP1.31
EDP_TXP1: length 75.2
  TOP w0.104: CV5.1 76.13,110.62 76.13,110.1 76.8,109.42 76.8,103.73 75.3,102.22 75.3,101.25 75.3,101.25 75.3,100.36 75.3,100.36 75.3,98.57 77.14,96.72 77.14,95.66 77.02,95.54 v2(76.7,95.54)
  IN1 w0.119: v2(76.7,95.54) 76.7,96.18 77.47,96.95 91.42,96.95 91.71,97.24 101.71,97.24 101.82,97.12 107.39,97.12 108.06,97.79 110.14,97.79 110.45,97.48 111.84,97.48 112.73,96.59 115.88,96.59 116.27,96.98 118.75,96.98 121.11,94.62 121.11,90.6 120.91,90.39 120.42,90.39 v2(120.36,90.34)
  BOTTOM w0.076: v2(120.36,90.34) 120.36,90.54 120.24,90.67 120.04,90.67 119.92,90.54 119.92,89.05 120.12,88.85 120.12,88.48 120.09,88.38 120.09,88.19 120.12,88.1 120.12,87.85 119.98,87.37 119.98,87.12 119.87,87 119.61,87 119.55,87.07 119.55,87.17 UC1.C45
EDP_TXP1_C: length 6.3
  TOP w0.104: v2(74.88,115.03) 75.07,114.84 75.07,113.87 75.59,113.36 75.59,113.31 76.02,112.88 76.02,112.3 CV5.2
  BOTTOM w0.104: JEDP1.33 74.7,116.72 74.85,116.57 74.85,115.75 75.05,115.55 75.05,115.2 v2(74.88,115.03)
EDP_TXP2: length 70
  TOP w0.104: v2(78.02,95.18) 78.15,95.31 78.15,96.74 75.99,98.9 75.99,100.08 75.99,100.08 75.99,101.53 75.99,101.53 75.99,101.86 78.16,104.03 v4(78.16,107.66) 78.16,110.52 CV7.1
  IN1 w0.119: v2(120.37,93.05) 120.12,93.05 119.89,93.28 119.89,94.83 118.84,95.87 112.43,95.87 111.54,96.77 110.15,96.77 109.84,97.08 108.36,97.08 107.65,96.36 101.55,96.36 101.39,96.51 92,96.51 91.63,96.14 83.4,96.14 83.22,96.14 82.51,95.44 79.41,95.44 79.04,95.81 78.47,95.81 78.22,95.56 78.22,95.39 v2(78.02,95.18)
  BOTTOM w0.076: v2(120.37,93.05) 120.37,92.93 120.29,92.85 119.85,92.85 119.17,92.17 119.17,88.36 119.34,88.18 119.47,88.18 UC1.B45
EDP_TXP2_C: length 7.3
  TOP w0.104: v2(76.27,114.52) 76.49,114.29 76.49,113.84 77.1,113.23 77.6,113.23 77.65,113.18 77.65,113.15 78.06,112.73 78.09,112.73 78.16,112.67 78.16,112.12 CV7.2
  BOTTOM w0.104: JEDP1.35 75.7,116.79 75.85,116.64 75.85,115.64 76.52,114.97 76.52,114.77 v2(76.27,114.52)
EDP_TXP3: length 66.1
  TOP w0.104: CV9.1 80.13,111.53 80.13,110.7 80.51,110.32 80.51,105.18 76.67,101.34 76.67,99.18 78.83,97.02 78.83,96.97 78.83,96.97 78.83,95.79 79.18,95.45 79.18,94.73 80.27,93.64 80.27,93.06 v2(80.2,93)
  IN1 w0.119: v2(80.2,93) 80.39,92.8 80.39,92.62 80.71,92.31 81.06,92.31 81.68,92.93 84.53,92.93 84.89,93.28 105.32,93.28 105.62,93.58 105.62,93.58 105.73,93.69 108.41,93.69 108.5,93.78 110.34,93.78 110.55,93.58 110.86,93.58 110.87,93.56 110.89,93.56 111.28,93.17 114.07,93.17 115.11,92.13 116.22,92.13 116.57,91.77 116.57,90.48 117.26,89.79 v2(117.95,89.79)
  BOTTOM w0.076: UC1.B47 118.56,88.06 118.12,88.51 118.12,88.87 118.36,89.11 118.36,89.85 118.26,89.95 118.1,89.95 v2(117.95,89.79)
EDP_TXP3_C: length 7.7
  TOP w0.104: CV9.2 80.15,113.11 80.15,113.52 79.8,113.87 v4(79.4,113.87) 78.09,113.87 77.73,114.24 77.73,114.72 v2(77.56,114.89)
  BOTTOM w0.104: JEDP1.37 76.7,116.82 76.85,116.67 76.85,115.71 77.07,115.49 77.56,115.49 77.78,115.26 77.78,115.1 v2(77.56,114.89)
EDRAM_OPIO_RCOMP: length 1.3
  TOP w0.381: RC90.1 107.24,84.09 v2(107.34,84.19)
  BOTTOM w0.254: v2(107.34,84.19) 107.54,84 UC1.H66
EMMC_RCOMP: length 5.7
  BOTTOM w0.203: UC1.AT1 145.52,70.19 145.65,70.19 145.67,70.2 145.7,70.2 145.73,70.23 147.65,70.23 147.87,70.01 v3(148.54,70.01) 148.87,70.01 149.34,69.54 RC4.1
EN_0.6V: length 5.2
  TOP w0.102: PR212.1 v3(40.96,36.68)
  TOP w0.254: PR212.1 40.95,35.74 PC222.1 40.06,35.73 PR210.2 38.62,35.73 38.3,36.06 v2(37.96,36.06)
  BOTTOM w0.254: v2(37.96,36.06) 37.89,36.12 PU200.2
EN_1.0V_PRIM_COREP: length 4.9
  TOP w0.102: v3(177.57,114.46) v2(177.23,114.8)
  IN2 w0.381: v2(177.23,114.8) 177.23,113.62 176.96,113.35 175.15,113.35 v2(174.39,112.59)
EN_1.2V: length 5.7
  TOP w0.102: v2(37.63,36.9) 37.96,36.57 38.55,36.57 v3(38.68,36.7)
  TOP w0.254: PC221.1 PR209.1 39.07,38.61 PR208.2 38.86,37.74 38.13,37 37.73,37 v2(37.63,36.9)
  BOTTOM w0.254: PU200.1 37.31,36.57 v2(37.63,36.9)
EN_1.8VALW: length 0.8
  BOTTOM w0.102: v3(167.71,99.15) 167.39,99.47 167.01,99.47
EN_1VS_VCCIO: length 4.1
  IN2 w0.254: v2(187.24,107.96) 187.24,108.73 188.16,109.65 v2(189.23,109.65)
  BOTTOM w0.254: PU401.13 187.01,108.18 v2(187.24,107.96)
  vias: v3(188.98,110.47)
EN_2.5V: length 5.3
  TOP w0.102: 199.91,23.63 200.26,23.29 v3(201.77,23.29)
  TOP w0.254: PU503.5 199.14,22.2 199.44,21.9 PR514.1 199.94,22.29 199.9,22.33 PC513.1 199.91,22.82 PR513.2
EN_+1VALWP: length 7.8
  BOTTOM w0.102: PU301.1 186.46,98.78 186.57,98.67 186.57,98.14 187.07,97.63 188.75,97.63 v3(189.64,96.74) 191.1,96.74 191.53,96.31 PR312.1 191.53,95.31 PR302.1
EN_INVPWR: length 260.4
  TOP w0.102: v2(55.76,106.04) 55.76,105.59 QV2.2
  TOP w0.107: RE55.1 261.79,34.6 261.79,35.5 261.49,35.8 v2(261.49,36.29) 261.77,36.01 262.26,36.01 262.8,36.56 262.8,37.17 UE1.B2
  IN2 w0.102: v2(261.49,36.29) 261.46,36.25 261.28,36.25 259.93,37.6 258.03,37.6 257.44,38.19 257.28,38.19 256.63,38.84 252.98,38.84 251.85,39.96 251.47,39.96 248.61,42.81 237.39,42.81 237,43.2 232.27,43.2 231.63,43.85 222.54,43.85 221.42,44.97 209.04,44.97 207.94,44.97 198.07,54.84 197.56,54.84 192.09,60.31 191.42,60.31 190.28,61.44 190.28,62.14 185.23,67.19 185.23,68.44 183.62,70.05 182.69,70.05 182.5,69.87 182.22,69.87 180.75,71.34 180.75,74.12 178.02,76.85 176.34,76.85 173.67,79.51 173.67,80.96 172.47,82.17 172.47,86.68 171.92,87.22 171.92,90.52 172.42,91.02 172.42,93.67 170.87,95.22 168.11,95.22 166.56,96.77 164.68,96.77 163.22,98.23 161.74,98.23 161.46,98.51 160.26,98.51 158.39,100.38 158.39,101.58 148.54,111.44 127.24,111.44 125.6,109.8 121.89,109.8 120.19,108.1 120.19,108.1 119.31,107.22 105.7,107.22 105.25,107.66 101.54,107.66 101.09,108.12 97.56,108.12 97.2,107.75 93.42,107.75 92.56,108.62 77.87,108.62 76.92,109.57 63.02,109.57 59.56,106.1 59.56,105.53 58.82,104.79 58.13,104.79 56.55,106.37 56.09,106.37 v2(55.76,106.04)
EN_LCDPWR: length 4
  TOP w0.102: RV3.2 71.39,107.66 DV3.1 70.77,107.33 70.2,107.91 v3(70.14,107.91) 69.35,108.7 UV24.4
EN_PD_HV_1: length 86.2
  TOP w0.102: v2(35.56,98.77) 36.24,98.77 36.39,98.62 36.98,98.62 37.26,98.34 39,98.34 39.11,98.44 40.06,98.44 40.23,98.61 41.06,98.61 41.4,98.27 41.4,97.94 41.92,97.43 43.74,97.43 44.53,98.22 44.53,99.69 44.09,100.13 PQ1214.5 ; v2(36.88,70.69) 36.88,70.97 37.55,71.64 41.07,71.64 41.51,71.19 43.4,71.19 43.6,70.99 44.42,70.99 45.54,72.12 45.54,74.33 45.08,74.79 v2(44.97,74.79) ; RT70.1 v2(29.35,69.2) ; v2(35.33,93.47) 35.33,93.34 35.59,93.08 36.9,93.08 37.34,92.64 37.34,91.35 37.53,91.15 38.06,91.15 38.12,91.09 38.79,91.09 38.8,91.1 39.13,91.1 40.07,92.04 40.74,92.04 40.97,91.81 PR1260.1 ; v2(49.95,79.19) 49.95,80.19 49.71,80.43 PR1211.1 49.35,81.26 PR1210.1
  IN2 w0.102: v2(29.35,69.2) 32.93,69.2 33.45,68.67 34.87,68.67 v2(36.88,70.69) 38.05,71.85 38.05,73.26 38.77,73.98 38.77,77.69 39.27,78.19 39.51,78.19 40.06,78.73 40.06,81.48 39.42,82.11 39.42,82.31 36.04,85.69 36.04,90.62 35.24,91.42 35.24,93.38 v2(35.33,93.47) 35.33,98.55 v2(35.56,98.77)
  BOTTOM w0.102: PR1250.2 44.9,74.79 v2(44.97,74.79) 45.99,74.79 47.12,75.92 47.12,76.22 PR1254.1 47.35,76.9 v3(47.35,78) 48.54,79.19 v2(49.95,79.19)
EN_PD_HV_1#: length 3.8
  TOP w0.102: PQ1214.2 41.57,100.13 41.23,99.79 41.23,98.89 PR1253.2 41.94,98.43 PQ1214.3
EN_PD_HV_1_R: length 6.5
  TOP w0.076: UT5.C2 30.01,63.56 30.01,64.14 30.62,64.75 30.62,64.84
  TOP w0.112: 30.62,64.84 30.62,64.98 31.22,65.58 31.22,67.97 30.91,68.28 RT70.2
EN_VCC_EDRAM: length 5.5
  IN2 w0.254: v2(48.53,56.75) 47.91,57.37 v2(46.15,57.37)
  BOTTOM w0.102: v2(46.15,57.37) v3(43.26,57.37)
EN_VCC_EOPIO: length 5
  TOP w0.102: PR1315.2 44.92,45.47 44.92,45.66 44.57,46.02 43.26,46.02 v3(42.84,45.6)
  IN2 w0.254: v2(47.46,46.11) 47.36,46.11 v2(45.72,44.47)
ENLDO_3V5V: length 242.9
  IN2 w0.102: v2(235.98,24.55) 235.97,24.55 235.97,24.54 236.1,24.67 236.1,25.99 232.6,29.48 221.83,29.48 220.7,28.34 202,28.34 201.54,27.87 199.21,27.87 198.87,28.21 197.31,28.21 197.02,28.51 185.43,28.51 184.28,27.36 164.06,27.36 163.56,26.86 159.61,26.86 158.24,25.49 137,25.49 136.25,26.24 135.05,26.24 134.3,25.49 115.73,25.49 114.27,24.03 95.83,24.03 95.13,23.32 83.53,23.32 81.3,25.55 46.9,25.55 43.18,21.83 32.45,21.83 28.97,25.31 28.97,39.67 30.42,41.12 30.42,42.4 v2(30.05,42.77)
  BOTTOM w0.102: PU100.11 235.53,25.11 235.97,24.68 235.97,24.55 v2(235.98,24.55)
  BOTTOM w0.254: PR103.1 29.91,42.77 v2(30.05,42.77) 30.51,42.77 PR102.1 31.14,43.4 32.56,43.4 33.2,44.04 33.2,44.84 33.45,45.09 PU102.11
ENVDD_PCH: length 319.4
  TOP w0.102: DV3.3 72.14,105.43 72.42,105.71 v2(72.42,105.84)
  TOP w0.107: UE1.L12 270.82,45.99 271.29,45.99 271.64,46.34 271.64,46.7 271.8,46.86 v2(271.8,47.08)
  IN1 w0.076: 149.91,80.79 149.01,79.9 149.01,79.38 148.73,79.1 144.85,79.1 144.21,78.46 139.21,78.46 138.66,79.01 v2(138.65,79.01)
  IN1 w0.102: v2(142.74,109.63) 143.42,108.95 145.38,108.95 148.74,105.59 148.74,104.83 149.16,104.41 149.16,103.83 150.31,102.68 150.31,100.45 151.43,99.34 151.43,95.15 151.26,94.99 151.26,94.45 151.44,94.27 151.44,91.83 150.76,91.15 150.76,85.43 151.99,84.2 151.99,81.77 151.72,81.5 151.18,81.5 151.01,81.33 150.44,81.33 149.91,80.79
  IN2 w0.102: v2(271.8,47.08) 271.8,46.28 272.73,45.35 272.73,44.91 273.23,44.42 273.23,43.78 272.75,43.3 272.75,38.53 273.41,37.87 273.41,33.51 272.06,32.15 267.98,32.15 267.37,31.54 267.03,31.54 266.87,31.39 265.44,31.39 264.89,31.94 264.59,31.94 263.97,32.56 263.97,33.38 263.18,34.18 261.03,34.18 260.06,35.15 260.06,35.95 259.5,36.5 257.68,36.5 257.19,37 255.16,37 255.04,37.13 254.05,37.13 253.71,36.79 251.14,36.79 250.35,37.57 250.35,38.83 250.13,39.06 249.18,39.06 246.55,41.68 237.36,41.68 236.68,42.37 222.87,42.37 221.09,44.16 209.37,44.16 207.58,44.16 197.71,54.02 196.99,54.02 191.52,59.49 191.02,59.49 189.47,61.04 189.47,61.75 184.01,67.21 184.01,68.73 183.3,69.44 182.94,69.44 182.76,69.26 181.97,69.26 179.74,71.48 179.74,73.66 177.92,75.49 176.84,75.49 172.71,79.61 172.71,80.63 171.77,81.57 171.77,86.51 171.31,86.97 171.31,90.77 171.81,91.27 171.81,93.42 170.82,94.41 167.9,94.41 166.22,96.08 164.5,96.08 162.96,97.62 161.49,97.62 161.21,97.9 160.01,97.9 157.78,100.13 157.78,101.33 150.55,108.56 143.48,108.56 142.74,109.3 v2(142.74,109.63) 142.57,109.63 141.95,110.24 130.68,110.24 130.33,110.58 127.25,110.58 125.51,108.84 121.85,108.84 119.61,106.61 105.31,106.61 105.09,106.83 101.17,106.83 100.84,107.16 97.68,107.16 97.48,106.95 93.36,106.95 92.44,107.87 77.36,107.87 74.74,105.24 72.91,105.24 72.42,105.73 v2(72.42,105.84)
  BOTTOM w0.076: UC1.U13 138.23,79.43 138.65,79.02 v2(138.65,79.01)
EOPIO_RCOMP: length 2
  TOP w0.381: RC91.1 108.85,83.7 v2(108.36,84.19) 108.36,84.34 v1(107.99,84.72)
  BOTTOM w0.254: UC1.H65 108.55,84 v2(108.36,84.19)
ESPI_ALERT#: length 171.5
  TOP w0.112: UE1.H7 268.33,41.28 v2(268.42,41.28) ; v2(142.14,62.32) 142.11,62.29 RC21.1
  IN1 w0.119: v2(272.85,35) 272.43,35.42 272.43,35.65 271.88,36.2 270.88,36.2 270.53,35.85 268.72,35.85 267.88,36.69 258.17,36.69 257.42,35.94 257.06,35.94 256.29,35.17 252.69,35.17 252.54,35.32 251.14,35.32 250.86,35.04 249.46,35.04 248.39,33.97 241.55,33.97 240.38,35.14 239.66,35.14 239.35,34.83 237.59,34.83 237.28,35.14 236.35,35.14 236.15,35.14 235.82,35.47 231.43,35.47 231.23,35.47 230.23,36.47 229.26,36.47 229.26,36.47 218.06,36.47 217.7,36.11 217.7,36.11 217.07,35.48 214.96,35.48 206.18,35.48 206.04,35.62 205.91,35.75 205.91,35.75 205.55,36.11 204.11,37.55 203.09,37.55 201.82,38.81 201.43,38.81 199.82,38.81 197.04,41.6 196.43,41.6 189.92,48.11 189.14,48.11 188.63,48.62 172.74,48.62 171.28,50.09 164.42,50.09 163.95,49.61 156.72,49.61 152.62,53.71 152.62,53.98 145.62,60.98 143.49,60.98 v2(142.14,62.32)
  IN2 w0.124: v2(272.61,44.06) 272.28,43.73 272.28,39.79 271.81,39.32 271.81,36.04 v2(272.85,35)
  BOTTOM w0.076: v2(142.14,62.32) 142.47,62.66 142.47,63.14 141.78,63.83 140.12,63.83 138.96,64.98 138.96,66.72 139.07,66.83 UC1.AY11
  BOTTOM w0.112: v2(272.61,44.06) 272.57,44.02 270.62,44.02 270.44,43.84 270.44,42.66 269.97,42.19 269.64,42.19 268.73,41.28 v2(268.42,41.28)
