# Allegro board LAE131PR10-1107-A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.0V_VCCSTG_C on BOTTOM (solid shape): 131.79,101.31 131.79,101.3 131.79,98.9 131.6,98.71 130.08,98.71 129.99,98.8 129.99,101.25 130.22,101.48 131.61,101.48
+1.0VS_VCCIO on TOP (solid shape): 130.13,73.65 130.13,73.09 130.11,73.06 130.09,72.99 130.06,72.92 130.05,72.84 130.04,72.77 130.04,72.73 130.04,72.38 129.54,72.38 129.25,72.09 129.25,71.77 129.15,71.67 126.6,71.67 126.55,71.72 126.55,72.21 126.71,72.36 128.02,72.36 128.18,72.53 128.18,73.54 129.27,73.54 129.27,73.49 129.27,73.44 129.29,73.39 129.31,73.34 129.34,73.3 129.38,73.27 129.42,73.23 129.47,73.21 129.52,73.19 129.57,73.19 129.62,73.19 129.67,73.19 129.72,73.21 129.77,73.23 129.81,73.27 129.85,73.3 129.88,73.34 129.9,73.39 129.92,73.44 129.93,73.49 129.93,73.54 129.92,73.59 129.9,73.64 129.88,73.69 129.85,73.73 129.81,73.77 129.77,73.8 129.72,73.82 129.67,73.84 129.62,73.85 129.57,73.85 129.52,73.84 129.47,73.82 129.42,73.8 129.38,73.77 129.34,73.73 129.31,73.69 129.29,73.64 129.27,73.59 129.27,73.54 128.18,73.54 128.18,73.77 128.05,73.91 127.63,73.91 127.58,73.96 127.58,74.44 127.62,74.48 129.3,74.48
+1.0VS_VCCIO on BOTTOM (solid shape): 179.88,108.75 179.88,108.3 179.35,108.3 179.35,107.8 179.88,107.8 179.88,107.5 179.35,107.5 179.35,107 179.88,107 179.88,106.65 179.55,106.32 178.07,106.32 177.8,106.58 177.8,108.81 177.93,108.93 179.69,108.93
+1.0VS_VCCIO on IN1 (solid shape): outline of 573 points within 118.32,71.72 128.91,76.08
+1.0VS_VCCIO on VCC: 127.74,67.02 126.88,67.89 126.88,71.45 126.73,71.6 126.62,71.6 126.62,72.38 127.51,73.27 127.51,73.88 129.94,73.88 130.96,72.87 134.35,72.87 134.75,73.27 134.75,73.9 135.74,74.9 137.52,74.9 138.05,75.43 138.05,82.41 139.96,84.32 139.96,85.08 146.92,92.04 177.78,92.04 179.71,93.97 179.71,97.23 177.55,99.39 177.55,108.55 182.78,108.55 183.77,107.56 183.77,83.91 146.07,83.91 145.16,83 145.16,67.02
+1.2V_DDR_B+ on TOP (solid shape): 35.54,40.82 35.54,40.27 35.72,40.09 35.72,38 35.33,37.61 34.22,37.61 33.59,38.24 33.59,39.4 34.45,40.25 34.45,40.7 34.55,40.8 34.79,40.8 35.04,41.05 35.32,41.05
+1.2V_DDR_B+ on BOTTOM (solid shape): 32.85,39.44 33.36,39.44 33.36,39.96 33.74,39.96 34.3,39.4 35.37,39.4 35.63,39.15 35.63,37.73 35.13,37.23 35.13,35.1 34.71,35.1 34.71,37.05 34.48,37.28 33.89,37.28 33.09,38.09 30.12,38.09 29.97,38.24 29.97,39.63 30.3,39.95 32.01,39.95 32.01,39.95 32.05,39.93 32.05,39.44 32.56,39.44 32.56,39.96 32.85,39.96
+1.2V_DDRP on TOP (solid shape): 42.2,28.92 42.2,27.45 41.94,27.19 39.61,27.19 39.42,27 39.42,24.88 39.85,24.44 39.85,22.95 39.65,22.75 37.49,22.75 37.28,22.97 37.28,28.4 38.03,29.15 41.98,29.15
+1.2V_DDRP on BOTTOM (solid shape): 37.32,33.92 37.32,33.18 37.59,32.91 38.48,32.91 38.56,32.84 38.56,31.96 39.45,31.07 39.45,23.35 38.83,22.73 33.56,22.73 33.14,23.15 33.14,25.58 33.58,26.03 35.17,26.03 37.31,28.17 37.31,31.32 36.51,32.13 36.51,33.93 36.6,34.02 37.23,34.02
+1.2V_DDRP on BOTTOM (solid shape): 32.25,36.86 32.25,35.58 32.18,35.5 31.13,35.5 31.02,35.62 31.02,36.12 31.06,36.2 31.15,36.21 31.66,36.34 31.75,36.86 31.76,36.96 31.85,37 32.11,37
+1.2V_LDO on TOP (solid shape): 296.96,50.29 296.96,49.22 296.72,48.99 296.72,48.92 296.27,48.47 296.27,48.15 296.22,48.1 295.78,48.1 295.78,48.1 294.41,48.1 293.99,48.53 293.99,49.48 294.08,49.58 295.24,49.58 295.51,49.31 296.53,49.31 296.75,49.52 296.75,50.28 296.81,50.35 296.89,50.35
+1.2V_LDO on TOP (solid shape): 298.55,50.29 298.55,49.54 299.02,49.07 299.02,48.91 299.45,48.49 299.45,47.56 299.41,47.53 298.87,47.53 298.75,47.65 298.75,48.26 298.79,48.33 298.8,48.4 298.82,48.41 298.82,48.6 298.66,48.76 298.66,48.8 298.33,49.12 298.33,50.28 298.39,50.33 298.5,50.33
+1.2V_LDO on BOTTOM (solid shape): 299.21,49.42 299.21,48.28 298.99,48.05 298.15,48.05 298.14,48.26 298.01,48.43 298.06,48.48 298.1,48.53 298.78,48.32 298.15,48.65 297.91,49.06 297.48,48.86 296.77,48.95 297.45,48.74 297.48,48.57 297.6,48.43 297.47,48.26 297.46,48.05 296.38,48.05 296.15,48.28 296.15,49.46 296.43,49.74 298.9,49.74
+1.2V_MEM on TOP (solid shape): outline of 27080 points within 38.8,21.97 182.37,73.26
+1.2V_MEM_CPUCLK on TOP (solid shape): 125.36,73.21 125.36,72.67 125.21,72.52 124.59,72.52 124.3,72.23 124.26,72.25 123.89,72.21 123.8,71.84 123.82,71.8 123.48,71.47 122.58,71.47 122.55,71.5 122.53,71.53 122.51,71.55 122.51,71.76 122.63,71.96 122.6,72.2 122.94,72.54 123.63,72.54 123.68,72.59 123.68,72.97 123.95,73.25 125.32,73.25
+1.8V_3.3V_ALW_VTR3 on TOP (solid shape): 275.23,40.19 275.78,40.19 275.78,40.01 275.22,40.01 275.22,39.6 274.66,39.6 274.07,39.6 273.9,39.78 273.9,40.35 274.17,40.63 275.23,40.63
+1.8V_3.3V_ALW_VTR3 on TOP (solid shape): 275.27,37.94 275.81,37.94 275.81,37.72 275.27,37.72 275.27,37.32 275.23,37.28 274.95,37.28 274.87,37.36 274.77,37.45 274.64,37.46 274.58,37.45 273.93,37.45 273.93,37.77 274.11,37.77 274.64,38.3 275.27,38.3
+1.8V_3.3V_ALW_VTR3 on IN2 (solid shape): 275.25,39.92 275.25,37.67 275.01,37.44 274.75,37.44 274.74,37.44 274.64,37.46 274.54,37.44 274.53,37.44 274.19,37.44 274.11,37.52 274.11,38.61 274.2,38.85 274.11,39.08 274.11,39.16 273.7,39.57 273.7,40.05 273.85,40.2 274.97,40.2
+1.8V_PRIM on TOP (solid shape): 156.53,75.34 156.53,74.83 155.59,73.9 155.59,73.41 155.27,73.08 154.42,73.08 154.21,73.29 154.21,74.53 155.34,75.66 156.21,75.66
+1.8V_PRIM on TOP (solid shape): 165.82,66.16 166.67,66.16 166.75,66.08 166.75,64.32 166.64,64.21 164.98,64.21 164.46,64.74 164.46,65.54 164.01,65.98 164.01,66.41 164.19,66.59 165.38,66.59
+1.8V_PRIM on TOP (solid shape): 147.38,77.89 147.38,77.43 146.92,76.97 146.92,76.49 146.76,76.33 146.24,76.33 146.12,76.21 146.12,75.7 145.85,75.43 145.46,75.43 145.43,75.46 145.43,76.98 145.46,77.02 146.12,77.02 146.18,77.08 146.18,77.94 146.31,78.07 147.2,78.07
+1.8V_PRIM on TOP (solid shape): 277.36,38.1 277.36,37.36 277.35,37.34 276.91,37.34 276.86,37.29 276.76,37.29 276.75,37.3 276.57,37.33 276.4,37.26 275.46,37.26 275.38,37.34 275.38,37.62 275.92,37.62 275.92,37.63 275.94,37.63 275.94,38.1 275.38,38.1 275.38,38.3 277.16,38.3
+1.8V_PRIM on TOP (solid shape): outline of 87 points within 243.33,31.08 245.53,33.93
+1.8V_PRIM on BOTTOM (solid shape): 160.09,99.37 161.23,99.37 161.36,99.25 161.36,98.95 161.26,98.85 153.44,98.85 153.44,98.99 153.11,99.31 153.11,100.2 153.26,100.35 159.11,100.35
+1.8V_PRIM on BOTTOM (solid shape): 125.73,102.65 125.73,101.44 125.56,101.27 123.93,101.27 123.92,101.28 123.45,100.81 122.43,100.81 122.18,101.06 122.18,101.82 122.56,102.2 123.51,102.2 123.72,102.42 123.76,102.39 124.1,102.36 124.28,102.66 124.34,102.71 125.67,102.71
+1.8V_PRIM on IN1 (solid shape): 166.37,66.01 166.37,63.98 165.99,63.59 164.85,63.59 164.59,63.85 164.59,66.01 164.85,66.26 166.12,66.26
+1.8V_PRIM on IN1 (solid shape): 154.85,100.14 154.85,99.5 154.84,99.49 154.84,99.21 154.46,98.83 154.46,98.11 154.45,98.1 154.43,97.99 154.45,97.89 154.46,97.88 154.46,96.8 154.22,96.57 153.38,96.57 152.99,96.95 152.99,100.05 153.35,100.41 154.58,100.41
+1.8V_PRIM on IN1 (solid shape): outline of 145 points within 179.33,50.64 196.98,58.34
+1.8V_PRIM on IN1 (solid shape): outline of 230 points within 146.29,76.88 155.05,79.54
+1.8V_PRIM on IN1 (solid shape): outline of 832 points within 243.48,29.09 277.38,33.98
+1.8V_PRIM on IN2 (solid shape): 154.84,100.09 154.84,99.45 154.57,99.18 153.26,99.18 153.06,99.39 153.06,100.36 153.16,100.45 154.47,100.45
+1.8V_PRIM on IN2 (solid shape): 155.21,78.4 155.21,73.54 155.03,73.35 154.31,73.35 154.05,73.61 154.05,77.85 153.85,78.05 153.85,78.38 154.07,78.6 155.01,78.6
+1.8V_PRIM on IN2 (solid shape): 130.39,101.91 132.26,101.91 132.4,101.77 132.4,100.94 132.12,100.66 130.32,100.66 130.3,100.68 130.2,100.68 128.71,102.16 124.45,102.16 124.34,102.27 124.34,102.65 124.47,102.78 124.5,102.77 124.74,102.8 124.9,102.97 124.91,103 126.28,103 129.04,103 129.04,103 129.3,103
+1.8V_PRIM on IN2 (solid shape): outline of 200 points within 275.43,30.23 279.29,38.56
+1.8V_RUN on TOP (solid shape): 247.14,56.86 247.14,56.17 245.94,54.96 244.86,54.96 244.35,55.47 244.35,56.48 244.99,57.12 246.89,57.12
+1.8V_RUN on TOP (solid shape): 192.79,73.82 192.79,72.36 192.62,72.19 190.46,72.19 190.3,72.36 190.3,73.73 190.63,74.06 192.55,74.06
+1.8V_RUN on TOP (solid shape): 300.04,45.05 301.14,45.05 303.02,43.17 303.02,39.21 302.77,38.96 302.14,38.96 301.86,39.24 301.86,39.76 301.75,39.86 301.75,41.37 298.9,44.23 298.9,44.99 299.09,45.18 299.91,45.18
+1.8V_RUN on TOP (solid shape): 167.64,72.15 167.64,70.86 167.29,70.5 166.15,70.5 166.15,70.5 166.15,69.95 165.96,69.95 165.96,70.5 165.96,70.5 165.43,70.5 165.33,70.61 165.33,71.16 165.48,71.32 165.91,71.32 166.17,71.57 166.17,72.08 166.45,72.36 167.44,72.36
+1.8V_RUN on BOTTOM (solid shape): 184.48,69.16 184.48,68.41 184.17,68.1 182.38,68.1 182,68.48 182,69.25 182.14,69.4 184.24,69.4
+1.8V_RUN on BOTTOM (solid shape): 166.1,72.31 167.97,72.31 168.23,72.05 168.23,69.74 167.24,69.74 166.32,70.66 166.32,71.19 166,71.52 164.54,71.52 164.4,71.66 164.4,72.26 164.51,72.36 166.05,72.36
+1.8V_RUN on IN1 (solid shape): 185.93,69.69 185.93,68.42 185.92,68.41 183.02,68.41 182.76,68.67 182.76,69.56 183.14,69.94 185.68,69.94
+1.8V_RUN on IN2 (solid shape): 255.31,63.25 255.31,62.44 254.84,61.97 253.21,61.97 252.88,61.64 252.76,61.64 246.28,55.16 245.8,55.16 245.42,55.54 245.42,56.04 252.88,63.49 255.07,63.49
+1.8V_RUN on IN2 (solid shape): 298.51,45.51 298.82,45.29 299.15,45.49 299.18,45.48 299.49,45.32 299.79,45.5 300.33,44.96 300.33,44.39 300.26,44.32 298.07,44.32 297.66,44.72 297.66,45.21 297.97,45.51
+1.8V_RUN_AUDIO on TOP (solid shape): 304.84,38.45 305.14,38.29 305.43,38.45 306.45,38.45 306.71,38.19 306.71,37.69 306.45,37.43 305.18,37.43 305.09,37.34 304.89,37.34 304.89,36.67 304.51,36.29 304.29,36.29 304.17,36.42 304.17,37.43 304.25,37.51 304.32,37.51 304.32,37.59 304.42,37.69 304.42,38.19 304.68,38.45
+1.8V_RUN_AUDIO on BOTTOM (solid shape): 304.68,37.49 304.68,35.52 304.22,35.06 302.84,35.06 302.3,35.6 302.3,36.5 303.51,36.5 303.51,36.44 303.51,36.39 303.53,36.34 303.55,36.3 303.58,36.26 303.62,36.22 303.66,36.19 303.71,36.16 303.76,36.15 303.81,36.14 303.86,36.14 303.91,36.15 303.96,36.16 304.01,36.19 304.05,36.22 304.09,36.26 304.12,36.3 304.14,36.34 304.16,36.39 304.17,36.44 304.17,36.5 304.16,36.55 304.14,36.6 304.12,36.64 304.09,36.69 304.05,36.72 304.01,36.75 303.96,36.78 303.91,36.79 303.86,36.8 303.81,36.8 303.76,36.79 303.71,36.78 303.66,36.75 303.62,36.72 303.58,36.69 303.55,36.64 303.53,36.6 303.51,36.55 303.51,36.5 302.3,36.5 302.3,37.87 302.45,38.02 304.16,38.02
+1.8V_RUN_CARD on TOP (solid shape): 315.78,48.83 316.1,48.57 316.42,48.83 316.43,48.87 316.89,48.87 317.03,48.73 317.03,48.35 317.04,48.35 317.04,47.15 318.88,45.31 321.23,45.31 324.44,42.1 324.44,42.09 325.31,42.09 325.5,41.9 325.5,41.12 325.44,41.06 321.5,41.06 315.18,47.38 315.18,48.69 315.36,48.87 315.77,48.87
+1.8V_RUN_CARD on IN3 (solid shape): 299.45,48.52 299.45,47.96 299.31,47.83 298.58,47.83 298.21,48.19 298.21,48.6 298.33,48.72 299.25,48.72
+1.8V_RUN_UZ8 on TOP (solid shape): 166.92,69.7 166.92,68.47 166.76,68.31 166.76,67.62 166.68,67.54 166,67.54 165.87,67.67 165.87,67.99 165.55,68.31 165.04,68.31 164.96,68.38 164.96,69.69 165.05,69.79 166.83,69.79
+1.8VALWP on BOTTOM (solid shape): 170.12,99.63 170.12,99.2 169.97,99.04 168.68,99.04 168.54,99.18 168.54,99.65 168.67,99.79 169.97,99.79
+1.8VALWP on BOTTOM (solid shape): 161.69,103.54 161.69,100.71 161.69,100.71 161.69,100.53 162.15,100.07 162.15,99.63 162.06,99.54 160.94,99.54 160.94,100.09 160.94,100.09 160.4,100.09 160.4,99.59 160.35,99.54 160.19,99.54 159.51,100.21 159.51,103.61 159.7,103.79 161.44,103.79
+1VALWP on TOP (solid shape): 180.76,98.71 180.76,97.52 180.57,97.33 177.45,97.33 177.21,97.57 177.21,98.75 177.29,98.84 180.63,98.84
+1VALWP on BOTTOM (solid shape): 180.76,98.65 180.76,98.02 180.77,98.02 181.19,97.61 183.53,97.61 184.83,96.31 184.83,93.67 184.57,93.41 180.44,93.41 180.29,93.57 180.29,94.04 180.3,94.05 180.3,97.17 180.06,97.42 177.64,97.42 177.33,97.72 177.33,98.65 177.52,98.84 180.57,98.84
+1VALWP_B+ on TOP (solid shape): 182.45,102.55 182.45,101.07 182.29,100.91 180.91,100.91 180.67,101.15 180.67,102.65 180.98,102.95 182.04,102.95
+1VALWP_B+ on BOTTOM (solid shape): 182.79,103.39 183.3,103.39 183.3,103.92 183.6,103.92 183.6,103.39 184.1,103.39 184.1,103.92 184.44,103.92 184.5,103.86 184.5,103.64 185.19,102.95 185.19,100.48 185.1,100.39 183.14,100.39 182.64,100.88 180.93,100.88 180.68,101.12 180.68,103.68 180.84,103.83 180.85,103.83 180.94,103.92 182.79,103.92
+1VS_VCCIOP on BOTTOM (solid shape): 182.23,111.99 182.23,105.94 182.15,105.85 180.24,105.85 180.02,106.06 180.02,107.13 179.48,107.13 179.48,107.38 180,107.38 180.01,107.4 180.01,107.9 180,107.93 179.48,107.93 179.48,108.18 180,108.18 180.02,108.18 180.02,112.15 180.16,112.29 181.94,112.29
+2.5V_MEM on TOP (solid shape): 194.29,37.03 194.29,33.18 194.13,33.03 192.42,33.03 191.92,33.52 191.92,35.1 192.48,35.66 192.48,37.03 192.66,37.2 194.11,37.2
+2.5V_MEM on TOP (solid shape): 194.63,26.77 194.63,25.84 194.19,25.4 193.57,25.4 193.54,25.37 193.54,24.87 193.52,24.85 193.34,24.85 193.31,24.87 193.31,25.37 193.28,25.41 192.86,25.41 192.82,25.45 192.82,26 193.04,26.21 193.04,26.74 193.14,26.84 194.19,26.84 194.23,26.88 194.53,26.88
+2.5V_MEM on TOP (solid shape): 117.62,35.44 117.62,34.73 117.87,34.47 120.79,34.47 121.49,33.78 121.49,33.76 121.68,33.55 121.97,33.56 121.99,33.57 123.06,33.57 123.32,33.31 123.32,32.68 122.95,32.3 119.03,32.3 117.85,33.49 116.52,33.49 115.73,34.27 113.2,34.27 113.02,34.45 113.02,35.36 113.24,35.58 117.48,35.58
+2.5V_MEM on BOTTOM (solid shape): 113.87,35.32 113.87,34.55 113.11,33.79 113.11,32.3 112.84,32.03 112.33,32.03 112.12,32.24 112.12,34.9 112.79,35.56 113.63,35.56
+2.5V_MEM on BOTTOM (solid shape): 192.71,39.9 192.71,39.62 192.61,39.52 192.61,37.13 192.63,37.11 192.63,33.76 192.48,33.61 191.74,33.61 191.31,34.04 191.31,34.64 191.21,34.73 191.21,37.03 190.98,37.26 190.98,39.85 191.39,40.25 192.36,40.25
+2.5V_MEM on BOTTOM (solid shape): 123.54,33.71 123.54,32.99 122.95,32.41 121.98,32.41 121.77,32.61 121.77,33.44 121.78,33.48 122.07,33.6 122.17,33.85 122.17,33.92 122.31,34.06 123.19,34.06
+2.5V_MEM on IN1 (solid shape): 193.8,34.7 193.8,33.81 193.65,33.66 192.06,33.66 191.9,33.83 191.9,34.79 192.08,34.97 193.54,34.97
+2.5V_MEM on IN3 (solid shape): outline of 252 points within 191.87,26.29 195.61,35.09
+2.5V_VIN on TOP (solid shape): 199.62,27.97 199.62,27.46 199.65,27.43 200.47,27.43 200.7,27.2 200.7,24.57 200.41,24.28 199.55,24.28 199.11,23.84 198.19,23.84 198.08,23.95 198.08,24.41 198.91,25.25 198.91,27.32 199.02,27.43 199.38,27.43 199.41,27.46 199.41,27.96 199.44,27.99 199.6,27.99
+3.3V_1.8V_ESPI on TOP (solid shape): 167.61,60.56 167.37,60.33 167.37,59.64 167.34,59.61 166.7,59.61 166.67,59.63 166.67,60.01 166.62,60.06 166.11,60.06 166.08,60.09 166.08,60.24 166.11,60.27 166.54,60.27 166.57,60.31 166.63,60.31 166.63,60.36 166.65,60.38 166.65,61.2 167.61,61.2
+3.3V_1.8V_PGPPA on TOP (solid shape): 164.25,65.58 164.25,64.7 165.11,63.84 166.66,63.84 166.71,63.79 166.71,63.32 166.66,63.27 164.45,63.27 163.57,64.15 163.45,64.15 162.04,65.56 161.7,65.56 161.32,65.93 162.92,65.93 162.92,65.88 162.93,65.83 162.94,65.78 162.96,65.74 163,65.69 163.03,65.66 163.07,65.63 163.12,65.6 163.17,65.59 163.22,65.58 163.27,65.58 163.32,65.59 163.37,65.6 163.42,65.63 163.46,65.66 163.5,65.69 163.53,65.74 163.55,65.78 163.57,65.83 163.58,65.88 163.58,65.93 163.57,65.99 163.55,66.04 163.53,66.08 163.5,66.12 163.46,66.16 163.42,66.19 163.37,66.21 163.32,66.23 163.27,66.24 163.22,66.24 163.17,66.23 163.12,66.21 163.07,66.19 163.03,66.16 163,66.12 162.96,66.08 162.94,66.04 162.93,65.99 162.92,65.93 161.32,65.93 161.23,66.03 161.23,66.59 161.37,66.73 163.1,66.73
+3.3V_1.8V_PGPPA on TOP (solid shape): 166.54,60.76 166.54,60.42 166.49,60.37 165.99,60.37 165.97,60.35 165.97,59.99 166.01,59.94 166.54,59.94 166.57,59.92 166.57,59.53 166.46,59.42 165.32,59.42 164.74,60 165.09,60 165.09,59.95 165.1,59.9 165.11,59.85 165.14,59.8 165.17,59.76 165.2,59.72 165.25,59.69 165.29,59.67 165.34,59.65 165.39,59.65 165.45,59.65 165.5,59.65 165.55,59.67 165.59,59.69 165.63,59.72 165.67,59.76 165.7,59.8 165.73,59.85 165.74,59.9 165.75,59.95 165.75,60 165.74,60.05 165.73,60.1 165.7,60.15 165.67,60.19 165.63,60.23 165.59,60.26 165.55,60.28 165.5,60.3 165.45,60.31 165.39,60.31 165.34,60.3 165.29,60.28 165.25,60.26 165.2,60.23 165.17,60.19 165.14,60.15 165.11,60.1 165.1,60.05 165.09,60 164.74,60 164.64,60.1 163.88,60.1 163.83,60.15 163.83,61.02 164,61.18 166.12,61.18
+3.3V_1.8V_PGPPA on IN1 (solid shape): 161.64,66.84 162.67,66.84 162.94,66.58 162.94,66.02 162.93,66.02 162.92,65.91 162.93,65.8 162.94,65.79 162.94,65.69 163.38,65.26 163.38,65.25 163.67,64.96 163.67,63.7 165.83,61.54 165.83,60.54 165.57,60.27 165.54,60.28 165.35,60.3 165.19,60.21 164.54,60.21 162.18,62.58 162.18,64.31 161.22,65.27 161.22,66.62 161.44,66.84
+3.3V_ALW on TOP (solid shape): 277.44,40.29 277.44,39.92 277.11,39.59 275.38,39.59 275.36,39.6 275.36,39.82 275.39,39.85 275.94,39.85 275.94,40.33 275.38,40.33 275.38,40.63 275.5,40.74 276.99,40.74
+3.3V_ALW on TOP (solid shape): 286.96,77.76 286.96,76.99 287.09,76.86 287.09,75.6 286.83,75.34 284.93,75.34 284.61,75.66 284.61,77.44 284.73,77.56 285.68,77.56 285.96,77.84 286.88,77.84
+3.3V_ALW on TOP (solid shape): 303.91,61.05 303.91,60.55 303.66,60.29 302.14,60.29 302.04,60.39 302.05,60.43 302.05,60.99 302.04,61.02 302.03,61.08 302.14,61.18 303.79,61.18
+3.3V_ALW on TOP (solid shape): 271.21,30.21 271.21,28.75 271.01,28.55 269.7,28.55 269.11,27.97 268.55,27.97 268.47,28.05 268.47,28.63 268.21,28.89 268.21,29.21 268.07,29.35 268.07,30.19 268.17,30.29 271.13,30.29
+3.3V_ALW on TOP (solid shape): 300.85,61.07 300.84,60.99 300.84,60.14 300.55,59.85 300.55,59.4 300.36,59.21 298.9,59.21 298.64,59.47 298.64,60.93 298.9,61.18 300.74,61.18
+3.3V_ALW on TOP (solid shape): 202.69,37.37 202.69,36.16 202.57,36.04 202.31,36.04 202.24,36.04 202.17,36.04 202,36.04 201.74,35.78 201.04,35.78 200.98,35.85 200.98,36.42 200.92,36.48 200.34,36.48 200.22,36.61 200.22,36.86 199.77,37.31 199.77,37.62 199.96,37.81 202.25,37.81
+3.3V_ALW on TOP (solid shape): 221.66,27.04 221.66,24.92 221.64,24.9 221.11,24.9 221.09,24.88 221.09,24.21 221.12,24.18 221.62,24.18 221.64,24.16 221.64,23.74 221.62,23.71 221.2,23.71 221.15,23.67 221.12,23.67 221.12,23.64 221.1,23.62 221.1,23.04 221.13,23.01 221.63,23.01 221.67,22.98 221.67,22.42 221.36,22.11 216.77,22.11 216.14,22.74 216.14,27.17 216.63,27.66 221.03,27.66
+3.3V_ALW on TOP (solid shape): 266.21,30.55 266.69,30.55 266.69,31.11 266.95,31.11 266.95,30.05 266.77,29.94 266.68,29.75 266.51,29.58 265.45,29.58 264.74,28.86 264.25,28.86 263.98,28.59 263.98,28.19 263.88,28.1 263.37,28.1 263.25,28.21 263.25,28.67 263.06,28.86 262.46,28.86 262.33,28.99 262.33,29.62 262.48,29.77 263.96,29.77 264.08,29.89 264.08,30.55 264.16,30.63 265.22,30.63 265.71,31.11 266.21,31.11
+3.3V_ALW on TOP (solid shape): 201.85,34.31 202.42,34.31 202.62,34.11 202.62,32.91 201.91,32.2 201.91,29.64 201.55,29.28 201.54,29.28 200.75,28.49 200.75,28.41 200.72,28.36 200.67,28.37 200.52,28.52 200.52,28.55 199.97,28.85 200.27,28.3 200.3,28.3 200.75,27.85 200.75,27.81 200.49,27.54 199.75,27.54 199.73,27.56 199.73,28.1 199.71,28.12 199.31,28.12 199.28,28.1 199.28,27.57 199.26,27.55 198.27,27.55 197.99,27.82 197.77,27.82 197.77,29.1 197.86,29.2 199.26,29.2 200.05,29.99 200.05,32.73 200.94,33.62 200.94,34.31 201.09,34.46 201.7,34.46
+3.3V_ALW on TOP (solid shape): outline of 153 points within 275.6,41.98 280.03,47.12
+3.3V_ALW on BOTTOM (solid shape): 268.81,29.21 268.81,26.67 268.67,26.52 267.58,26.52 267.48,26.62 267.48,28.98 267.85,29.34 268.68,29.34
+3.3V_ALW on BOTTOM (solid shape): 171.26,103.26 171.26,101.22 171.06,101.02 169.59,101.02 169.47,101.14 169.47,102.67 170,102.67 170,103.11 169.47,103.11 169.47,103.49 169.71,103.73 170.79,103.73
+3.3V_ALW on BOTTOM (solid shape): 305.73,76.74 305.73,73.93 305.72,73.92 305.72,73.21 305.44,72.93 304.8,72.93 304.73,73 304.73,74.99 304.25,75.47 304.25,75.96 303.79,76.42 303.05,76.42 302.88,76.59 302.2,76.59 302.2,76.6 302.2,76.99 302.33,77.12 305.34,77.12
+3.3V_ALW on BOTTOM (solid shape): 185.12,104.11 185.12,103.9 185.52,103.5 186.36,103.5 186.59,103.27 186.59,103.14 186.58,103.13 186.58,102.29 186.39,102.09 186.16,102.09 185.63,101.56 185.63,100.44 185.6,100.41 185.4,100.41 185.35,100.46 185.35,102.98 184.63,103.69 184.63,104.14 184.69,104.2 185.03,104.2
+3.3V_ALW on BOTTOM (solid shape): 167.52,82.65 167.52,82.3 167.08,81.86 167.08,81.73 167.03,81.72 166.76,81.4 167.03,81.07 167.08,81.06 167.08,79.36 167.01,79.29 166.15,79.29 165.85,78.99 165.26,78.99 165.23,79.03 165.23,80.66 165.27,80.69 165.3,80.72 165.36,80.74 165.43,80.73 165.95,80.99 165.43,81.26 165.36,81.24 165.3,81.27 165.27,81.3 165.23,81.32 165.23,82.01 165.36,82.14 166.25,82.14 166.46,82.35 166.46,82.59 166.58,82.71 167.46,82.71
+3.3V_ALW on IN2 (solid shape): 202.19,37.18 202.19,36.54 201.68,36.04 201.68,35.15 202.31,34.51 202.44,34.51 202.82,34.13 202.82,33.24 202.31,32.73 201.17,32.73 199.39,34.51 199.39,35.12 200.04,35.12 200.04,35.06 200.05,35.01 200.07,34.96 200.09,34.92 200.12,34.87 200.16,34.84 200.2,34.81 200.25,34.78 200.3,34.77 200.35,34.76 200.4,34.76 200.45,34.77 200.5,34.78 200.55,34.81 200.59,34.84 200.63,34.87 200.66,34.92 200.68,34.96 200.7,35.01 200.7,35.06 200.7,35.12 200.7,35.17 200.68,35.22 200.66,35.26 200.63,35.3 200.59,35.34 200.55,35.37 200.5,35.4 200.45,35.41 200.4,35.42 200.35,35.42 200.3,35.41 200.25,35.4 200.2,35.37 200.16,35.34 200.12,35.3 200.09,35.26 200.07,35.22 200.05,35.17 200.04,35.12 199.39,35.12 199.39,37.5 199.58,37.69 201.68,37.69
+3.3V_ALW on IN2 (solid shape): outline of 1923 points within 282.2,58.9 307.66,78.71
+3.3V_ALW on VCC: outline of 81 points within 23.88,27.15 286.39,113.51 ; 1 cut-out
+3.3V_ALW_DSW on TOP (solid shape): 175.09,54.13 175.09,53.51 174.96,53.37 173.62,53.37 173.54,53.37 173.3,53.14 173.3,52.48 173.51,52.27 173.51,50 173.42,49.9 172.63,49.9 172.52,50.02 171.47,50.02 170.82,49.37 170.44,49.37 170.18,49.62 170.18,50.64 170.41,50.87 171.27,50.87 171.38,50.97 171.38,53.3 172.12,54.05 172.41,54.34 174.89,54.34
+3.3V_ALW_PCH on TOP (solid shape): 199.81,30.5 199.81,29.97 199.52,29.67 197.65,29.67 197.37,29.95 197.37,30.45 197.5,30.57 199.73,30.57
+3.3V_ALW_PCH on TOP (solid shape): outline of 281 points within 135.42,72.32 141.85,75.57
+3.3V_ALW_PCH on TOP (solid shape): outline of 823 points within 145.25,68.26 163.94,104.97
+3.3V_ALW_PCH on BOTTOM (solid shape): 168.91,90.24 169.06,90.24 169.06,89.82 168.54,89.82 168.54,89.44 169.06,89.44 169.06,88.81 168.93,88.68 167.05,88.68 166.94,88.79 166.94,90.26 167.01,90.33 168.82,90.33
+3.3V_ALW_PCH on BOTTOM (solid shape): 143.56,97.5 143.56,96.73 143.39,96.56 142.88,96.56 142.88,96.55 142.78,96.55 142.66,96.44 142.22,96.44 142.06,96.6 142.06,97.45 142.17,97.57 143.49,97.57
+3.3V_ALW_PCH on BOTTOM (solid shape): 171.55,77.65 171.55,76.04 171.27,75.76 171.27,71.23 171.27,71.17 171.15,71.05 170.19,71.05 169.86,71.37 169.86,72.3 170.09,72.53 170.09,75.57 171.17,76.65 171.17,76.78 171.21,76.82 171.21,77.73 171.26,77.78 171.43,77.78
+3.3V_ALW_PCH on BOTTOM (solid shape): 147.33,104.07 147.33,103.99 147.32,103.99 147.32,100.82 147.1,100.59 145.46,100.59 145.41,100.64 145.41,101.26 146.07,101.93 146.07,103.51 146.07,103.52 146.07,104.05 146.33,104.31 147.09,104.31
+3.3V_ALW_PCH on IN1 (solid shape): 162.54,69.61 162.54,68.35 162.23,68.04 161.46,68.04 161.28,68.22 161.28,68.3 161.7,68.72 161.7,69.07 161.29,69.48 161.29,69.71 161.42,69.83 162.32,69.83
+3.3V_ALW_PCH on IN1 (solid shape): outline of 87 points within 140.74,96.19 143.38,104.36
+3.3V_ALW_PCH on IN2 (solid shape): outline of 259 points within 139.58,73.69 145.48,75.79
+3.3V_ALW_PCH on IN2 (solid shape): outline of 393 points within 179.33,29.77 199.65,59.01
+3.3V_ALW_PCH on IN3 (solid shape): outline of 112 points within 140.97,103.14 157,105.78
+3.3V_ALW_PCH on IN3 (solid shape): outline of 347 points within 132.46,72.19 137.07,74.62
+3.3V_ALW_PCH on VCC: 178.8,57.24 171.3,64.74 159.28,64.74 158.01,63.47 147.55,63.47 145.67,65.35 145.67,78.33 148.87,78.33 149.35,77.84 149.35,74.79 150.14,74.01 152.04,74.01 153.95,72.1 175.03,72.1 177.95,69.18 183.16,69.18 183.77,68.57 183.77,57.6 183.41,57.24
+3.3V_ALW_PCH_UZ3 on TOP (solid shape): 199.72,34.38 199.72,31.57 199.44,31.29 197.82,31.29 197.57,31.54 197.57,33.06 197.91,33.41 197.96,33.41 197.96,33.45 197.99,33.48 197.99,33.91 198.1,34.03 198.48,34.03 198.88,34.43 199.04,34.43 199.07,34.46 199.65,34.46
+3.3V_ALW_UE1 on TOP (solid shape): 267.6,32.75 267.6,31.94 266.92,31.26 266.54,31.26 266.54,30.71 266.36,30.71 266.36,31.26 265.93,31.26 265.93,31.66 265.98,31.76 266.01,31.87 266.58,32.44 266.58,32.93 266.62,32.96 267.38,32.96
+3.3V_ALW_UE1 on TOP (solid shape): 275.22,52.37 275.22,52.02 274.89,51.69 274.89,50.77 274.83,50.7 274.64,50.7 274.54,50.61 274.54,50.01 274.7,49.85 274.7,48.87 274.62,48.79 273.92,48.79 273.77,48.94 273.77,50.79 273.84,50.97 273.77,51.15 273.77,52 274.18,52.4 275.19,52.4
+3.3V_ALWP on TOP (solid shape): 228.55,28.85 228.55,22.35 228.13,21.94 222.25,21.94 221.77,22.42 221.77,23.02 221.74,23.04 221.74,23.08 221.72,23.11 221.68,23.11 221.68,23.11 221.23,23.11 221.21,23.13 221.21,23.56 221.24,23.59 221.72,23.59 221.74,23.62 221.75,23.7 221.75,24.2 221.74,24.25 221.69,24.3 221.21,24.3 221.19,24.32 221.19,24.77 221.21,24.78 221.72,24.78 221.77,24.83 221.77,28.95 222.21,29.39 228.01,29.39
+3.3V_ALWP on BOTTOM (solid shape): 228.35,29.14 228.35,23.21 228.34,23.2 228.34,22.17 227.86,21.68 222.63,21.68 222.13,22.19 222.13,27.05 222.5,27.05 222.5,29.24 222.67,29.4 228.08,29.4
+3.3V_CAM on TOP (solid shape): 62.38,113.51 62.38,112.44 61.09,111.14 60,111.14 59.87,111.27 59.87,112.79 60.63,113.56 62.33,113.56
+3.3V_EC_PLL on TOP (solid shape): 266.61,36.89 266.61,35.95 266.61,35.94 266.61,35.3 266.33,35.03 266.33,32.41 266.22,32.29 265.72,32.29 265.54,32.48 265.54,32.49 265.41,32.62 265.41,34.18 265.41,34.18 265.41,34.52 265.98,35.09 265.98,35.17 266.25,35.44 266.25,36.22 266.26,36.23 266.26,36.86 266.36,36.96 266.54,36.96
+3.3V_HDD_M2 on TOP (solid shape): 22.3,16.92 22.3,16.65 22.38,16.57 22.38,16.57 22.83,16.11 22.83,14.09 22.82,14.08 22.82,13.51 22.49,13.18 19.89,13.18 19.55,13.52 19.55,14.4 21.12,14.4 21.12,14.34 21.13,14.28 21.15,14.22 21.18,14.16 21.21,14.11 21.25,14.06 21.3,14.02 21.35,13.99 21.41,13.96 21.46,13.94 21.52,13.92 21.59,13.92 21.65,13.92 21.71,13.93 21.77,13.95 21.82,13.97 21.88,14 21.93,14.04 21.97,14.09 22.01,14.14 22.04,14.19 22.06,14.25 22.08,14.31 22.08,14.37 22.08,14.43 22.08,14.49 22.06,14.55 22.04,14.61 22.01,14.66 21.97,14.71 21.93,14.76 21.88,14.8 21.82,14.83 21.77,14.85 21.71,14.87 21.65,14.88 21.59,14.88 21.52,14.88 21.46,14.86 21.41,14.84 21.35,14.81 21.3,14.78 21.25,14.74 21.21,14.69 21.18,14.64 21.15,14.58 21.13,14.52 21.12,14.46 21.12,14.4 19.55,14.4 19.55,14.66 20.55,15.67 20.55,17.09 20.83,17.37 21.85,17.37
+3.3V_HDD_M2 on TOP (solid shape): outline of 294 points within 24.45,13.05 39.14,19.89
+3.3V_HDD_M2 on IN3 (solid shape): 26.39,17.68 26.39,16.3 25.26,15.18 23.55,15.18 21.53,13.15 20.1,13.15 19.81,13.45 19.81,14.4 21.12,14.4 21.12,14.34 21.13,14.28 21.15,14.22 21.18,14.16 21.21,14.11 21.25,14.06 21.3,14.02 21.35,13.99 21.41,13.96 21.46,13.94 21.52,13.92 21.59,13.92 21.65,13.92 21.71,13.93 21.77,13.95 21.82,13.97 21.88,14 21.93,14.04 21.97,14.09 22.01,14.14 22.04,14.19 22.06,14.25 22.08,14.31 22.08,14.37 22.08,14.43 22.08,14.49 22.06,14.55 22.04,14.61 22.01,14.66 21.97,14.71 21.93,14.76 21.88,14.8 21.82,14.83 21.77,14.85 21.71,14.87 21.65,14.88 21.59,14.88 21.52,14.88 21.46,14.86 21.41,14.84 21.35,14.81 21.3,14.78 21.25,14.74 21.21,14.69 21.18,14.64 21.15,14.58 21.13,14.52 21.12,14.46 21.12,14.4 19.81,14.4 19.81,14.84 21.6,16.63 23.45,16.63 23.46,16.63 24.43,16.63 25.08,17.29 25.08,17.77 25.31,18 26.06,18
+3.3V_LAN on TOP (solid shape): 270,88.74 270,88.23 269.62,87.85 269.62,86.71 269.37,86.45 267.83,86.45 267.69,86.59 267.69,88.37 268.16,88.84 269.9,88.84
+3.3V_LAN on TOP (solid shape): 296.61,86.9 296.61,85.25 296.55,85.18 294.9,85.18 294.77,85.31 294.77,85.95 295.15,86.33 295.15,86.96 295.28,87.09 296.42,87.09
+3.3V_LAN on TOP (solid shape): 309.95,100.49 310.96,100.49 311.15,100.3 311.15,99.79 310.96,99.6 309.18,99.6 309.06,99.73 309.06,100.49 309.18,100.62 309.82,100.62
+3.3V_LAN on TOP (solid shape): 303.31,73.75 303.19,73.47 303.36,73.21 303.62,73.18 303.81,73.35 304,73.35 304.23,73.12 304.23,71.56 304.12,71.45 304.12,70.88 304.09,70.81 304.02,70.78 303.71,70.45 304.02,70.12 304.09,70.09 304.12,70.02 304.12,67.34 304.63,66.82 304.69,66.82 304.93,66.58 304.93,64.86 304.8,64.74 303.6,64.74 303.53,64.76 303.5,64.83 303.29,65.11 302.95,65.04 302.93,65.03 302.83,64.93 302.07,65.69 302.07,69.28 302.16,69.37 302.16,73.59 302.33,73.75
+3.3V_LAN on BOTTOM (solid shape): 271.66,100.3 271.66,99.79 271.21,99.35 269.05,99.35 267.34,97.63 267.34,91.53 267.59,91.28 267.77,91.28 267.86,91.22 267.85,91.11 268.1,90.57 268.35,91.11 268.34,91.22 268.43,91.28 269.75,91.28 270.13,90.9 270.13,89.61 270.05,89.4 270.13,89.19 270.13,88.7 270.05,88.49 270.13,88.28 270.13,87.34 269.37,86.58 266.96,86.58 266.07,87.47 266.07,98.9 267.97,100.81 271.15,100.81
+3.3V_LAN on IN1 (solid shape): outline of 576 points within 288.3,72.17 306.45,96.61
+3.3V_LAN on IN2 (solid shape): outline of 683 points within 267.14,84.75 297.31,92.8
+3.3V_LAN_OUT on TOP (solid shape): 274.58,90.52 274.58,90.43 273.8,89.65 273.8,89.61 273.79,89.6 273.79,87.32 273.43,86.96 271.4,86.96 271.15,86.71 271.15,86.2 271.02,86.07 270,86.07 269.88,86.2 269.88,86.49 270.3,86.91 270.3,87.8 270.48,87.98 272.54,87.98 272.7,88.13 272.84,88.13 273.2,88.49 272.85,88.84 272.81,88.86 272.8,88.89 272.8,89.25 272.85,89.25 274.05,90.45 274.05,90.77 274.32,90.77
+3.3V_LAN_OUT on IN1 (solid shape): outline of 481 points within 270.21,85.78 282.49,100.78
+3.3V_LAN_UZ2 on TOP (solid shape): 304.04,63.98 304.55,63.98 304.55,64.48 304.99,64.48 305.12,64.36 305.12,62.96 304.87,62.71 304.1,62.71 303.68,62.29 302.17,62.29 302.04,62.41 302.05,62.48 302.05,62.66 302.07,62.71 302.07,62.76 302.07,63.3 302.43,63.66 302.43,64.02 302.58,64.17 303.03,64.17 303.34,64.48 304.04,64.48
+3.3V_M_TPM on BOTTOM (solid shape): 170.23,90.04 171.67,90.04 171.78,89.92 171.78,88.19 171.56,87.97 170.81,87.97 170.52,87.68 170.52,86.44 170.46,86.38 170.26,86.38 170.21,86.43 170.21,87.26 170.06,87.42 170.06,88.91 169.97,88.99 169.74,89.13 169.49,89.06 169.23,89.06 169.17,89.12 169.17,90.15 169.23,90.21 170.06,90.21
+3.3V_MMI_AUX on TOP (solid shape): 297.58,57.6 297.58,57.48 297.65,57.42 298.11,57.42 298.16,57.37 298.16,57.1 298.26,56.99 298.26,56.8 298.48,56.59 300.95,56.59 301.06,56.48 301.06,55.78 300.99,55.72 299.02,55.72 298.9,55.59 298.9,55.47 298.87,55.45 298.7,55.3 298.66,55.08 298.66,55.05 298.56,54.96 298.56,54.86 298.56,54.85 298.56,54.72 298.55,54.72 298.55,54.46 298.56,54.45 298.56,53.61 298.5,53.55 298.41,53.55 298.35,53.62 298.35,54.6 298.12,54.82 298.12,55.09 298.26,55.22 298.26,55.94 298.24,55.94 298.13,56.04 297.63,56.04 297.53,55.94 297.5,55.94 297.5,55.91 297.25,55.66 296.8,55.66 296.67,55.78 296.67,57.75 296.83,57.91 297.28,57.91
+3.3V_MMI_IN on TOP (solid shape): 295.85,57.69 295.85,56.04 295.72,55.91 294.04,55.91 293.88,56.07 293.21,56.07 293.13,56.15 293.13,57.65 293.27,57.79 295.74,57.79
+3.3V_MMI_IN on TOP (solid shape): 297.36,50.29 297.36,49.43 297.38,49.42 297.38,48.37 297.42,48.33 297.42,47.9 297.65,47.66 297.65,43.39 297.55,43.29 295.35,43.29 295.01,43.63 295.01,44.76 295.56,44.76 295.56,45.31 295.01,45.31 295.01,45.56 295.56,45.56 295.56,46.11 295.01,46.11 295.01,46.45 295.14,46.59 296.69,46.59 296.95,46.84 296.95,47.36 296.97,47.48 296.95,47.59 296.95,48.64 296.88,48.7 296.88,48.99 296.99,49.1 296.99,49.1 297.14,49.25 297.14,50.28 297.2,50.34 297.31,50.34
+3.3V_MMI_IN on IN2 (solid shape): outline of 151 points within 293.08,48.35 297.54,57.8
+3.3V_RUN on TOP (solid shape): 235.3,33.79 235.3,32.93 235.05,32.68 233.75,32.68 233.5,32.93 233.5,33.75 233.71,33.96 235.12,33.96
+3.3V_RUN on TOP (solid shape): 294.86,46.41 294.86,45.96 295.41,45.96 295.41,45.72 294.85,45.72 294.85,45.17 295.41,45.17 295.41,44.91 294.87,44.91 294.87,44.25 294.74,44.12 293.5,44.12 293.39,44.23 293.39,46.32 293.55,46.48 294.79,46.48
+3.3V_RUN on TOP (solid shape): 247.23,25.28 247.23,24.92 247.22,24.9 246.73,24.9 246.69,24.87 246.69,24.48 246.72,24.46 247.23,24.46 247.27,24.42 247.27,24.09 247.16,23.98 245.77,23.98 245.47,24.29 245.47,25.12 245.47,25.12 245.47,25.28 245.54,25.35 247.16,25.35
+3.3V_RUN on TOP (solid shape): 293.35,23.82 294.51,23.82 294.78,23.55 294.78,22.53 294.68,22.43 294.2,22.43 294.16,22.4 294.11,22.4 294.11,22.34 293.19,21.42 291.38,21.42 291.26,21.53 291.26,22.02 290.72,22.56 290.72,22.86 291.25,22.86 291.25,23.29 290.72,23.29 290.72,23.57 290.73,23.58 290.98,23.58 291.44,24.03 291.44,24.05 291.46,24.07 291.46,24.68 291.57,24.79 292.37,24.79
+3.3V_RUN on TOP (solid shape): 16.89,83.15 16.89,82.77 16.84,82.72 16.41,82.72 16.39,82.7 16.39,82.16 16.41,82.14 16.92,82.14 16.94,82.11 16.94,81.93 16.92,81.91 16.41,81.91 16.39,81.88 16.39,81.37 16.41,81.35 16.92,81.35 16.94,81.32 16.94,80.92 16.77,80.74 16.13,80.74 15.8,80.41 15.78,80.41 15.67,80.4 15.58,80.36 15.13,80.36 15.07,80.39 14.96,80.51 14.96,81.98 14.99,82.02 15.25,82.02 15.37,82.14 15.37,82.67 15.5,82.82 15.52,83.01 15.51,83.04 15.75,83.28 16.77,83.28
+3.3V_RUN on TOP (solid shape): outline of 148 points within 144.97,79.32 148.22,83.09
+3.3V_RUN on TOP (solid shape): outline of 198 points within 27.75,17.94 32.51,23.02
+3.3V_RUN on TOP (solid shape): outline of 369 points within 180.4,37.53 197.61,72.99
+3.3V_RUN on BOTTOM (solid shape): 224.1,40.03 224.1,39.09 224.11,39.09 224.11,38.17 223.91,37.98 222.98,37.98 222.89,38.07 222.89,40.04 223.01,40.16 223.97,40.16
+3.3V_RUN on BOTTOM (solid shape): 118.22,99.24 118.22,96.64 118.11,96.53 115.55,96.53 115.32,96.76 115.32,97.25 116.21,98.14 116.21,99.98 117.48,99.98
+3.3V_RUN on BOTTOM (solid shape): 157.14,77.81 157.14,75.19 157.42,74.91 157.42,73.96 158.1,73.28 158.19,73.28 158.21,73.25 158.93,73.25 159.05,73.13 159.05,72.58 158.99,72.52 157.37,72.52 157.2,72.69 156.95,72.69 156.38,73.26 156.38,74.18 156,74.56 156,75.11 155.26,75.85 155.26,76.69 155.32,76.75 156.16,76.75 156.58,77.17 156.58,77.73 156.77,77.92 157.03,77.92
+3.3V_RUN on BOTTOM (solid shape): 182.19,71.17 182.2,71.16 182.2,70.9 182.16,70.89 181.89,70.5 182.13,70.09 182.15,70.07 182.25,70.05 182.32,70.04 183.09,70.04 183.12,70.07 183.36,70.07 183.39,70.1 184.28,70.1 184.38,70 184.38,69.61 184.28,69.51 181.74,69.51 181.33,69.92 181.33,70.88 181.55,71.11 181.57,71.11 181.71,71.15 181.82,71.24 182.12,71.24
+3.3V_RUN on BOTTOM (solid shape): 149.32,99.76 149.32,99.47 149.31,99.46 149.29,99.32 149.31,99.17 149.32,99.16 149.32,98.77 149.59,98.5 150.11,98.5 150.12,98.49 150.43,98.81 151.11,98.81 151.3,98.63 151.3,98.33 151.21,98.24 150.68,98.24 150.42,97.99 150.42,97.44 150.43,97.44 150.55,97.32 150.55,97.24 150.63,97.24 150.72,97.15 150.91,97.15 151.3,96.76 151.3,96.25 151.13,96.08 150.72,96.08 150.55,96.25 150.55,96.75 150.55,96.75 150.55,96.86 150.44,96.86 150.28,97.01 149.13,97.01 149.04,97.1 149.04,97.7 148.91,98.22 148.46,97.92 148.43,97.85 148.36,97.82 148.11,97.82 148.03,97.9 148.03,99.83 148.2,100 149.08,100
+3.3V_RUN on BOTTOM (solid shape): outline of 215 points within 100.71,99.79 126.05,115.92
+3.3V_RUN on IN1 (solid shape): 191.33,38.25 191.33,37.11 191.18,36.96 188.88,36.96 188.56,37.28 188.56,37.68 188.59,37.68 188.59,37.63 188.6,37.58 188.62,37.53 188.64,37.48 188.67,37.44 188.71,37.4 188.75,37.37 188.8,37.35 188.85,37.33 188.9,37.32 188.95,37.32 189,37.33 189.05,37.35 189.1,37.37 189.14,37.4 189.18,37.44 189.21,37.48 189.23,37.53 189.25,37.58 189.26,37.63 189.26,37.68 189.25,37.73 189.23,37.78 189.21,37.83 189.18,37.87 189.14,37.91 189.1,37.94 189.05,37.96 189,37.98 188.95,37.98 188.9,37.98 188.85,37.98 188.8,37.96 188.75,37.94 188.71,37.91 188.67,37.87 188.64,37.83 188.62,37.78 188.6,37.73 188.59,37.68 188.56,37.68 188.56,38.79 188.2,39.15 188.2,40.01 188.57,40.38 189.21,40.38
+3.3V_RUN on IN2 (solid shape): outline of 352 points within 287.99,21.22 292.45,39.4
+3.3V_RUN on IN3 (solid shape): outline of 975 points within 27.96,17.84 45.66,44.93
+3.3V_RUN on VCC: 178.16,69.69 175.24,72.61 154.16,72.61 152.25,74.52 150.35,74.52 149.86,75 149.86,78.05 149.08,78.83 145.67,78.83 145.67,82.79 146.28,83.41 183.77,83.41 183.77,70.3 183.16,69.69
+3.3V_RUN on VCC: 233.66,33.37 228.83,38.19 199.16,38.19 198.27,37.31 46,37.31 44.09,35.4 40.56,35.4 31.63,44.33 31.63,65.65 32.39,66.41 32.39,73.9 42.93,84.44 42.93,92.19 53.45,102.71 55.23,102.71 56.01,103.49 56.01,108.96 56.75,109.7 69.83,109.7 70.47,110.33 130.96,110.33 134.26,107.03 149.86,107.03 149.86,104.47 149.5,104.11 147.94,104.11 146.54,105.5 136.04,105.5 131.96,101.42 131.96,98.77 66.7,98.77 66.57,98.65 56.15,98.65 55.68,99.01 55.38,98.5 48.26,91.39 48.26,71.07 46.63,69.44 43.33,69.44 36.07,62.18 36.07,46.98 38.12,44.93 240.14,44.93 249.79,54.58 251.57,54.58 263.53,66.54 263.53,91.41 277.48,91.41 280.4,94.33 298.96,94.33 298.96,80.13 301.84,77.25 303.48,77.25 303.53,77.2 303.53,59.38 296.55,52.4 296.55,37.94 288.27,37.94 287.91,38.3 287.91,57.9 292.99,62.98 292.99,84.66 291.19,86.45 286.03,86.45 284.86,85.29 284.86,79.09 277.39,79.09 271.27,72.97 271.27,61.54 262.05,52.31 261.26,52.31 260.61,51.66 260.61,50.87 259.46,49.73 259.46,41.98 258.47,40.99 253.35,40.99 251.19,43.15 248.56,43.15 238.78,33.37
+3.3V_RUN_AUDIO on TOP (solid shape): 291.99,25.85 291.99,25.07 291.84,24.92 291.5,24.92 291.33,24.75 291.33,24.12 290.92,23.71 290.67,23.71 290.67,23.7 290.59,23.7 290.59,23.55 290.58,23.54 290.58,22.42 290.81,22.19 290.81,21.48 290.55,21.23 290.55,20.3 290.49,20.21 290.38,20.23 289.95,20.66 289.95,23.88 290.46,24.39 290.46,25.89 290.55,25.98 291.85,25.98
+3.3V_RUN_AUDIO_DVDD on TOP (solid shape): 296.04,37.18 296.04,35.4 295.79,35.15 295.15,35.15 295.02,35.27 295.02,35.65 294.77,35.91 294.77,37.56 294.9,37.69 295.53,37.69
+3.3V_RUN_AUDIO_UZ5 on TOP (solid shape): 294.78,21.16 294.78,20.23 294.5,19.95 294.5,19.27 294.37,19.14 294.01,19.14 293.89,19.27 291.5,19.27 291.29,19.48 291.29,21.15 291.36,21.22 294.72,21.22
+3.3V_RUN_CARD on TOP (solid shape): 311.49,39.81 312.82,39.81 312.97,39.66 312.97,39.15 312.79,38.97 310.39,38.97 309.44,39.92 308.49,39.92 308.49,39.94 308.07,39.94 307.75,40.25 307.75,41.19 307.95,41.4 309.9,41.4
+3.3V_RUN_CARD on TOP (solid shape): 297.75,50.29 297.75,49.17 297.84,49.07 297.84,49.03 298.06,48.82 298.06,48.04 297.92,47.89 297.68,47.89 297.54,48.03 297.54,50.27 297.61,50.34 297.7,50.34
+3.3V_RUN_CARD on IN3 (solid shape): 309.71,41.92 309.71,40.67 309.45,40.41 308.82,40.41 307.84,41.39 307.84,41.99 307.95,42.1 309.53,42.1
+3.3V_RUN_CARD on IN3 (solid shape): 298.09,47.13 298.22,47 298.22,44.44 298.05,44.27 297.18,44.27 296.91,44.54 296.91,48.23 297.2,48.53 297.4,48.66 297.48,48.89 298.09,48.89
+3.3V_RUN_UZ3 on TOP (solid shape): 198.35,42.87 198.91,42.87 199.82,41.96 199.82,37.88 199.65,37.7 199.65,37.18 199.82,37 199.82,35.88 199.71,35.77 198.92,35.77 198.57,36.12 198.02,36.12 197.96,36.18 197.96,36.78 197.74,37 197.74,37.84 197.77,37.87 197.77,42.84 197.82,42.89 198.33,42.89
+3.3V_TBT on TOP (solid shape): 18.29,84.8 18.29,83.08 18.52,82.85 19.27,82.85 19.41,82.71 22.09,82.71 22.25,82.54 23.28,82.54 23.4,82.43 24.18,82.43 24.22,82.47 24.38,82.47 24.46,82.39 24.46,82.29 24.31,82.14 24.23,82.14 24.06,81.96 24.06,81.85 23.92,81.71 23.72,81.71 23.05,81.04 17.1,81.04 17.1,83.53 16.56,84.07 16.56,84.93 16.64,85.01 18.09,85.01
+3.3V_TBT on IN1 (solid shape): 26.96,85.65 26.96,84.96 26.58,84.58 25.63,84.58 25.54,84.48 25.51,84.5 25.03,84.27 25.37,83.87 25.45,83.85 25.48,83.77 25.48,83.34 25.45,83.26 25.37,83.24 25.03,82.9 25.37,82.57 25.45,82.55 25.48,82.47 25.48,81.96 24.39,80.87 22.99,80.87 22.52,81.34 22.52,82.35 23.15,82.99 23.15,84.13 23.27,84.25 24.41,84.25 24.57,84.4 24.57,85.08 24.64,85.15 26.27,85.15 26.39,85.27 26.39,85.65 26.52,85.78 26.84,85.78
+3.3V_TBT_LC on BOTTOM (solid shape): 34.42,80.59 34.11,80.28 33.2,80.28 33.2,81.76 33.66,81.76 33.89,81.98 33.89,83.48 33.91,83.51 34.42,83.51
+3.3V_TBT_S0 on TOP (solid shape): 19.9,86.02 19.9,85.62 19.67,85.4 19.67,85.24 19.46,85.03 18.56,85.03 18.41,85.18 17.58,85.18 17.25,85.51 17.25,86.03 17.35,86.11 17.45,86.2 19.72,86.2
+3.3V_TBT_S0 on BOTTOM (solid shape): 19.88,86.65 19.88,85.21 19.11,84.44 18.61,84.44 18.42,84.24 18.42,81.82 18.15,81.55 17.32,81.55 17.28,81.5 17.15,81.5 16.89,81.76 16.89,85.06 18.61,86.77 19.75,86.77
+3.3V_TBT_S0 on IN2 (solid shape): outline of 262 points within 18.7,84.93 30.84,91.5
+3.3V_TBT_SX on TOP (solid shape): 26.8,76.93 26.8,75.53 26.04,74.77 25.28,74.77 25.1,74.59 25.1,74.14 25.15,74.09 25.63,74.09 25.66,74.06 25.66,73.93 25.63,73.91 25.12,73.91 25.1,73.88 25.1,73.53 24.18,72.61 21.97,72.61 21.72,72.87 21.72,73.47 21.73,73.51 21.97,73.75 22.86,73.75 24.64,75.53 25.53,75.53 25.78,75.79 25.78,75.81 25.79,75.82 25.83,75.99 25.79,76.16 25.78,76.17 25.78,76.29 25.66,76.42 25.53,76.42 25.4,76.55 25.4,76.93 25.53,77.06 26.67,77.06
+3.3V_TP on TOP (solid shape): 247.94,27.27 247.94,25.97 248.19,25.73 248.88,25.73 249.02,25.58 249.02,24.03 248.84,23.85 247.56,23.85 247.37,24.03 247.37,24.58 246.82,24.58 246.82,24.76 247.38,24.76 247.38,25.35 247.26,25.47 247.26,26.7 247.31,26.75 247.31,27.32 247.35,27.36 247.86,27.36
+3.3V_VDD_PIC on TOP (solid shape): 26.55,74.14 26.55,73.75 26.77,73.53 26.77,73.37 26.93,73.37 28.2,72.1 28.2,70.83 28.7,70.33 28.97,70.33 29.19,70.25 29.4,70.33 31.24,70.33 31.36,70.45 33.18,70.45 33.53,70.1 33.53,69.44 33.28,69.18 32.01,69.18 31.93,69.26 31.93,69.72 31.9,69.74 31.47,69.74 31.45,69.72 31.45,69.21 31.4,69.16 30.89,69.16 30.36,69.69 28.45,69.69 28.14,70 28.13,70.01 28,70.22 27.8,70.35 27.79,70.35 27.56,70.58 27.56,71.29 27.56,71.3 27.59,71.44 27.56,71.59 27.56,71.6 27.56,71.72 27.31,71.98 26.16,71.98 25.28,72.87 25.28,73.5 25.25,73.53 25.25,73.73 25.28,73.75 25.78,73.75 25.81,73.78 25.81,74.24 25.78,74.26 25.28,74.26 25.25,74.29 25.25,74.49 25.28,74.52 26.16,74.52
+3.3V_VDD_PIC_PDA on TOP (solid shape): 32.26,68.93 32.26,68.29 32.13,68.17 32.13,67.27 32.07,67.17 31.96,67.19 31.75,67.31 31.5,67.31 31.42,67.32 31.38,67.4 31.38,68.03 30.99,68.42 30.99,68.93 31.12,69.06 31.44,69.06 31.44,69.06 32.13,69.06
+3.3V_WLAN on TOP (solid shape): 282.89,38.2 282.89,37.81 283.05,37.64 283.05,37.16 283.17,37.05 283.17,35.68 283.06,35.57 282.5,35.57 282.35,35.43 282.35,34.3 282.25,34.19 280.34,34.19 280.26,34.28 280.26,37.8 280.78,38.32 282.78,38.32
+3.3V_WLAN on TOP (solid shape): 281.86,54.29 281.86,53.75 282.15,53.46 283.35,53.46 283.47,53.34 283.47,52.91 283.47,52.1 283.42,52.05 282.56,52.05 282.34,52.17 282.11,52.05 279.84,52.05 279.3,52.6 279.07,52.6 278.93,52.74 278.93,54.27 279.1,54.45 281.7,54.45
+3.3V_WLAN on TOP (solid shape): 294.35,63.34 294.58,62.77 294.81,63.34 294.88,63.34 295.03,63.19 296.29,63.19 296.29,62.71 295.79,62.71 295.79,62.07 296.29,62.07 296.29,61.94 295.79,61.94 295.79,61.31 296.29,61.31 296.29,60.61 296.04,60.36 294.07,60.36 293.82,60.61 293.82,63.15 294.01,63.34
+3.3V_WLAN on BOTTOM (solid shape): 281.51,54.37 281.51,53.83 281.74,53.6 281.74,52.99 280.98,52.99 280.98,52.99 280.12,52.99 280.06,53.04 279.4,53.04 279.01,53.43 279.01,54.19 279.32,54.5 281.21,54.5 281.38,54.5
+3.3V_WLAN on BOTTOM (solid shape): 282.84,37.63 282.84,35.61 282.42,35.19 280.18,35.19 280.07,35.29 280.07,36.21 280.14,36.28 281.66,36.28 281.69,36.31 281.85,36.52 281.75,36.76 281.75,37.85 281.86,37.96 282.51,37.96
+3.3V_WLAN on IN1 (solid shape): outline of 288 points within 278.41,53.08 295.38,62.58
+3.3V_WLAN on IN2 (solid shape): outline of 1068 points within 278.13,35.38 290.78,57.05
+3.3V_WLAN_UZ2 on TOP (solid shape): 300.33,64.01 300.33,63.56 300.73,63.15 300.73,62.38 300.64,62.29 300.14,62.29 300.14,62.28 299.49,62.28 297.99,60.79 296.69,60.79 296.55,60.93 296.55,62.03 297.93,62.03 297.93,61.98 297.94,61.93 297.96,61.88 297.98,61.83 298.01,61.79 298.05,61.76 298.09,61.73 298.13,61.7 298.18,61.69 298.24,61.68 298.29,61.68 298.34,61.69 298.39,61.7 298.43,61.73 298.48,61.76 298.51,61.79 298.54,61.83 298.57,61.88 298.58,61.93 298.59,61.98 298.59,62.03 298.58,62.08 298.57,62.13 298.54,62.18 298.51,62.22 298.48,62.26 298.43,62.29 298.39,62.31 298.34,62.33 298.29,62.34 298.24,62.34 298.18,62.33 298.13,62.31 298.09,62.29 298.05,62.26 298.01,62.22 297.98,62.18 297.96,62.13 297.94,62.08 297.93,62.03 296.55,62.03 296.55,63.09 296.65,63.19 296.81,63.19 297.4,63.78 297.4,63.94 297.62,64.16 300.18,64.16
+3.3V_WWAN on TOP (solid shape): 280.7,76.88 280.68,76.59 280.9,76.39 281.1,76.19 283.76,76.19 285.57,74.38 285.57,70.83 285.42,70.68 285.12,70.68 281.87,73.93 280.76,73.93 280.56,74.13 279.46,74.13 277.95,75.65 277.95,76.91 278.04,77.01 280.57,77.01
+3.3V_WWAN on TOP (solid shape): 262.19,76.07 263.91,76.07 263.99,75.99 263.99,74.83 263.8,74.65 263.73,74.62 263.65,74.65 263.3,74.75 263.08,74.45 263.07,74.43 262.85,74.21 262.85,73.19 262.79,73.12 259.84,73.12 258.97,73.99 258.97,75.97 259.05,76.05 260.9,76.05 261.02,76.17 262.09,76.17
+3.3V_WWAN on BOTTOM (solid shape): 288.04,72.13 288.04,70.45 287.78,70.2 284.36,70.2 283.72,70.83 283.72,72.92 284.44,73.64 286.53,73.64
+3.3V_WWAN on BOTTOM (solid shape): 262.93,74.65 262.93,72.6 262.83,72.49 261.88,72.49 261.87,72.5 261.55,72.5 260.47,73.59 260.47,74.8 260.58,74.92 262.66,74.92
+3.3V_WWAN on BOTTOM (solid shape): 280.56,75.4 280.56,72.59 280.46,72.5 279.08,72.5 278.97,72.61 278.97,74.08 278.9,74.16 278.81,74.25 278.7,74.25 278.66,74.25 278.31,74.25 277.97,74.59 277.97,76.15 278.08,76.25 279.7,76.25
+3.3V_WWAN on IN2 (solid shape): outline of 164 points within 260.12,73.48 279.76,76.45
+3.3V_WWAN_UZ4 on TOP (solid shape): 290.1,77.65 290.1,77.2 290.14,77.16 290.14,75.15 290.14,75.15 290.14,74.02 289.18,73.06 289.18,71.49 288.17,70.48 286.46,70.48 286.26,70.68 286.26,74.2 287.35,75.29 287.35,76.15 287.53,76.33 287.53,76.33 288.19,76.99 288.19,77.69 288.32,77.82 289.93,77.82
+5V_ALW on TOP (solid shape): 16.27,58.84 16.27,57.67 15.89,57.29 13.1,57.29 12.87,57.52 12.87,58.75 13.17,59.06 16.06,59.06
+5V_ALW on TOP (solid shape): 296.77,67.32 296.77,65.92 296.57,65.73 294.88,65.73 294.66,65.94 294.66,67.51 294.73,67.57 296.51,67.57
+5V_ALW on TOP (solid shape): 286.99,82.61 286.99,79.28 286.93,79.21 286.16,79.21 285.88,79.5 283.19,79.5 283.09,79.6 283.09,82.9 283.21,83.03 286.58,83.03
+5V_ALW on TOP (solid shape): 24.32,48.04 29.21,48.04 29.34,47.91 29.34,47.34 28.89,46.89 28.64,46.89 28.32,46.58 28.07,46.58 27.69,46.2 24.13,46.2 23.12,47.21 21.85,47.21 21.59,46.96 20.32,46.96 20.13,47.15 20.13,48.23 20.26,48.35 20.8,48.35 21.2,48.33 21.6,48.35 22.29,48.35 22.42,48.48 23.88,48.48
+5V_ALW on TOP (solid shape): 294.34,73.63 294.34,72.84 294.03,72.54 294.03,72.21 293.85,72.03 293.52,72.03 292.85,71.36 292.82,71.33 292.8,71.3 292.72,71.23 292.72,71.11 292.49,70.88 292.49,69.64 292.6,69.53 293.58,69.53 293.62,69.49 293.62,69.23 293.54,69.15 293.28,69.15 293.19,69.19 293.09,69.21 292.63,69.21 292.58,69.15 292.25,69.15 292.16,69.06 292.12,69.06 291.87,68.82 291.23,68.82 291.23,71.77 291,72.01 290.37,72.01 290.09,72.29 290.09,73.41 290.21,73.54 290.22,73.54 290.52,73.83 294.13,73.83
+5V_ALW on TOP (solid shape): outline of 152 points within 172.39,108.8 180.26,116.53
+5V_ALW on TOP (solid shape): outline of 173 points within 21.27,28.23 28.64,35.91
+5V_ALW on BOTTOM (solid shape): 174.56,116.07 174.56,115.03 174.37,114.84 173.89,114.84 173.89,115.36 173.46,115.36 173.46,114.84 172.98,114.84 172.85,114.97 172.85,116.11 173.04,116.3 174.33,116.3
+5V_ALW on BOTTOM (solid shape): 40.45,61.88 40.45,59.85 40.32,59.72 39.82,59.72 39.82,60.29 38.99,60.29 38.99,59.78 38.61,59.78 38.61,60.29 37.78,60.29 37.78,59.91 37.66,59.78 36.51,59.78 36.32,59.98 36.32,61.69 36.58,61.94 40.39,61.94
+5V_ALW on BOTTOM (solid shape): 62.71,69.23 62.71,67.52 62.31,67.12 62.29,67.12 62.17,67.12 62.05,67.07 60.71,67.07 60.63,67.15 60.63,67.24 60.7,67.3 61.76,67.3 62.04,67.58 62.04,69.14 62.22,69.32 62.63,69.32
+5V_ALW on BOTTOM (solid shape): 191.22,108.59 191.22,106.63 190.46,105.87 188.86,105.87 188.69,106.04 188.69,106.96 188.86,107.13 189.62,107.13 189.72,107.23 189.75,107.23 189.75,107.26 189.77,107.28 189.77,107.64 190.31,107.64 190.31,108.07 189.77,108.07 189.77,108.62 189.94,108.79 191.02,108.79
+5V_ALW on BOTTOM (solid shape): 71.02,77.17 71.02,76.65 70.78,76.41 70.78,75.87 70.77,75.79 70.77,75.72 70.77,75.69 70.18,75.1 68.9,75.1 68.85,75.15 68.85,75.25 68.9,75.3 69.66,75.3 70.27,75.91 70.27,77.1 70.41,77.23 70.96,77.23
+5V_ALW on BOTTOM (solid shape): 26.58,30.44 26.73,30.4 26.89,30.44 26.9,30.45 28.01,30.45 28.35,30.1 28.35,29.51 28.36,29.5 28.36,27.66 28.21,27.52 27.52,27.52 27.18,27.18 26.37,27.18 26.24,27.3 26.24,30.27 26.42,30.45 26.57,30.45
+5V_ALW on BOTTOM (solid shape): 132.4,105.87 132.4,105.85 132.43,105.85 132.49,105.78 132.49,105.75 132.89,105.35 132.89,104.49 132.67,104.26 132.29,104.26 132.26,104.24 132.24,104.23 132.1,104.16 132.03,104.02 132.03,104 131.9,103.88 131.9,103.65 131.88,103.63 131.45,103.63 131.37,103.7 131.37,104.47 131.4,104.49 131.51,104.57 131.57,104.68 131.58,104.7 131.9,105.02 131.9,105.13 131.97,105.33 131.85,105.51 131.85,105.51 131.68,105.68 131.45,105.68 131.29,105.84 131.29,106.04 131.37,106.11 132.16,106.11
+5V_ALW on BOTTOM (solid shape): 15.92,60.1 16.12,59.95 16.37,59.98 16.44,59.99 16.5,59.95 16.63,59.84 16.81,59.81 16.88,59.8 16.92,59.74 17.35,59.52 17.54,59.96 17.55,60.06 17.63,60.1 18.23,60.1 18.29,60.04 18.29,57.56 18.17,57.44 18.15,57.44 18.06,57.42 17.97,57.38 17.96,57.37 17.86,57.37 17.86,57.45 17.88,57.47 17.98,57.96 17.48,57.98 17.4,57.94 17.33,57.98 16.88,58.01 16.81,57.57 16.82,57.49 16.76,57.42 16.72,57.4 16.68,57.37 16.53,57.37 16.32,57.45 16.11,57.37 13.4,57.37 13.08,57.69 13.08,59.72 13.46,60.1
+5V_ALW on BOTTOM (solid shape): outline of 286 points within 257.05,79.28 285.12,85.38
